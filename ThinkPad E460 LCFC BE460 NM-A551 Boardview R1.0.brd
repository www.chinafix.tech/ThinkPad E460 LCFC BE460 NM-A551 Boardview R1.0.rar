# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_FB: length 2.5
  BOTTOM w0.254: PU201.3 215.5,166.54 v4(215.66,166.37) 215.79,166.25 216.24,166.25 216.67,165.82 PC212.1
+3VALW_GS: length 37.6
  TOP w0.254: UGSEN1.14 179.64,105.4 179.44,105.2
  TOP w0.305: 181.73,105.79 181.67,105.85 UGSEN1.1
  TOP w0.381: QV13.5 QV13.2 184.54,106.74
  TOP w0.508: 181.73,105.79 182.31,105.79 183.08,105.02 v1(183.08,104.75) 184.54,106.21 184.54,106.74 ; CG2.1 175.66,111.17 174.03,109.55 QG1.1 ; 179.44,105.2 179.16,104.92 v4(177.54,104.92) 177.39,104.92 176.56,104.08 C8527.1 CC101.1 174.64,104.29 RG2.1 175.29,104.96 RC350.2 175.29,106.99 v1(174.36,106.99) 173.52,106.99 CG3.1 173.21,107.41 173.21,109.51 QG1.1 ; QG1.1 172.43,109.55 171.91,110.07 RG1.2
  IN2 w0.508: v1(183.08,104.75) 183.08,105.76 180.71,108.12 177.12,108.12 175.99,106.99 v1(174.36,106.99)
+3VALW_LAN: length 51.4
  TOP w0.305: v1(254.98,96.81) 254.98,96.57 254.84,96.42 UL1.29 ; UL1.15 257.85,91.44 258.07,91.22 v1(258.81,91.22) ; UL1.19 258.24,93.04 v1(258.27,93.02) ; UL1.5 253.64,89.2 v1(253.35,88.91) 253.24,89.02 UL1.4
  TOP w0.508: RL15.1 RL16.1 v1(283.7,84.87)
  IN1 w0.508: v1(283.7,84.87) 285.11,86.28 285.11,92.6 280.4,97.31 259.44,97.31 256.9,94.77
  BOTTOM w0.381: RL9.1 252.91,88.22 253.35,88.65 v1(253.35,88.91) CL3.1 252.79,89.62 251.92,90.48 RL4.2
  vias: v1(249.41,96.55) v1(250.17,96.55) v4(248.66,96.95)
+3VALW_LOGO: length 16.3
  TOP w0.114: JLCD.9 56.32,114.94 56.7,114.94 57.18,115.42 57.18,115.93 56.98,116.14 v1(56.98,116.2)
  BOTTOM w0.114: D1.3 60.66,123.6 61.42,123.6 62.66,122.37 62.66,121.32 61.84,120.5 v4(61.84,119.3) 61.84,119.17 60.96,118.29 59.95,118.29 R25.2 59.39,118.83 59.19,119.04 C181.1 58.53,119.04 57.28,117.79 57.28,117 57.39,116.88 C180.1 56.98,116.47 v1(56.98,116.2)
+3VALW_OUT: length 2.7
  BOTTOM w0.254: PU201.4 216.14,166.99 216.46,166.67 PR203.1
+3VALW_P: length 33.3
  IN3 w0.381: v1(216.36,151.92) 216.94,151.92 217.91,152.9 217.91,164.68 218.93,165.69 v1(220.15,165.69)
  IN3 w0.508: v1(218.66,166.92) 218.66,166.62 217.18,165.13 217.18,153.47 v1(216.36,152.66)
  BOTTOM w0.254: PR207.2 220.05,165.79 v1(220.15,165.69) ; PR203.2 218.41,166.67 v1(218.66,166.92)
  vias: v4(217.54,158.92)
+3VALW_PCH: length 59.2
  TOP w0.241: 113.11,129.89 CC530.1 ; CC530.1 112.77,130.22 ; CC530.1 113.11,130.55
  TOP w0.254: v2(107.19,128.66) 107.19,129.43 CC532.1 ; v2(109.67,128.74) 110.23,128.74 CC531.1
  TOP w0.508: RC298.2 132.25,140.49 v1(132.44,140.3) ; RC367.2 131.06,86.28 128.64,83.87 124.11,83.87 v1(107.71,67.46) ; RC93.2 RC92.2 107.08,145.41 106.62,144.95 RC375.2 ; RA27.1 v1(194.6,58.05) ; v1(137.14,144.33) 136.99,144.18 136.99,144.18 RC330.1 136.54,143.02 RC333.1 ; v1(104.12,144.3) 104.12,143.87 104.25,143.75 RC306.2 RC83.1 ; v1(90.91,145.12) 90.91,144.94 91.17,144.69 91.17,143.16 90.53,142.53 RC132.1 ; RC101.1 123.93,152.69 v1(124.44,153.19) ; RC95.2 v1(122.79,151.75) ; RC308.2 v1(132.44,141.76)
  BOTTOM w0.254: RPC15.2 88.52,130.71 v1(88.28,130.46) 88.53,130.21 RPC15.1 ; v2(112.62,130.07) 112.61,130.06 UC1.AG15 ; UC1.AK15 v2(113.81,129.41) ; v2(107.19,128.66) 107.56,128.29 UC1.T16 ; UC1.Y16 109.36,128.29 109.67,128.6 v2(109.67,128.74) 109.47,128.94 UC1.Y15 ; UC1.AD15 110.96,129.06 111.54,129.42 111.63,129.85 v2(111.45,130.15)
  vias: v1(75.3,113.67) v1(76.07,113.67) v1(84.07,81.71) v1(84.57,81.2) v1(86.92,145.42) v1(86.91,144.57) v1(87.45,144.92) v1(87.5,133.25) v1(87.61,130.46) v1(87.78,145.46) v1(96.64,149.53) v1(97.4,149.53) v1(104.88,144.3) v1(114.55,146.76) v1(124.44,154.21) v1(132.07,66.47) v1(132.96,66.47) v4(171.57,66.09)
+3VALW_PRIM: length 1.6
  TOP w0.254: v2(108.02,126.72) 107.96,126.65 CC97.1
  BOTTOM w0.254: UC1.AJ21 113.35,125.04 v2(113.06,125.32) ; UC1.V19 108.06,126.69 108.04,126.69 v2(108.02,126.72)
  vias: v1(87.38,128.45) v4(86.81,128.95)
+3VALW_RTCPRIM: length 33.5
  TOP w0.254: C200.1 114.14,127.68 ; C200.1 114.47,128.02 ; C200.1 114.11,128.05 CC58.1 113.56,127.63 ; C201.1 115.33,128.06 v2(114.82,127.55)
  IN1 w0.254: 119.88,127.4 119.59,127.11 115.26,127.11 v2(114.82,127.55) 115.26,127.99 119.22,127.99 119.26,128.02 119.88,128.02
  IN1 w0.508: 119.88,127.4 119.88,128.02 122.55,130.69 122.55,131.9 126.38,135.74 126.38,138.25 129.52,141.39 129.52,142.32 130.03,142.83 v1(130.16,142.83)
  BOTTOM w0.254: UC1.AK17 v2(114.82,127.55)
  vias: v4(135.04,141.98)
+3VBS: length 6.1
  TOP w0.508: v1(214.71,168.66) 214.08,168.66 213.7,168.28 v4(213.7,166) 213.7,163.37 PR202.1
+3VDMIC: length 3.2
  TOP w0.114: JLCD.5 57.44,113.8 57.44,114.05 58,114.61 58.86,114.61 v1(59.04,114.43)
  BOTTOM w0.114: v1(59.04,114.43) 59.35,114.75 R22.2
+3VL: length 452.7
  TOP w0.203: v1(179.19,118.92) 179.06,118.92 178.81,119.17 UE1.26 ; RPE5.2 184.25,138.35 v1(184.5,138.6) 184.75,138.34 RPE5.1 ; CE9.1 186.54,132.37 185.86,131.68 UE1.112 ; CE6.1 186.16,113.7 186.26,113.79 UE1.50 ; RPE3.4 180.82,110.33 v1(180.87,110.28) ; UE1.127 179.86,131.92 178.92,132.85 CE4.1 ; CE8.1 185.53,132.24 185.06,131.77 UE1.114 ; UE1.92 195.05,127.57 196.4,128.91 CE10.1 ; UE1.121 182.26,131.64 180.96,132.94 CE5.1
  TOP w0.254: PR10.1 v1(225.99,171.05)
  TOP w0.381: C53.1 294.65,42.32 v1(294.29,42.68)
  TOP w0.508: C53.1 296.58,42.93 297.43,43.79 U8.2 ; RE31.2 v1(195.43,135.29) ; v1(200.65,119.17) 200.29,119.54 LE1.1 ; RE39.2 198.08,125.13 v1(198.14,125.07) ; v1(226.21,156.41) 237.84,156.41 v4(240.73,159.3) 258.18,159.3 260.6,156.89 260.6,155.88 261.36,155.11 264.41,155.11 266.06,153.46 266.06,151.05 266.82,150.29 268.72,150.29 269.58,149.43 R71.1 ; v1(187.2,133.69) CE9.1 CE8.1 ; RE33.2 v1(189.47,135.29) ; v1(198.11,117.78) 197.81,117.78 197.58,118 RE3.2 ; RA30.2 v1(175.36,63.54) ; v1(97.52,140.24) 97.31,140.03 94.28,140.03 92.55,141.76 RC127.1 ; RE4.1 v1(173.59,123.73) ; v1(196.5,129.61) CE10.1 ; CE4.1 v1(178.24,133.69) ; CE5.1 v1(180.27,133.69) ; CE6.1 v1(187.05,112.12)
  IN1 w0.508: v1(294.29,42.68) 293.68,42.07 287.13,42.07 282.52,46.68 282.52,56.38 282.61,56.48 282.61,70.54 276.52,76.64 271.94,76.64 269.74,78.84 265.94,78.84 263.44,81.34 257.48,81.34 256.51,82.31 253.8,82.31 251.96,80.47 244.7,80.47 244.27,80.05 240.57,80.05 234.63,85.98 234.63,94.21 227.16,101.68 221.7,101.68 220.52,102.86 220.52,105.15 219.32,106.35 216.71,106.35 213.28,109.77 212.24,109.77 210.58,111.43 209.03,111.43 208.53,110.93 v1(208.53,110.66) 208.51,110.65 200.79,110.65 v1(199.64,111.81) ; v1(175.36,63.54) 175.61,63.8 199.73,87.92 211.69,87.92 v1(212.96,89.19)
  IN2 w0.508: 187.17,137.98 187.17,144.9 178.99,153.08 171.67,153.08 170.99,153.77 162.98,153.77 162.41,154.34 153.84,154.34 152.94,155.24 148.13,155.24 143.09,150.21 141.04,150.21 140.33,150.92 140.33,151.43 140.31,151.45 140.31,151.48 139.94,151.86 138.59,151.86 137.99,151.25 137.99,148.03 137.48,147.51 135.66,147.51 133.5,149.68 131.67,149.68 129.53,151.81 128.19,151.81 127.81,152.19 127.81,152.5 127.25,153.06 126.87,153.06 126.85,153.07 126.85,153.07 126.47,153.44 126.47,153.45 126.36,153.56 126.36,154.35 125.72,154.99 122.93,154.99 122.42,155.49 120.39,155.49 115.94,151.05 111.24,151.05 109.85,149.65 108.45,149.65 107.18,150.92 v1(99.56,150.92)
  IN3 w0.508: v1(97.52,140.24) 97.63,140.13 99.4,140.13 100.58,141.31 100.58,147.09 98.82,148.84 98.82,150.19 v1(99.56,150.92)
  BOTTOM w0.254: 218.57,168.94 223.88,168.94 225.61,170.67 225.61,170.67 v1(225.99,171.05)
  BOTTOM w0.508: v1(212.96,89.19) 212.45,89.69 212.45,92.74 211.69,93.5 211.69,100.29 209.37,102.61 209.37,107.66 208.53,108.5 v1(208.53,110.66) ; PR217.1 v1(219.45,160.7) ; PR216.1 v1(223.51,164.38)
  vias: v1(218.05,170.86) v1(218.05,170.23) v1(218.05,169.59)
+3VL_AVCC: length 5.6
  TOP w0.203: 194.44,120.37 UE1.74
  TOP w0.254: LE1.2 198.42,119.72 CE3.1 CE2.1 195.98,119.72 195.84,119.58 v3(195.55,119.58) 195.47,119.58 194.68,120.37 194.44,120.37
+3VLX: length 0.9
  TOP w0.508: PC203.2 v1(212.07,164.27)
  vias: v4(208.4,160.45)
+3VS: length 519.5
  TOP w0.203: RPE3.1 179.32,110.51 v1(179.56,110.27) 179.82,110.53 RPE3.2 ; v1(176.51,125.76) 176.51,125.64 176.98,125.17 UE1.11 ; RPE5.4 v1(183.25,138.59)
  TOP w0.254: RPC22.8 127.42,147.79 v1(127.5,147.87) 127.64,147.73 RC29.1 ; 265.06,119.03 U16.1 ; RPE5.3 183.75,138.09 v1(183.25,138.59) ; v1(243.69,83.6) 244.31,84.21 URE1.11 ; 268.47,124.76 267.96,124.76 267.56,124.36 U16.13 ; PR308.2 v1(185.05,173.29) ; v1(105.14,148.01) 105.49,148.37 QC1.2 ; U6.1 222.51,92.89 222.4,92.79 221.93,92.79 221.47,92.34 221.47,91.78 C35.1 ; v1(104.5,148.75) QC2.5 ; URE1.37 245.51,90.4 v1(245.45,90.46) ; U1.1 41.41,126.29 42.15,127.03 C1.1 ; U6.13 225.01,98.72 225.25,98.97 C34.1 ; v1(108.44,148.11) 108.08,148.11 107.83,148.37 QC1.5 ; C28.1 207.61,99.25 U5.13 ; C29.1 205,92.12 205,92.86 205.11,92.97 U5.1 ; QC2.2 v1(101.2,148.75)
  TOP w0.305: RE47.2 183.18,140.46 v1(183.18,141.3)
  TOP w0.381: RC409.1 101.64,147.49 101.2,147.94 v1(101.2,148.75) ; 174.19,115.08 173.73,115.54 173.73,116.53 174.16,116.96 RE41.1 ; v1(110.85,146.59) 110.86,146.58 RC67.1 ; RA28.1 CA12.1 ; 190.15,73.24 C52.1 ; v1(194.57,60.38) 194.62,60.33 CA1.1 194.62,58.81 RA25.1 ; v1(108.95,146.59) 109.14,146.4 109.34,146.4 RC70.1 ; JU3AC.15 v1(135.66,55.73) ; R106.1 278.16,112.68 v1(277.73,112.68) ; C51.1 124,157.27 C50.1 125.75,158.04 UTPM1.8
  TOP w0.508: R56.2 225.76,90.58 225.64,90.46 v1(224.42,90.46) R57.2 R54.2 R55.2 ; v1(243.98,93.07) RRE24.1 ; v1(65.12,121.85) 63.45,121.85 61.35,123.96 55.89,123.96 54.74,125.1 53.04,125.1 v1(52.44,124.51) ; v1(270.2,125.7) C189.1 269.49,125.14 269.11,124.76 268.47,124.76 ; v1(265.09,117.85) C184.1 266.01,118.09 265.06,119.03 ; RA18.1 190.99,49.93 190.84,50.08 190.84,51.11 191.01,51.29 CA12.1 192.11,51.29 v1(192.31,51.49) ; v1(208.64,97.31) 208.64,98.76 C28.1 ; RE9.2 198.06,114.52 v1(198.29,114.75) ; R41.2 203.93,91.09 203.42,91.6 203.42,93.08 v1(203.69,93.35) ; R41.2 205.14,91.98 C29.1 ; R41.2 205.14,90.53 205.34,90.33 206.81,90.33 R40.2 R43.2 208.11,90.28 210.09,90.28 R42.2 ; v1(122.78,156.21) 123.79,157.22 C51.1 123.94,157.93 123.18,158.69 123.18,159.63 R268.2 ; RC52.2 131.49,134.62 v1(132.07,134.03) ; R52.2 R50.2 219.92,100.67 v1(219.52,101.06) ; R246.2 v1(267.71,127.43) ; CD58.1 CD57.1 167.24,152.36 166.88,152 166.07,152 165.79,152.29 v1(165.79,152.83) ; C34.1 225.78,99.47 v1(225.93,99.61) ; v1(268.95,116.25) 268.98,116.28 R248.2 ; v1(177.91,61.83) 177.91,62.39 178.16,62.64 178.75,62.64 178.71,62.68 RA4.2 178.71,63.29 179.31,63.89 v1(180.14,63.89) ; v1(66.76,120.4) 66.05,119.69 62.49,119.69 60.54,117.74 v1(60.54,116.8) ; v1(244.21,81.06) 244.33,81.06 244.58,81.31 RRE21.1 245.47,81.74 245.52,81.69 RRE22.1 245.52,80.6 245.8,80.32 247.02,80.32 247.38,80.68 RRE23.1 ; v1(53.7,129.24) 51.24,129.24 50.45,130.03 50.45,130.36 49.79,131.02 49.46,131.02 49.44,131.05 45.6,131.05 C1.1 ; R244.2 v1(268.6,127.43) ; v1(177.88,61.09) 178.58,61.09 RA3.1 179.15,60.97 v1(179.56,60.56) ; RC110.1 141.38,137.9 v1(140.57,138.72) ; R249.2 v1(266.82,127.43) ; v1(220.69,92.81) 220.79,92.72 220.79,91.6 221.04,91.35 C35.1 ; R111.1 v1(165.28,71.04) ; R51.2 v1(224.36,101.05) ; v1(265.93,127.43) R245.2 R250.2 ; R3.2 v1(46.57,122.05) ; R36.2 v1(203.82,101.12) ; RC287.1 RC277.1 102.47,144.23 v1(102.53,144.29) ; v1(143.95,58.27) 143.52,58.71 R60.1 ; C52.1 R70.1 ; R35.2 v1(204.83,101.12) ; v1(87.75,135.27) 87.75,135.81 87.5,136.06 87.5,137.18 88.01,137.7 88.62,137.7 89.13,138.21 v1(89.13,138.37) 89.41,138.08 RC88.1 ; v1(205.85,101.12) R39.2 R38.2 ; R251.2 v1(267.96,116.25) ; v1(174.38,107.88) 174.56,107.71 RC347.2 ; R49.2 222.59,100.97 v1(222.52,101.04) ; RE8.2 174.06,115.08 173.6,114.63 v1(173.6,114.24) ; RC106.2 110.14,149.64 RC107.2 109.66,150.1 v1(109.4,150.35) ; RC388.1 100.81,143.73 RC2.1 RC1.1 101.58,144.13 v1(101.75,144.29) ; R37.2 v1(202.8,101.12) ; v1(266.9,116.25) R247.2 ; R252.2 v1(271.14,116.25) ; v1(127.16,151.49) 127.69,150.96 RC165.1 ; R53.2 v1(223.48,101.05)
  IN1 w0.508: v1(214.61,131.48) v1(213.85,131.48) 213.21,131.48 210.81,129.08 203.95,129.08 202.15,130.88 194.79,130.88 194.05,131.62 191.08,131.62 190.44,130.98 179.94,130.98 179.43,131.49 ; v1(176.51,125.76) 176.51,125.89 178.16,127.54 178.16,130.22 179.43,131.49 ; v1(143.95,58.27) v1(170.3,58.27) ; 179.43,131.49 178.94,131.99 178.94,135.33 182.2,138.59 v1(183.25,138.59)
  IN2 w0.254: v1(58.74,63.72) 58.74,56.86 63.99,51.61 74.16,51.61 80.51,57.96 v1(103.62,57.96)
  IN2 w0.508: v1(173.6,114.24) 173.6,108.4 174.12,107.88 v1(174.38,107.88) 175.65,107.88 178.03,110.27 v1(179.56,110.27)
  IN3 w0.254: v1(103.62,57.96) 104.26,58.59 120.13,58.59 122.18,56.55 133.51,56.55 134.33,55.73 v1(135.66,55.73)
  IN3 w0.381: v1(143.95,58.27) 143.73,58.49 137.23,58.49 135.66,56.92 v1(135.66,55.73)
  IN3 w0.508: v1(53.7,129.24) 53.7,126.27 52.44,125.01 v1(52.44,124.51) 50.41,124.51 47.96,122.05 v1(46.57,122.05) ; v1(173.6,114.24) 174.24,114.24 175.43,115.44 175.43,119.44 175.11,119.76 175.11,120.96 175.81,121.66 175.81,125.06 v1(176.51,125.76) ; v1(192.31,51.49) 191.64,52.17 191.64,54.4 193.89,56.65 193.89,58.99 194.57,59.67 v1(194.57,60.38)
  BOTTOM w0.254: v1(189.73,156.13) 187.7,156.13 187.44,156.38 187.44,158.32 184.19,161.57 184.19,166.37 185.05,167.22 v1(185.05,173.29) ; v1(148.07,152.47) 148.56,151.99 148.99,151.99 149.15,152.15 JDIMM2.199 ; RPC26.7 88.39,134.03 88.26,134.16 88.26,134.51 88.27,134.53 RPC26.8 ; v1(130.65,154.68) 131.5,155.53 131.5,156.43 137.68,162.61 145.06,162.61 145.61,163.16 145.61,164.21 146.17,164.77 146.17,165.17 PR704.2 ; PR406.2 59.37,63.1 v1(58.74,63.72)
  BOTTOM w0.305: JDIMM1.199 163.55,152.15 165.11,152.15 v1(165.79,152.83) ; v1(183.25,138.59) 182.59,139.25 182.59,140.71 v1(183.18,141.3)
  BOTTOM w0.381: v1(67.6,133.15) 67.04,132.6 UV4.5 ; v1(66.76,120.4) 65.94,119.58 65.94,118.68 65.47,118.21 R17.1
  BOTTOM w0.508: v1(122.78,156.21) 123.08,156.51 123.08,159.41 125.39,161.72 RC408.1 ; v1(208.52,120.12) CC22.1 207.74,120.11 USROM1.8 ; v1(139.79,150.57) 140.3,150.06 140.3,148.67 141.17,147.8 141.17,140.56 140.57,139.96 v1(140.57,138.72) ; v1(132.07,134.03) 134.68,136.64 134.68,145.52 133.77,146.43 133.77,147.37 v1(133.8,147.39) ; v1(60.54,116.8) 60.54,116.24 59.99,115.7 R22.1 ; v1(89.13,138.37) 89.13,138.27 88.77,137.91 RC108.1 ; v1(183.89,67.86) 168.52,67.86 165.35,71.04 v1(165.28,71.04) ; v1(251.94,85.21) RRE25.2 ; v1(245.45,90.46) 245.45,90.18 CRE24.1 ; v1(87.75,135.27) 87.75,135.05 88.27,134.53
  vias: v1(65.64,122.61) v1(65.72,121.64) v1(66.12,122.13) v1(77.21,159.36) v1(77.86,159.34) v1(78.49,159.34) v1(79.13,159.34) v1(110.98,153.32) v1(112,153.32) v1(124.68,148) v1(127.16,150.48) v1(174.12,57.39) v1(174.61,57.84) v1(175.06,58.33) v1(175.55,58.81) v1(187.29,71.39) v1(187.78,71.88) v1(188.23,72.33) v1(188.7,72.8) v1(189.21,73.31) v1(190.26,155.49) v1(190.49,154.86) v1(190.62,156.13) v1(191,155.49) v1(191.25,154.86) v1(191.38,154.1) v1(191.76,155.37) v1(191.89,154.61) v1(213.85,130.84) v1(213.85,130.21) v1(214.61,130.84) v1(214.61,130.21) v1(215.37,131.48) v1(215.37,130.84) v1(215.37,130.21) v1(216.14,131.48) v1(216.14,130.84) v1(216.14,130.21) v1(216.9,131.48) v1(216.9,130.84) v1(236.85,75.99) v1(237.09,75.34) v1(237.61,75.99) v1(237.6,74.71) v1(237.98,75.34) v1(238.49,74.71) v1(238.63,75.61) v1(241.8,92.5) v1(242.18,91.99) v1(242.31,93.01) v1(242.55,90.46) v1(242.69,92.5) v1(242.94,80.69) v1(243.07,91.99) v1(243.19,90.84) v1(243.19,90.2) v1(243.58,81.07) v1(246.62,145.57) v1(246.62,144.81) v1(246.63,144.06) v1(246.64,143.42) v1(247.38,145.57) v1(247.38,144.81) v1(247.39,144.06) v1(247.4,143.42) v1(248.14,145.57) v1(248.14,144.81) v1(248.15,144.06) v1(248.15,143.43) v1(252.85,153.46) v1(252.84,152.81) v1(252.84,139.81) v1(252.84,139.07) v1(253.58,139.78) v1(253.58,139.15) v4(192.25,152.5)
+3VS_CMOS: length 15.7
  TOP w0.254: v4(55.54,112.67) 55.62,112.67 56.14,113.19 v1(56.55,113.19) 56.55,113.47 JLCD.6
  BOTTOM w0.508: v1(56.55,113.19) 56.87,113.19 58.54,114.85 58.54,115.49 C176.1 58.63,115.75 58.63,116.72 59.34,117.44 60.89,117.44 C177.1 62.35,117.41 C11.1 62.41,117.56 R17.2 64.81,117.61 64.33,118.08 64.33,118.49 U4.1
+3VS_DP: length 16
  TOP w0.114: v4(271.1,146.46) 271,146.46 v1(270.62,146.84)
  TOP w0.254: v1(256.85,147.53) 257.07,147.31 UM1.1 ; UM1.36 v1(265.61,147.31) ; UM1.32 265.51,145.31 265.61,145.41 v1(265.61,145.47) ; v1(256.84,144.62) 257.03,144.81 UM1.6 ; UM1.12 257.67,141.23 ; UM1.25 265.22,141.81 v1(265.56,141.46)
  TOP w0.381: RM20.1 270.19,146.23 270.62,146.67 v1(270.62,146.84) 270.36,147.1 RM28.1 ; RM22.1 v1(253.74,144.19) ; RM34.1 v1(253.74,141.52)
  TOP w0.508: RM21.1 v1(254.24,148.5) ; RM23.1 262.08,154.01 v1(262.06,153.98) ; 257.67,141.23 257.46,141.02 CM9.1 CM10.1 ; RM32.1 257.88,151.13 257.55,150.8 v1(257.55,149.27)
  vias: v1(256.38,138.16) v1(256.76,139.35) v1(256.77,138.72)
+3VS_DVDD: length 10.8
  TOP w0.203: CA14.1 182.4,61.93 v3(183.22,61.93) 183.38,61.77 183.38,61.31 183.93,60.76 185.27,60.76 186.03,60.01 UA1.18
  TOP w0.508: CA14.1 182.35,62.16 183.12,62.92 183.12,63.33 182.39,64.05 181.48,64.05 180.41,62.99 RA4.1
+3VS_FP: length 8.9
  TOP w0.508: R70.2 188.25,75.19 v4(187.76,75.67) 186.94,76.5 JFPB.6
+3VS_LS:
  vias: v4(214.75,134.54)
+3VS_VDDIO: length 6.3
  TOP w0.203: CA42.1 190.51,57.66 UA1.7
  TOP w0.381: CA42.1 190.93,57.75 191.37,57.31 192.87,57.31 v1(192.95,57.39) RA27.2 RA25.2
+3VS_VDDO: length 34.2
  TOP w0.203: UA1.2 189.94,55.66 190.19,55.41 190.19,54.18 190.79,53.58 191.07,53.58 191.57,53.07 RA28.2 191.86,53.07 192.24,52.69 v1(192.31,52.69)
  BOTTOM w0.254: v1(192.31,52.69) 195.88,56.26 195.88,67.58 194.59,68.87 v4(186.68,68.87) 183.7,68.87 RA29.1
+3VS_VGA: length 239.7
  TOP w0.254: v1(125.2,171.99) 124.33,171.12 122.41,171.12 v4(119.11,167.81) 113.15,167.81 110.48,165.15 110.48,164.57 110.93,164.13 111.88,164.13 112.26,163.75 v1(112.26,162.73)
  TOP w0.381: RV72.1 61.34,169.72 61.34,169.11 v1(61.35,169.09) 61.31,169.05 RV73.1 ; RV50.1 86.01,139.28 87.23,140.49 88.25,140.49 88.53,140.77 RV52.1 ; CV10.1 60.66,150.58 v2(59.92,149.84) ; RV61.1 RV76.1 44.23,176 43.19,174.96 43.16,174.96 42.45,174.25 v1(42.45,174.05)
  TOP w0.508: v1(49.46,168.64) 49.44,168.61 49.44,166.28 52,163.71 54.97,163.71 v1(55.76,162.92) 55.88,162.92 58.67,165.71 v1(58.67,165.98) ; v1(71.36,151.16) 70.34,150.15 70.34,148.24 ; v1(75.04,148.24) 70.34,148.24 ; 70.34,148.24 69.51,147.42 69.51,143.1 67.04,140.62 v1(67.04,139.03) ; RV50.1 85.17,139.63 v1(84.82,139.99)
  IN1 w0.508: v1(77.45,154.96) 77.45,154.7 79.4,152.74 83.01,152.74 84.51,151.24 v1(84.51,151.24) 84.96,151.68 84.96,153.72 84.21,154.46 v1(84.18,154.46) ; v1(21.09,167.99) 21.09,168.09 20.45,168.72 18.57,168.72 v1(18.36,168.93) 17.76,169.53 v1(17.76,171.25) 18.24,171.74 19.41,171.74 19.9,171.25 24.42,171.25 27.82,174.66 28.15,174.66 v1(28.18,174.63) ; v1(55.76,162.92) 55.76,162.97 56.15,163.36 63.81,163.36 65.59,161.58 65.59,160.74
  IN2 w0.254: v1(112.26,162.73) 112.26,162.23 111.75,161.72 111.75,161.46 109.47,159.18 105.71,159.18 103.04,156.51 97.95,156.51 97.69,156.24 92.85,156.24 91.43,154.82 88.38,154.82 87.79,154.23 84.42,154.23 v1(84.18,154.46)
  IN2 w0.508: v1(84.51,151.24) 83.88,151.24 82.67,150.03 76.83,150.03 v1(75.04,148.24)
  IN3 w0.508: v1(28.18,174.63) 28.71,174.63 32.42,170.92 36.68,170.92 40.05,174.29 42.21,174.29 v1(42.45,174.05) ; v1(84.51,151.24) 84.51,140.29 v1(84.82,139.99) ; v1(46.08,168.92) 46.21,168.92 47.1,168.03 48.85,168.03 v1(49.46,168.64)
  BOTTOM w0.254: CV149.1 20.76,169 20.76,170.09 21.09,170.41 UV9.1 ; RV43.1 67.03,139.02 v1(67.04,139.03) ; v1(125.2,171.99) 124.9,172.3 PR612.1 ; PR604.2 111.64,166.55 110.61,165.53 110.61,164.51 110.99,164.13 111.75,164.13 112.26,163.62 v1(112.26,162.73)
  BOTTOM w0.305: QV2.2 85.19,151.54 84.89,151.24 v1(84.51,151.24) ; QV2.5 85.19,154.24 84.97,154.46 v1(84.18,154.46)
  BOTTOM w0.381: v1(28.18,174.63) 28.15,174.61 RV95.2 ; UV3.AA18 v2(58.77,149.17) 59.2,149.6 UV3.AB18 ; RV120.2 76.27,157.5 RV119.2 76.77,156.63 77.53,157.39 RV138.2 77.96,157.33 77.96,155.48 v1(77.45,154.96) 76.93,154.96 76.28,155.61 RV118.2 ; RV115.1 75.5,148.7 v1(75.04,148.24) 75.56,147.72 RV80.1 ; UV3.AA17 v2(58.77,150.17) ; v2(59.92,149.84) 59.34,150.41 UV3.AB17 ; RV111.1 69.65,162.82 67.62,160.79 v1(67.62,160.57) ; v1(49.46,168.64) 49.41,168.64 49.13,168.36 RV63.1
  BOTTOM w0.508: v1(61.35,169.09) 61.35,168.9 61.57,168.68 RV71.1 RV70.1 59.79,167.57 59.09,166.86 59.09,166.41 v1(58.67,165.98) ; v1(17.76,171.25) 18.13,171.62 RV92.1 ; RV91.1 v1(18.36,168.93) ; v1(42.45,174.05) 42.43,174.03 42.43,173.51 42.86,173.08 42.86,171.58 44.13,170.31 45.12,170.31 46.08,169.35 v1(46.08,168.92) 46.46,168.54 RV64.1 RV65.1 RV66.1 ; v1(21.09,167.99) CV149.1
  vias: v1(66.92,160.57) v1(66.92,159.94) v1(67.68,159.94)
+5V_ALW:
  vias: v4(139.24,63.41)
+5V_PWRGD: length 3.2
  TOP w0.254: v1(203.65,171.29) 204.11,171.29 PR211.1 204.32,172.72 v4(204.03,173.01)
  BOTTOM w0.254: PU202.2 203.49,171.46 v1(203.65,171.29)
+5V_VCC: length 6.1
  BOTTOM w0.254: PU202.5 203.48,172.81 203.7,173.03 203.7,173.52 204.14,173.95 PC218.2 v4(208.2,173.95)
+5V_VIN:
  vias: v1(197.83,173.28) v1(198.47,173.28) v1(199.11,173.28) v4(197.99,175.56)
+5VALW: length 585.4
  TOP w0.203: U11.4 v1(218.42,137.46)
  TOP w0.254: v1(134.6,69.02) 135.08,69.5 U14.4 ; U14.7 v1(134.53,67.7) ; CV175.1 59.89,172.62 59.89,173.3 UV12.4
  TOP w0.508: v1(154.13,168.83) 153.88,169.08 152.01,169.08 151.5,168.58 151.5,167.58 v4(151.26,167.34) 149.64,165.72 149.61,165.72 R9448.1 148.2,164.31 v1(148.2,162.66) ; PR602.2 109.9,171.83 110.46,171.27 110.46,170.73 109.95,170.22 PR601.2 109.84,169.68 109.84,165.54 v4(108.48,164.18) 106.67,162.38 106.67,159.18 106.14,158.64 v1(106.04,158.64) ; R156.1 181.68,144.62 181.22,145.08 v1(180,145.08) ; v1(69.17,57.22) 69.17,55.48 72.04,52.61 v1(73.01,52.61) 74.73,52.61 v4(76.32,51.02) 78.89,48.46 83.66,48.46 84.08,48.88 v1(84.08,49.11) ; CV175.1 59.89,172.08 v1(59.6,171.79) ; RV134.1 74.45,158.35 76.05,156.75 80.52,156.75 v1(82.03,155.24) ; RE2.2 v1(177.22,111.21) ; v1(272.79,129.83) R9450.1 ; D15.5 v1(275.65,119.19) ; PR306.1 v1(183.81,175.23)
  IN1 w0.508: v1(59.6,171.79) 59.6,172 60.1,172.51 61.7,172.51 62.21,172 v1(62.21,171.74) ; v1(38.11,125.38) 35.57,125.38 34.54,126.41 31.87,126.41 30.35,127.94 14.47,127.94 13.07,129.33 13.07,131.87 9.55,135.4 9.55,157.3 12.57,160.32 12.57,161.84 13.84,163.11 14.98,163.11 17.39,165.53 17.39,168.19 v1(17.65,168.45) ; v1(64.45,68.31) 62.68,68.31 59.56,71.42 59.56,80.68 60.18,81.3 60.18,83.7 66.39,89.91 66.39,95.45 67.58,96.64 70.76,96.64 72.61,98.5 76.25,98.5 v1(77.07,99.32) ; v1(272.79,129.83) 275.24,127.37 v1(275.24,120.78) ; v1(114.42,49.2) 105.4,49.2 97.02,57.58 85.21,57.58 83.56,55.93 83.56,52.75 84.57,51.74 84.57,50.59 84.08,50.1 v1(84.08,49.11)
  IN2 w0.508: 82.03,153.72 v1(82.03,155.24) ; 82.03,153.72 83.17,152.58 84.2,152.58 85.33,153.72 88,153.72 88.59,154.31 91.64,154.31 93.06,155.73 97.9,155.73 98.16,156 103.4,156 v1(106.04,158.64) 108.08,158.64 109.72,157 113.26,157 117.19,160.94 126.23,160.94 126.88,161.59 130.29,161.59 131.69,160.19 139.31,160.19 141.08,161.96 147.3,161.96 148,162.66 v1(148.2,162.66) 149.67,162.66 150.81,161.52 185.46,161.52 189.1,157.88 v1(189.1,157.65) ; 82.03,153.72 78.86,153.72 78.66,153.51 75.89,153.51 75.56,153.84 74.03,153.84 72,155.88 69.84,155.88 66.29,159.43 66.29,166.16 66.79,166.67 66.79,171.37 65.52,172.64 62.72,172.64 62.21,172.13 v1(62.21,171.74) ; v1(64.45,68.31) 65.08,68.31 67.3,66.09 67.3,57.73 68.08,56.96 68.91,56.96 v1(69.17,57.22) ; v1(59.6,171.79) 59.17,171.37 59.17,168.19 60.06,167.31 60.06,164.89 59.49,164.32 53,164.32 51.25,166.07 51.25,169.41 50.41,170.25 47.54,170.25 44.67,173.12 42.46,173.12 41.83,173.76 40.18,173.76 38.04,171.62 29.46,171.62 28.92,172.16 22.92,172.16 19.06,168.3 17.79,168.3 v1(17.65,168.45)
  IN3 w0.508: v1(183.81,175.23) 183.81,169.29 184.27,168.83 184.27,162.71 189.1,157.88 v1(189.1,157.65)
  BOTTOM w0.229: PU401.9 67.91,57.16 ; PU701.18 151.72,170.76
  BOTTOM w0.254: PU404.4 76,99.32 v1(77.07,99.32) ; CV164.1 62.41,172.99 62.15,173.26 UV11.4 ; PR402.1 v1(73.01,52.61) ; 67.91,57.16 69.11,57.16 v1(69.17,57.22) ; 151.72,170.76 153.25,170.76 PC705.2 ; PU402.4 64.45,69.22 PC444.1 64.29,68.46 v1(64.45,68.31)
  BOTTOM w0.508: CV164.1 62.41,172.32 62.21,172.12 v1(62.21,171.74) ; v1(77.07,99.32) PC463.1 ; RL22.1 243.44,100.11 242.82,99.49 241.93,99.49 241.42,100 237.23,100 235.12,102.1 217.49,102.1 214.7,99.31 214.7,88.9 213.73,87.93 200.65,87.93 198.24,90.34 v1(198.24,91.41) ; RV143.1 38.72,125.81 38.28,125.38 v1(38.11,125.38) ; 195.06,158.12 194.62,157.67 193.9,157.67 193.41,158.16 189.6,158.16 v1(189.1,157.65) ; PC705.2 154.13,169.88 PR706.1 v1(154.13,168.83)
  BOTTOM w1.27: 199.62,154.67 198.52,154.67 195.06,158.12 195.06,165.25 193.99,166.33
  vias: v1(138.23,69.22) v1(138.87,69.22) v1(139.53,69.2) v1(140.19,69.17) v1(140.88,69.15) v1(200.62,153.62) v1(200.67,154.76) v1(200.98,154.21) v1(201.3,154.76) v1(201.25,153.62) v1(201.62,154.21) v1(201.94,154.76) v1(201.89,153.62) v1(202.26,154.21) v1(202.53,153.62) v1(202.58,154.76) v1(202.9,154.21) v1(203.22,154.75) v1(203.17,153.61) v1(203.54,154.2) v1(203.81,153.61) v1(203.86,154.75) v1(204.18,154.2) v1(220.34,138.1) v1(220.34,137.46) v1(220.34,136.7) v1(221.1,138.1) v1(221.1,137.46) v1(221.1,136.7) v1(221.48,138.6) v1(221.86,138.1) v1(221.86,137.46) v1(221.86,136.7) v1(274.53,120.5) v1(274.53,119.84) v1(275.22,120.12) v1(275.91,120.9) v1(279.21,25.13) v1(279.29,24.5) v1(279.85,25.13) v1(279.93,24.5)
+5VALW_OUT: length 1.8
  BOTTOM w0.203: PR213.1 204.29,173.02 203.63,172.36 PU202.4
+5VALW_P: length 21.4
  IN3 w0.381: v1(206.03,172.14) 206.64,171.52 206.64,161.68 207.18,161.14 207.18,156.5 206.56,155.88 v1(203.79,155.88)
  BOTTOM w0.254: v1(206.03,172.14) PR215.2 205.27,172.14 205.27,172.99 PR213.2
  vias: v1(199.89,160.1) v1(200.23,159.54) v1(200.56,160.1) v1(201.88,159.02) v1(201.91,158.39) v1(201.92,157.74) v1(202.55,159.02) v1(202.58,158.39) v1(202.6,157.74) v4(199.89,157.91)
+5VBS: length 5.8
  TOP w0.508: PR212.1 202.13,168.65 202.13,171.96 v4(202.31,172.14) 203.08,172.91 v1(203.08,173.89)
+5VFB: length 1.6
  BOTTOM w0.254: PC229.1 204.15,171.91 PU202.3
+5VLP: length 81.1
  TOP w0.508: R157.1 182.26,142.67 185.34,145.74 v4(185.34,155.57) 185.34,156.23 187.93,158.82 189.2,158.82 190.62,157.4 v1(197.6,157.4) ; PC8.1 v1(221.29,169.63)
  IN1 w0.508: v1(221.29,169.63) 221.29,173.97 219.7,175.56 v1(201.8,175.56) 200.78,174.54 200.78,173.91 199.51,172.64 197.86,172.64 195.32,170.1 195.32,158.8 196.72,157.4 v1(197.6,157.4)
  BOTTOM w0.254: PC225.1 202.55,175.17 202.21,174.83 PU202.7
  BOTTOM w0.508: PC225.1 202.01,175.35 v1(201.8,175.56)
+5VLX: length 1.2
  TOP w0.508: PC217.2 200.96,169.42 v1(201.2,169.66)
  vias: v4(205.15,169.46)
+5VS: length 580.1
  TOP w0.508: RE6.2 RE5.2 198.45,126.88 v1(198.49,126.92) ; v1(128.01,57.07) 127.83,57.25 127.83,59.28 127.29,59.82 v1(127.29,67.89) ; 223.51,132.51 224.27,133.27 224.27,140.13 223.7,140.7 199.06,140.7 194.69,145.08 191.25,145.08 188.33,148 v4(188.33,156) v1(188.33,157.53) ; R59.1 142.63,60.88 142.73,60.78 142.73,57.56 143.49,56.8 v1(143.49,55.79) ; R68.1 v1(55.87,50.21) ; v1(145.08,160.37) 145.43,160.37 147.9,157.91 R9446.1 ; Q4.2 v1(275.3,109.55)
  IN1 w0.508: v1(220.2,131.48) 220.2,130.72 219.3,129.81 216.91,129.81 214.78,127.68 203.37,127.68 202.53,128.52 199.26,128.52 198.49,127.76 v1(198.49,126.92)
  IN1 w0.762: 152.69,56.37 148.14,56.37 147.32,55.55 143.73,55.55 v1(143.49,55.79) 143.49,56.55 141.35,58.69 134.21,58.69 132.57,57.06 128.02,57.06 v1(128.01,57.07)
  IN2 w0.508: v1(62.97,171.89) 63.09,172 65.02,172 66.16,170.86 66.16,169.72 65.02,168.58 65.02,166.42 65.52,165.91 65.52,159.18 69.52,155.18 71.8,155.18 73.83,153.15 73.83,152.52 74.41,151.94 77.72,151.94 77.84,152.07 79.88,152.07 80.47,151.47 82.55,151.47 83.02,151.94 85.34,151.94 85.59,151.68 86.86,151.68 88.82,153.64 98.8,153.64 100.26,155.1 105.41,155.1 106,155.7 112.85,155.7 117.46,160.31 127.51,160.31 128.48,159.34 130.59,159.34 131.26,158.67 132.93,158.67 133.6,159.34 139.66,159.34 140.68,160.35 145.06,160.35 v1(145.08,160.37) 145.59,160.88 184.97,160.88 v1(188.33,157.53) ; v1(128.01,57.07) 127.07,56.13 122.88,56.13 117.09,50.34 105.91,50.34 98.8,57.45 81.02,57.45 74.54,50.97 71.87,50.97 70.29,49.39 56.7,49.39 v1(55.87,50.21) ; v1(275.3,109.55) 275.46,109.39 275.46,103.93 273.3,101.77 261.99,101.77
  IN2 w1.016: 257.68,77.01 257.68,76.96 260.37,74.27 262.22,74.27 262.7,74.75 263.44,74.75 264.15,75.46 272.08,75.46 277.72,69.82 v1(277.72,43.23) v1(277.72,42.01)
  IN3 w0.508: v1(32.11,127.24) 30,127.24 29.45,127.79 13.93,127.79 12.38,129.34 12.38,132.47 7.27,137.57 7.27,160.91 10.58,164.22 15.98,164.22 17.78,166.02 17.78,167.08 21.7,171 22.73,171 23.69,171.96 30.41,171.96 32.09,170.29 37.04,170.29 40.37,173.62 41.96,173.62 42.18,173.4 43.48,173.4 44.03,173.95 44.03,174.63 44.86,175.47 52.92,175.47 54.09,174.29 55.75,174.29 56.9,173.13 62.21,173.13 62.97,172.37 v1(62.97,171.89)
  BOTTOM w0.508: v1(32.11,127.24) 33.81,127.24 35.8,125.25 36.94,125.25 37.57,124.62 38.91,124.62 39.66,125.37 RV129.1 ; v1(127.29,67.89) 127.32,67.86 128.42,67.86 129.33,68.78 129.33,69.59 128.82,70.1 R65.1 R63.1 127.39,70.34 R58.1
  BOTTOM w1.016: v1(277.72,42.01) v1(277.72,43.23) 278.34,43.85 Q22.1 D24.2
  vias: v1(154.2,57.12) v1(154.86,57.12) v1(174.63,55.1) v1(175.27,55.63) v1(220.83,131.48) v1(221.47,131.48) v1(222.1,131.48) v1(222.1,130.84) v1(222.74,131.48) v1(222.74,130.84) v1(223.12,79.79) v1(223.37,131.48) v1(223.5,80.42) v1(223.88,79.79) v1(224.26,80.42) v1(224.64,79.79) v1(225.03,80.42) v1(225.03,79.15) v1(225.41,79.79) v1(225.79,80.42) v1(225.79,79.15) v1(246.62,76.11) v1(247.38,76.11) v1(248.14,76.11) v1(248.9,76.11) v1(249.66,76.11) v1(250.55,76.11)
+5VS_AVDD: length 4.5
  TOP w0.203: CA15.1 183.37,55.68 183.74,56.06 UA1.28
  TOP w0.381: CA15.1 182.96,55.39 182.39,54.82 v3(182.39,54.74) 182.09,54.44 181.25,54.44 RA6.1
+5VS_CLASSD: length 9.1
  TOP w0.203: CA5.1 188.92,61.74 188.71,61.54 188.71,60.94 188.59,60.81 188.48,60.81 188.03,60.36 UA1.13 ; CA4.1 185.95,61.39 185.95,61.08 186.83,60.2 UA1.16
  TOP w0.381: CA4.1 185.4,61.94 185.39,61.94 185.23,62.1 185.23,62.1 185.2,62.14 v1(185.07,62.14) ; v1(192.97,61.6) 192.89,61.68 192.6,61.68 CA16.1 ; CA5.1 189.29,61.55 v1(189.29,60.99)
  TOP w0.508: CA3.1 CA2.1
  vias: v1(175.75,52.79) v1(175.75,52.03) v3(175.37,52.41)
+5VS_HDMI:
  vias: v1(281.41,53.91) v1(281.41,53.22) v1(281.41,52.56) v1(281.41,51.85) v4(280.7,52.84)
+5VS_HDMI_F:
  vias: v4(283.2,44.62)
+5VS_LS:
  vias: v4(221.73,134.67)
+AVEE: length 2.7
  TOP w0.203: UA1.21 184.58,58.95 183.9,59.62 182.79,59.62 CA18.1
+V1.00AP: length 17.7
  IN3 w0.381: v1(152.44,168.45) 152.42,168.47 151.88,168.47 151.37,167.95 151.37,167.57 149.47,165.68 148.73,165.68 146.55,163.5 139.94,163.5 139.55,163.88 v1(139.55,164.52)
  BOTTOM w0.229: 151.54,169.16 PU701.22
  BOTTOM w0.254: v1(152.44,168.45) 152.38,168.51 152.19,168.51 151.54,169.16
  vias: v1(142.2,166.76) v1(142.2,166.13) v1(142.85,166.12) v1(142.86,166.76) v1(143.5,166.76) v1(143.49,166.12) v1(144.13,166.74) v1(144.13,166.1) v1(144.77,166.76) v1(144.76,166.12) v4(145.15,165.27)
+VCC_AMPHYPLL: length 2.1
  TOP w0.254: v2(103.88,129.38) 104.3,129.8 CC46.1
  BOTTOM w0.381: UC1.L15 UC1.K15 103.88,129.29 v2(103.88,129.38)
  vias: v1(83.48,133.22)
+VCC_CORE: length 58.6
  TOP w0.254: v2(111.49,118.4) 111.78,118.69 CC250.1 ; CC249.1 CC248.1 CC247.1 109.58,117.55 CC502.1 ; 103.04,116.61 103.04,116.28 102.87,116.11 CC512.1 ; v1(73.21,80.44) 73.18,80.46 PR452.1 ; CC517.1 CC516.1 ; CC246.1 108.2,113.53 CC244.1 108.22,113.1 ; CC518.1 115.13,116.26 v2(115.44,116.57) ; 103.52,114.65 CC504.1 ; 103.24,120.09 CC508.1 102.9,119.76 ; v2(102.56,113.83) 102.78,113.61 CC243.1 ; CC245.1 CC503.1 ; CC500.1 CC252.1 CC253.1 ; CC515.1 CC514.1
  TOP w0.305: CC511.1 101.75,117.18 ; CC511.1 101.75,117.84 ; CC511.1 102.09,117.51 ; CC504.1 103.52,114 ; 114.87,117.6 CC515.1 114.54,117.25 ; CC510.1 102.3,113.57 v2(102.56,113.83) 102.18,114.21 CC509.1 ; CC257.1 103.26,115.2 ; CC248.1 108.3,117.89 ; v2(113.01,115.6) 113.27,115.35 CC500.1 112.93,115.01 ; CC250.1 112.13,117.75 CC237.1 ; CC251.1 100.77,118.73 ; 99.13,110.95 CC517.1 98.79,111.28 ; 98.79,111.92 CC516.1 99.13,112.25 ; CC506.1 100.12,115.86 ; CC506.1 99.78,116.19 ; CC506.1 100.12,116.52 ; 103.65,117.72 CC255.1 ; CC255.1 103.36,117.38 ; CC255.1 103.03,117.72 ; 103.56,113.61 CC243.1 103.23,113.95 ; CC512.1 102.84,115.94 v2(102.56,115.66) ; CC503.1 109.57,113.18 ; CC247.1 108.93,117.93 ; CC246.1 107.56,113.1 ; 98.28,114.21 CC501.1 98.61,113.86 ; CC245.1 108.91,113.22 ; 114.97,115.17 CC519.1 115.27,115.49 v2(115.44,115.66) 115.13,115.97 CC518.1 114.66,116.11 ; CC507.1 97.85,119.2 ; CC507.1 97.52,119.54 ; CC507.1 97.12,119.2 PC467.2 ; PC478.2 99.32,122.55 CC254.1 99.8,122.21 ; 103.78,115.95 CC505.1 103.41,115.6 ; CC256.1 100.82,115.35 ; CC502.1 109.58,117.89 ; CC249.1 107.64,117.89 ; CC514.1 113.56,117.6 ; CC253.1 114.54,115.48 ; CC252.1 113.9,115.48
  TOP w0.508: 91.17,117.89 88.75,117.89 86.6,115.73 84.94,115.73 84.46,116.21 RC120.1
  BOTTOM w0.203: UC1.G37 102.57,115.68 v2(102.56,115.66) UC1.G38 ; UC1.AM32 115.03,118.86 UC1.AL33 ; UC1.G42 v2(102.56,113.83) UC1.G40 ; UC1.G35 v2(102.56,117.49) 102.66,117.67 UC1.G33 ; UC1.A39 v2(98.2,114.39) ; UC1.G30 102.75,119.76 v2(102.49,119.29) 102.72,118.89 UC1.G32 ; UC1.A44 v2(98.2,111.92) ; UC1.A30 98.78,119.35 v2(98.51,119.08) ; UC1.J30 v2(103.97,119.32)
  BOTTOM w0.254: UC1.AM33 v2(115.44,117.49) UC1.AM35 v2(115.44,116.57) UC1.AM37 v2(115.44,115.66) UC1.AM38 ; PL403.2 v1(73.21,80.44)
  BOTTOM w0.381: UC1.A34 98.85,116.87 98.19,117.53 98.19,118.76 v2(98.51,119.08)
  vias: v1(71.23,87.38) v1(71.25,91.19) v1(71.25,90.56) v1(71.25,89.92) v1(71.25,89.29) v1(71.25,88.65) v1(71.25,88.02) v1(71.84,91.45) v1(71.84,90.81) v1(71.84,90.18) v1(71.84,89.54) v1(71.84,88.91) v1(71.84,88.27) v1(71.81,87.64) v1(72.4,91.14) v1(72.4,90.51) v1(72.4,89.87) v1(72.4,89.24) v1(72.4,88.6) v1(72.4,87.97) v1(72.4,87.33) v1(72.98,91.4) v1(72.98,90.76) v1(72.98,90.13) v1(72.98,89.49) v1(72.98,88.86) v1(72.98,88.22) v1(72.98,87.59) v1(73.54,88.53) v1(73.54,87.89) v1(73.64,91.35) v1(73.62,90.71) v1(73.57,89.82) v1(73.57,89.16) v1(73.57,87.26) v1(74.2,90.99) v1(74.2,89.95) v1(74.58,90.48) v1(74.96,90.99) v1(74.96,89.95) v1(75.34,90.48) v1(75.72,91.02) v1(75.72,89.95) v1(76.11,90.48) v1(76.46,91.02) v1(76.49,89.95) v1(76.84,90.48) v1(76.77,89.34) v1(76.77,88.7) v1(76.77,88.04) v1(77.07,87.48) v1(77.2,91.02) v1(77.22,89.95) v1(77.4,89.34) v1(77.4,88.7) v1(77.4,88.04) v1(77.58,90.48) v1(94.04,115.6) v1(94.75,115.6) v1(95.54,115.6) v1(95.74,121.44) v1(96.25,115.6) v1(96.93,115.6) v1(97.52,121.44) v2(104.06,117.47) v2(104.15,115.65) v2(104.07,113.83) v2(104.76,118.52) v2(105.65,117.76) v2(105.65,116.87) v2(105.65,115.98) v2(105.65,115.09) v2(105.65,114.08) v2(105.65,113.19) v2(105.77,118.52) v2(111.49,117.76) v2(111.49,116.87) v2(111.49,115.98) v2(111.49,115.09) v2(111.49,114.33) v2(111.49,113.44) v2(113.01,117.89) v2(113.01,117.13) v2(113.01,116.36) v4(74.92,87.93)
+VCC_DSW3P3: length 1.7
  BOTTOM w0.254: UC1.AJ17 113.12,127.96 v2(113.05,127.96) ; UC1.AD18 UC1.AD17 111.08,127.64 v2(111.37,127.94)
  vias: v1(95.1,139.15) v1(95.87,139.15) v4(91.13,139.87)
+VCC_FAN1: length 9.7
  TOP w0.508: v1(47.45,49.66) 48,50.21 R68.2 53.59,51.96 v4(53.74,52.12)
  BOTTOM w0.508: JFAN.2 v1(47.45,49.66)
+VCC_GT: length 39.7
  TOP w0.254: CC522.1 103.38,107.26 ; CC522.1 103.85,106.93 ; CC522.1 103.38,106.6 ; v2(109.05,100.01) 109.14,100.11 CC290.1 ; CC290.1 109.54,99.74 ; CC290.1 109.54,100.45 ; PR456.1 85.34,63.57 85.4,63.51 89.26,63.51 89.49,63.74 v1(89.69,63.74) ; CC520.1 105.59,100.49 CC294.1 104.79,100.3 104.97,100.12 ; 110.79,98.17 CC286.1 110.07,98.17 v2(109.96,98.06) ; CC525.1 CC524.1 ; 110.85,98.33 CC285.1 CC287.1 CC288.1 CC289.1 111.2,100.63 111.22,100.66
  TOP w0.305: CC525.1 104.76,101.76 ; 107.19,98.17 107.19,98.17 CC291.1 ; CC293.1 106.29,99.35 v2(106.31,99.36) ; CC293.1 105.68,99.09 105.81,98.97 ; CC293.1 105.68,99.71 ; CC294.1 104.79,100.86 ; CC283.1 108.99,98.65 v2(109.05,98.71) ; CC283.1 108.99,97.87 ; CC283.1 109.33,98.2 ; v2(103.97,102.86) 103.54,103.28 CC523.1 103.52,103.61 ; CC289.1 110.75,100.24 ; 104.64,102.75 CC524.1 ; CC285.1 111.2,97.89 ; CC286.1 110.47,97.82 ; v2(105.39,98.71) 105.3,98.62 CC292.1 ; CC292.1 105.64,98.08 ; CC292.1 105.3,97.5 v2(105.39,97.41) ; CC291.1 106.79,97.82 ; CC291.1 106.46,98.17 ; v2(109.96,99.36) 109.95,99.35 CC284.1 109.24,99.59 109.05,99.78 v2(109.05,100.01) ; CC287.1 110.9,98.97 110.9,98.97 ; 110.85,99.6 CC288.1
  TOP w0.508: RC125.1 101.38,92.16 102.22,93 104.25,93
  BOTTOM w0.203: UC1.K60 103.28,102.86 UC1.J60 ; v2(98.1,106.93) 98.13,106.96 UC1.A53 ; 105.96,102 105.96,101.75 UC1.N63 105.85,101.65 UC1.M62 ; UC1.A58 v2(98.31,104.48) ; UC1.AA64 109.66,101.14 110.27,101.14 UC1.AC64 ; UC1.A48 98.15,109.44 v2(98.1,109.49) ; UC1.A62 98.32,102 v2(98.15,102.18) ; UC1.R63 106.76,102.06 ; UC1.A66 v2(98.1,99.53)
  BOTTOM w0.254: v1(89.69,63.74) 89.72,63.76 PL406.2 ; v2(107.22,101.31) UC1.T62
  vias: v1(89.34,69.76) v1(89.29,68.61) v1(89.67,69.2) v1(89.92,68.61) v1(90,69.76) v1(90.3,69.2) v1(90.63,69.76) v1(90.56,68.61) v1(90.94,69.2) v1(91.24,68.61) v1(91.27,69.76) v1(91.57,69.2) v1(91.9,69.76) v1(91.88,68.61) v1(92.21,69.2) v1(92.21,68.05) v1(92.54,69.76) v1(92.51,68.61) v1(92.84,69.2) v1(92.84,68.05) v1(93.15,68.64) v1(93.17,70.9) v1(93.17,69.78) v1(93.5,70.34) v1(93.5,69.22) v1(93.48,68.08) v1(93.53,67.44) v1(93.83,70.9) v1(93.83,69.78) v1(93.81,68.64) v1(94.14,70.34) v1(94.14,69.22) v1(94.11,68.08) v1(94.22,67.42) v1(94.44,68.64) v1(94.47,70.9) v1(94.47,69.78) v1(94.77,70.34) v1(94.77,69.22) v1(94.93,68.18) v1(95.1,70.95) v1(95.1,69.78) v1(95.23,68.76) v1(95.43,70.39) v1(95.59,69.35) v1(95.56,68.18) v1(95.82,70.92) v1(95.89,69.93) v1(95.87,68.76) v1(96.22,69.35) v1(96.2,68.18) v1(96.45,70.92) v1(96.5,68.76) v1(96.55,69.93) v1(96.83,68.18) v1(96.86,69.35) v1(97.09,70.92) v1(97.09,70.29) v1(97.47,68.38) v1(97.8,67.82) v1(98.1,68.38) v1(98.15,67.29) v1(102.75,80.19) v1(102.8,81.85) v1(102.78,78.49) v1(102.78,77.12) v1(102.78,75.83) v1(103.16,79.66) v1(103.31,81.34) v1(103.26,75.32) v1(103.44,77.1) v1(103.74,78.49) v1(103.79,80.86) v1(103.82,79.66) v1(103.77,74.81) v1(103.87,76.61) v1(107.17,88.93) v1(107.17,88.17) v1(107.17,87.41) v1(107.17,86.65) v1(107.17,85.76) v1(107.17,85) v2(103.99,111.94) v2(103.97,111.09) v2(104.01,110.23) v2(103.97,109.26) v2(103.97,108.34) v2(103.97,107.43) v2(104.05,105.54) v2(103.97,103.77) v2(104.12,106.46) v2(104.12,104.68) v2(104.93,102.37) v2(105.39,101.31) v2(106.31,98.06) v2(106.31,96.76) v2(107.17,99.35) v2(107.22,97.41) v2(107.3,98.71) v2(107.47,108.21) v2(108.13,98.71) v2(108.13,96.76) v2(108.19,108.21) v2(108.9,108.24) v2(109.05,97.41) v2(109.96,96.76) v2(110.79,102.76) v2(111.4,102.76) v2(112.07,105.49) v2(112.07,104.68) v2(112.18,108.25) v2(112.2,107.53) v4(103.24,72.06)
+VCC_HDA: length 93.1
  TOP w0.254: CC99.1 113.52,126.69 v2(113.05,126.69)
  TOP w0.508: v1(144.48,149.05) 144.48,145.37 v4(144.52,145.33) 144.52,140.45 146.57,138.39 146.57,118.12 142.27,113.82 137.62,113.82 137.27,114.18 RC299.2 ; v1(138.79,143.42) 138.79,143.81 137.53,145.07 136.48,145.07 135.63,144.22 RC330.2 134.77,143.73 CC540.1 134.05,143.71 v1(134.02,143.74)
  IN1 w0.254: 122.62,128.65 122.62,128.02 119.85,125.25 115.26,125.25 113.82,126.69 v2(113.05,126.69)
  IN1 w0.508: v1(138.79,143.42) 139.02,143.42 140.95,145.35 140.95,146.29 142.16,147.49 143.55,147.49 144.48,148.42 v1(144.48,149.05) ; 122.62,128.65 127.07,133.09 127.07,137.89 129.2,140.02 130.75,140.02 131.45,140.72 131.45,142.04 133.15,143.74 v1(134.02,143.74)
  BOTTOM w0.254: v2(113.05,126.69) 113.09,126.69 UC1.AJ19
+VCC_IO: length 50.2
  TOP w0.305: CC339.1 114.59,111.79 ; CC339.1 114.24,111.46 ; CC339.1 114.24,112.12 ; v2(113.98,120.23) 113.9,120.15 CC338.1 114.23,119.58 ; 114.59,112.55 CC336.1 114.24,112.22 ; 117.15,112.43 CC337.1 116.49,112.43
  TOP w0.508: RC297.2 134.09,113.42 134.45,113.06 136.63,113.06 136.63,113.06 ; v1(138.91,146.11) 140.74,146.11 143.12,148.49 143.12,151.17 141.98,152.31 141.98,153.16 143.03,154.21 145.52,154.21 ; v1(101.84,109.33) 101.52,109.01 100.96,109.01 100.64,108.69 RC344.1 99.85,108.69 99.55,109 99.55,109.25 98.7,110.1 89.19,110.1 v1(88.6,109.51) ; RC192.2 131.9,148.28 131.92,148.31 132.86,148.31 v1(132.89,148.33)
  IN1 w0.508: v1(132.89,148.33) 132.89,148.45 133.46,149.02 134.17,149.02 137.09,146.11 v1(138.91,146.11)
  BOTTOM w0.203: v2(115.44,113.83) 115.05,113.44 UC1.AM42 ; UC1.AK28 114.11,120.36 v2(113.98,120.23) 114.11,120.09 UC1.AK30
  BOTTOM w0.254: UC1.AM30 115.44,119.38 v2(115.44,119.32) ; UC1.AM30 114.59,120.23 UC1.AL30 115.03,120.69 UC1.AM28 v2(115.44,120.23) 115.44,120.17 UC1.AM30 ; UC1.AL42 114.59,113.83 UC1.AM42 115.05,113.31 v2(115.44,112.92)
  vias: v1(86.2,94.38) v4(86.17,103.93)
+VCC_IO_AP:
  vias: v4(142.92,159.02)
+VCC_IO_AP_GATE:
  vias: v4(145.89,162)
+VCC_MPHYGT: length 8.1
  TOP w0.254: CC50.1 105.81,128.85 v2(105.5,128.54) ; CC50.1 106.14,129.24 ; CC50.1 105.48,129.24 ; v2(106.4,127.32) 106.85,126.87 CC52.1 106.33,126.63 106.32,126.64 ; CC47.1 112.23,124.99 v2(112.23,125.32)
  BOTTOM w0.254: UC1.AF20 111.86,125.69 v2(112.23,125.32) UC1.AF21 ; UC1.N17 106.07,127.64 v2(106.38,127.95) 106.72,128.29 UC1.P16 ; UC1.T19 107.66,126.34 108.02,125.98 v2(108.02,125.95) 107.99,125.93 107.97,125.93 107.73,125.69 UC1.T20 ; UC1.P15 106.74,128.94 v2(106.34,128.54) ; UC1.N18 106.08,126.99 v2(106.4,127.32)
  vias: v1(79.53,134.74) v1(80.04,135.25) v1(80.12,125.3) v1(80.18,134.49) v1(80.5,135.76) v1(80.61,124.87) v1(80.7,134.96) v1(81.2,135.5) v4(78.17,125.55)
+VCC_SA: length 17.3
  TOP w0.254: PR460.1 67.43,104.31 69.3,106.18 v1(69.3,106.23) ; CC334.1 113.52,122.8 v2(113.64,122.69) ; CC334.1 CC335.1 ; CC334.1 113.14,122.39 ; CC335.1 112.5,122.33 v2(112.38,122.21) ; CC335.1 112.21,122.8 ; 104.84,121.61 CC333.1 104.56,121.18 104.44,121.05 ; 103.21,120.66 CC332.1 102.86,120.85 v2(102.55,121.16)
  TOP w0.305: 101.75,123.02 CC329.1 102.09,123.35 ; 101.75,122.92 CC330.1 102.09,122.59 ; CC331.1 102.9,123.6 ; CC331.1 103.56,123.6 ; CC331.1 103.23,123.26
  TOP w0.508: v1(81.65,121.46) 82.06,121.05 RC370.1
  BOTTOM w0.203: UC1.G23 v2(102.56,122.98) 102.72,122.69 UC1.G25 v2(102.56,122.06) UC1.G27 102.79,121.6 v2(102.55,121.16) UC1.G28
  BOTTOM w0.254: PL408.2 v1(69.3,106.23)
  vias: v1(75.55,108.92) v1(75.55,108.29) v1(75.55,107.65) v1(75.55,107.02) v1(75.55,106.38) v1(76.23,109.23) v1(76.23,108.59) v1(76.23,107.96) v1(76.23,107.32) v1(76.23,106.69) v2(103.97,122.98) v2(103.97,121.15) v2(106.01,121.53) v2(106.62,121.53) v2(107.23,121.53) v2(107.97,121.56) v2(108.73,121.56) v2(109.46,121.59) v2(110.24,121.57) v2(111.32,121.59) v2(113.65,123.35) v4(74.95,107.26)
+VCC_ST: length 149.8
  TOP w0.254: U148.A2 77.31,122.22
  TOP w0.381: v2(104.56,126.02) 104.56,125.02 104.82,124.76 CC70.1 ; v2(98.03,127.16) 98.03,127.03 97.56,126.57 96.46,126.57 95.91,126.02 CC69.1
  TOP w0.508: v1(90.32,129.54) 92.58,127.27 v1(93.46,127.27) 94.72,126.02 CC69.1 ; v1(83.87,97.09) 83.43,97.53 83.43,100.91 v4(83.57,101.05) 84.51,101.05 v1(87.76,104.3) 88.35,104.3 89.64,103 v1(89.64,101.25) 90.43,101.25 RC358.1 ; v1(78.91,121.46) 78.91,120.72 C8535.2
  IN2 w0.508: v1(78.91,121.46) 78.91,121.97 77.59,123.29 77.59,127.58 79.24,129.23 82.85,129.23 83.15,129.54 v1(90.32,129.54)
  IN3 w0.508: v1(83.87,97.09) 79.99,93.21 79.99,87.28 77.32,84.61 77.32,73.45 74.78,70.91 69.92,70.91 67.63,68.63 66.92,68.63 66.41,68.12 66.41,67.61 63.86,65.06 61.83,65.06 59.09,62.31 59.09,58.5 57.56,56.98 56.47,56.98 v1(54.41,59.04) ; v1(89.64,101.25) v1(89.64,99.85) v1(89.64,98.08)
  BOTTOM w0.203: v2(98.03,127.16) 98.4,126.78 UC1.A18
  BOTTOM w0.254: v1(54.41,59.04) 54.41,60.39 54.84,60.81 PC403.1 55.35,60.79 PR404.1 PR403.1 ; v2(104.56,126.02) 104.55,126.02 UC1.K20 UC1.K21
  BOTTOM w0.508: RC20.1 v1(89.64,98.08) RC355.1 ; RC31.2 RC34.2 RC3.2 88.45,104.3 v1(87.76,104.3) ; v1(89.64,99.85) RC356.1 ; v1(83.87,97.09) 83.67,97.29 83.67,115.21 79.32,119.57 79.32,121.05 v1(78.91,121.46) ; RC53.1 v1(89.64,101.25)
+VCC_STG: length 41.2
  TOP w0.381: v2(98.1,124.31) 98.54,124.75 CC68.1
  TOP w0.508: U149.4 78.75,116.86 v4(79.11,116.51) 79.11,116.3 78.86,116.05 v1(78.86,115.49) 79.57,115.49 79.82,115.24 79.82,113.1 v1(79.67,112.95)
  IN2 w0.508: v1(78.86,115.49) 78.86,120.01 79.88,121.03 79.88,122.41 78.98,123.31 78.98,126.78 80.51,128.32 81.65,128.32
  IN3 w0.508: v1(79.67,112.95) 79.7,112.95 85.46,107.19 85.46,102.41 87.37,100.5 v1(87.37,99.79)
  BOTTOM w0.203: UC1.A22 v2(98.1,124.31)
  BOTTOM w0.254: UC1.G20 102.86,126.02 102.68,125.71 102.68,125.71 v2(102.68,125.71)
  BOTTOM w0.508: v1(87.78,103.3) 88.54,103.3 RC404.2
GND: length 1544.9
  TOP w0.114: U14.14 137.21,67.7 U14.17 v1(136.47,68.45) ; UV6.M9 19.31,134.38
  TOP w0.203: JLCD.13 54.58,115.46 54.42,115.31 v1(54.42,115.26) ; UE1.122 v1(181.86,129.45) ; 77.64,119.43 77.64,120.14 77.36,120.42 77.16,120.42 R9494.2 76.7,120.88 U148.B2 ; UGSEN1.10 v1(178.19,107.35) ; UGSEN1.16 180.64,105.15 v1(180.84,104.95) ; UGSEN1.12 v1(178.18,106.35) ; UV6.T9 15.95,134.2 15.95,134.19 v1(15.68,133.92) ; UGSEN1.13 178.31,105.85 v1(178.17,105.71) ; UE1.3 v1(179.18,128.37) ; UE1.27 v1(176.52,118.77) ; JTOUCH1.10 v1(247.9,154.59) ; UGSEN1.15 v1(180.14,104.87) ; Q24.1 147.22,161.77 147.67,161.32 147.67,160.96 148.16,160.47 Q24.4 ; RPE4.1 v1(193.39,135.56) ; U6.10 v1(226.73,95.51) ; v1(186.04,116.49) 185.86,116.31 UE1.49 ; v1(161.65,72.68) 161.7,72.63 JKB.30 ; JTOUCH1.3 v1(250.7,156.62) ; 21.71,159.9 22.08,160.27 22.08,160.88 21.98,160.98 21.98,161.03 21.63,161.37 v1(21.53,161.37) ; UE1.113 v1(185.46,129.45) ; JTOUCH1.6 249.5,154.81 v1(249.28,154.59) ; UE1.91 v1(192.14,127.17) ; UGSEN1.5 v1(181.36,108.5) ; v1(176.26,128.81) 176.62,129.17 UE1.1 ; RPE4.4 v1(191.89,135.56)
  TOP w0.229: PU301.14 180.16,172.45 ; PU301.1 179.76,168.18 ; PU301.3 180.56,168.24
  TOP w0.254: v2(111.39,128.58) 111.24,128.72 CC531.2 ; UV7.M9 19.26,154.35 19.26,154.36 v2(18.92,154.7) ; v2(107.42,114.84) 107.56,114.7 CC246.2 ; v1(203.49,95.56) 203.53,95.61 U5.21 ; 51.01,119.81 51.01,119.81 51.32,120.12 51.32,120.41 JLCD.38 52.28,120.61 v1(52.33,120.56) ; v1(263.97,140.17) 263.97,141.01 UM1.24 ; CC244.2 CC245.2 ; CC244.2 108.22,114.8 v2(108.19,114.84) ; CC244.2 107.59,114.14 CC246.2 ; CC245.2 108.91,114.68 108.93,114.7 ; CC245.2 CC503.2 109.57,114.83 v2(109.58,114.84) ; 113.14,123.59 113.14,123.63 112.9,123.87 ; v1(117.53,162.67) 117.63,162.67 118.24,163.28 PR626.2 ; U1.6 45.71,123.73 45.89,123.55 v1(46.28,123.55) ; CC539.2 110.36,129.64 v2(110.56,129.43) ; CC341.2 117.62,120.68 117.36,120.43 v2(117.36,120.23) ; URE1.8 v1(242.81,86.03) ; U16.21 v1(263.39,122.22) ; JCP.12 123.16,63.35 v1(123.85,64.04) ; CC507.2 96.92,118.61 PC467.1 ; CC507.2 97.52,117.61 PC465.1 ; CC507.2 98.25,118.61 PC476.1 ; U6.21 v1(220.71,95.51) ; PR420.1 58.12,54.79 v1(58.12,54.36) ; v2(119.65,133.92) 119.75,133.82 C197.2 ; v1(285.58,57.59) D3.3 ; v1(222.59,167.49) 222.72,167.63 PU1.2 ; URE1.15 245.91,83.67 v1(245.85,83.61) ; C201.2 114.91,128.81 v2(114.67,128.57) 114.64,128.61 C200.2 ; C201.2 115.74,128.81 RC151.1 ; C201.2 115.33,129.31 ; UTPM1.2 127.26,161.04 v1(127.36,160.94) ; v2(113.58,124.53) 113.33,124.79 CC47.2 ; C200.2 114.14,128.95 ; C200.2 114.11,128.63 CC58.2 113.56,129.03 ; UM1.31 v1(265.61,144.81) ; 103.8,124.33 103.66,124.19 CC331.2 ; v1(210.19,96.1) 210.19,96.07 209.84,95.71 209.07,95.71 208.97,95.61 U5.10 ; 180.16,172.45 v1(179.92,172.7) 179.35,173.26 PR302.1 ; CC340.2 117.36,123.08 v2(117.36,122.98) ; 114.31,121.43 CC526.2 113.84,121.1 v2(113.68,121.26) ; CC235.2 106.65,114.12 CC246.2 ; RM27.2 268.82,147.1 268.34,147.57 v1(268.34,147.67) ; CC254.2 99.32,123.13 PC478.1 ; CC46.2 103.92,130.39 v2(103.83,130.29) ; CC59.2 CC99.2 113.13,126.04 v2(113.06,125.98) 112.92,126.12 CC96.2 ; v1(84.36,53.09) 84.36,53.08 83.79,52.51 PU403.6 ; v1(52.89,116.47) 52.99,116.36 53.78,116.36 JLCD.16 54.63,117.21 JLCD.36 ; RC8.2 116.4,126.11 116.4,126.31 v2(116.73,126.63) ; RC359.2 108.22,132.12 v2(108.29,132.05) ; CV6.2 47.98,145.82 47.32,145.82 v2(46.94,146.2) ; PC519.1 111.8,123.39 CC335.2 ; PR301.1 v1(181.44,174.16) 181.44,173.9 PC316.2 ; 179.76,168.18 179.61,168.03 v1(179.61,167.95) ; v2(27.7,140.38) 27.33,140.76 UV6.B1 ; JLCD.19 53.26,117.55 52.76,117.05 52.43,117.05 v1(52.31,116.92) ; URE1.35 246.31,88.37 v1(246.11,88.17) ; RC403.1 139.39,118.54 139.79,118.94 139.79,121.96 v1(138.94,122.82) ; 180.56,168.24 180.56,167.38 v1(180.4,167.22) ; v1(260.88,140.2) 260.9,140.22 UM1.18 ; CV63.2 50.49,152.31 50.82,152.31 50.82,152.3 51.28,152.3 51.39,152.4 CV57.2 ; D5.1 268.92,151.85 v1(268.97,151.8) ; 111.96,100.68 111.78,100.5 CC289.2 CC288.2 CC287.2 111.78,98.74 111.78,98.6 111.78,98.6 CC285.2 ; v1(72.37,62.57) PR425.1 ; 113.7,129.9 CC530.2 ; CC530.2 113.7,130.69 v2(113.63,130.75) ; CC530.2 114.14,130.22 ; CC61.2 110.24,135.63 v2(109.8,135.63) ; v1(63.74,65.92) 63.61,65.79 63.61,65.03 61.96,63.38 PR441.1 ; v1(287.48,61.25) 287.23,61.5 D11.3 ; CC532.2 107.75,129.46 108.3,129.46 v2(108.31,129.45) ; v2(114.54,134.65) 114.18,135.01 CC60.2 ; CC502.2 109.58,116.96 CC247.2 CC248.2 CC249.2 107.64,116.45 v2(107.42,116.24) ; v1(112.05,164.62) 112.12,164.62 112.55,165.06 PC620.2 112.66,165.92 PR619.1 ; PR421.2 57.07,57.45 v1(56.9,57.61) ; JLCD.30 49.78,120.29 49.78,120.28 49.56,120.06 v1(49.56,120.05) ; v2(108.86,125.95) 108.56,126.25 CC95.2 ; v2(105.52,127.34) 105.8,127.06 CC49.2 105.8,126.25 v2(105.56,126.02) ; v1(108.82,116.11) 108.9,116.03 PRT7.2 109.46,115.48 v2(109.58,115.6) ; v2(106.33,125.98) 106.39,126.04 CC52.2 106.88,126.07 CC97.2 ; v1(153.2,59.72) JTP.7 ; v1(51.29,118.12) 51.47,118.29 51.47,118.57 JLCD.24 ; U16.10 v1(269.23,122.22)
  TOP w0.305: v2(25.29,159.52) 24.96,159.85 24.96,159.85 UV7.E2 ; v2(109.96,98.71) 110.43,98.71 CC286.2 ; v2(100.27,119.35) 100.63,119.7 CC251.2 ; v1(23.7,154.71) 24.11,154.3 UV7.F9 ; v1(23.7,154.71) 23.31,154.32 UV7.G9 ; v1(23.7,154.71) UV7.G8 ; CC243.2 102.66,113.02 v2(102.56,112.92) ; UV7.B3 27.31,158.66 v2(27.43,158.54) ; v2(102.56,124.77) 103.14,124.19 CC331.2 ; JLCD.35 56.38,115.74 56.38,116.5 v1(56.55,116.67) ; v2(116.09,115.66) 116.09,115.41 CC519.2 ; UV7.M1 19.31,161.34 18.8,161.84 v1(18.8,162.03) ; v1(24.8,162.47) 25.28,161.98 25.28,161.18 ; UV6.D8 25.67,135.16 v2(25.29,134.78) 25.29,134.78 UV6.E8 ; v2(17.31,154.69) 17.32,154.69 UV7.P9 ; CV53.2 51.46,154.51 51.08,154.89 51.07,154.89 50.92,155.04 50.92,155.04 CV3.2 ; CC342.2 119.47,124.04 v2(119.65,124.22) ; CC257.2 102.25,115.07 102.56,114.77 v2(102.56,114.75) 102.94,114.36 CC504.2 ; CC284.2 108.15,99.35 v2(108.13,99.36) ; UV7.E1 24.91,160.85 24.9,160.86 24.93,160.86 25.24,161.18 25.28,161.18 ; v1(22.11,134.76) 22.1,134.76 21.71,135.16 ; UV7.B1 27.31,161.11 v1(27.56,161.36) ; 112.22,99.6 CC288.2 ; 113.06,118.69 CC250.2 112.72,119.02 ; 25.28,161.18 25.44,161.18 25.7,160.92 25.7,160.71 UV7.D1 ; UV6.G8 23.7,134.76 v1(23.71,134.76) ; CC523.2 102.94,103.24 v2(102.56,102.86) 103.02,102.39 CC524.2 ; v1(23.65,141.22) 23.58,141.15 23.58,141.05 23.31,140.78 23.31,140.76 UV6.G1 ; UV6.T1 15.93,140.94 v1(15.57,140.94) ; v2(101.92,121.15) 101.92,120.96 102.23,120.66 CC332.2 ; v1(15.68,161.12) 15.7,161.12 16.11,160.71 UV7.T1 ; CC291.2 106.75,98.71 v2(106.31,98.71) ; CC255.2 103.87,118.31 v2(103.97,118.4) ; UV6.E1 25.02,140.87 25.02,141.09 25.26,141.33 v1(25.45,141.33) 25.71,141.07 UV6.D1 ; 100.13,123.13 CC254.2 99.8,123.48 ; v2(115.17,118.4) 114.95,118.18 CC515.2 114.54,118.52 ; v2(100.25,114.61) 100.57,114.29 CC256.2 100.91,114.21 CC509.2 CC510.2 ; 112.5,123.73 CC335.2 CC334.2 113.14,123.59 ; CC252.2 CC500.2 113.27,113.47 CC211.2 ; CC252.2 113.9,114.11 ; CC252.2 CC253.2 ; UV6.M1 19.31,140.74 v2(18.92,140.35) ; 98.61,113.28 CC501.2 97.95,113.28 ; v2(109.58,116.24) CC502.2 109.91,116.96 ; UV6.B3 27.3,139.16 27.04,138.9 27.04,138.52 v1(27.04,138.51) ; CC514.2 113.9,118.52 ; 100.82,123.35 CC329.2 CC330.2 100.82,122.59 ; v2(22.15,155.49) 22.09,155.49 21.71,155.11 21.71,155.1 ; 21.71,139.96 22.1,140.35 22.12,140.35 v1(22.14,140.37) ; CC292.2 104.33,98.08 v2(104.15,97.9) ; CC248.2 108.3,116.63 ; v2(103.97,116.57) 103.46,116.57 CC505.2 ; 112.38,98.97 CC287.2 ; UV7.D8 25.69,155.1 v2(25.3,154.7) 25.29,154.7 24.91,155.09 UV7.E8 ; UV7.G1 23.11,160.9 v1(23.11,161.35) ; v2(104.45,99.34) 104.46,99.35 CC293.2 ; CC339.2 113.66,112.12 ; CC339.2 113.66,111.46 ; CC339.2 113.32,111.79 ; UL1.6 v1(254.04,90.96) ; UV6.P1 17.71,140.76 v2(17.3,140.35) ; v2(116.09,112) 116.25,111.84 CC337.2 ; CV106.2 24.49,165.18 v1(25.19,165.88) ; CC508.2 101.98,120.09 v2(101.84,120.23) ; v2(104.45,99.99) 104.21,100.23 CC294.2 ; CC511.2 100.8,117.51 v2(100.27,116.97) 100.71,116.54 CC506.2 ; v1(133.98,144.57) 134.03,144.62 CC540.2 ; CC283.2 108.4,97.68 v2(108.13,97.41) ; v2(102.56,116.57) 102.25,116.27 CC512.2 ; CC525.2 103.7,101.42 103.83,101.29 v2(104.45,101.29) ; v1(23.71,134.76) 23.71,134.76 UV6.G9 ; v1(23.71,134.76) 23.83,134.64 23.83,134.64 24.11,134.36 UV6.F9 ; v2(18.91,134.76) 18.93,134.76 19.31,134.38 ; UV7.B9 27.31,154.19 v1(27.77,153.72) 28.11,154.06 UV7.A9 ; 112.23,100.24 CC289.2 ; CC344.2 117.36,112.99 v2(117.36,112.92) ; CC249.2 107.31,116.96 ; CC343.2 117.36,116.68 v2(117.36,116.57) ; v2(102.56,107.43) 102.8,107.19 CC522.2 102.8,105.84 v2(102.56,105.6) ; 146.04,163.37 146.09,163.32 146.09,163.04 146.75,162.38 Q24.1 ; v1(25.93,145.97) 26.09,145.81 CV95.2 CV94.2 ; CC290.2 110.13,100.5 v2(109.96,100.66) ; UV6.B9 27.7,133.97 v1(27.7,133.93) 28.11,134.34 UV6.A9 ; 113.66,112.22 CC336.2 113.32,112.55 ; CV110.2 26.47,165.76 v1(26.59,165.88) ; 114.23,118.99 CC338.2 113.9,118.65 ; v1(19.87,146.41) 19.92,146.35 CV89.2 ; UV6.P9 18.11,133.96 v1(18.11,133.85) ; CC247.2 108.93,116.63 ; CC518.2 115.79,116.11 116.09,116.42 v2(116.09,116.57) ; QC3.4 84.52,99.21 84.37,99.36 84.37,99.97 v1(84.52,100.12) ; CC503.2 110,114.14 ; v2(100.27,111.92) 100.27,111.92 CC516.2 CC517.2 99.71,110.15 v2(100.22,109.64) ; 112.38,98.33 CC285.2
  TOP w0.381: CV10.2 60.96,151.49 60.61,151.14 v2(60.56,151.14) ; v2(55.77,150.17) 55.13,150.17 CV59.2 ; v2(58.72,153.88) 58.92,154.08 CV40.2 ; CV33.2 53.57,143.03 v2(53.74,143.21) ; v2(51.34,160.02) 51.91,159.45 RV75.1 ; v1(63.36,169) RV11.2 CV75.2 ; CA18.2 181.52,59.34 v1(181.62,59.24) ; UV7.T9 16.1,154.31 15.71,154.31 v1(15.47,154.07) ; R273.1 116.2,160.02 116.2,160.88 v1(116.17,160.9) ; v2(47.77,149.67) 47.77,149.4 47.58,149.21 CV2.2 ; v1(44.86,171.18) 44.32,171.18 CV20.2 ; QC3.1 86.25,97.4 v1(86.98,96.68) ; v2(59.65,143.07) 59.65,143.69 RV82.1 ; CC69.2 97.4,126.02 v2(97.49,125.92) ; UV7.P1 17.71,160.76 17.27,161.2 v1(17.25,161.2) ; CV60.2 55.73,152.87 v2(55.77,152.83) ; CV53.2 51.46,154.48 v2(52.11,153.83) ; v1(45.98,174.05) 45.98,173.9 45.9,173.82 45.9,173.39 RV77.1 ; UV6.E2 v2(25.32,139.55) ; v1(131.34,135.25) 130.24,136.34 CC537.2 ; C52.2 v1(191.07,75.23) ; RV15.2 14.71,128.98 v1(14.53,128.8) ; v1(65.89,167.82) 65.48,167.41 CV74.2 ; v2(53.06,148.02) 53.52,148.48 CV44.2 ; CC225.2 105.43,120.44 CC333.2 ; D18.3 v1(282.56,123.22) ; JU3AC.16 136.16,55.98 v1(136.39,55.75) 136.66,56.01 JU3AC.17 ; CV45.2 57.44,151.16 v2(56.77,151.83) ; CV65.2 58.54,156.8 v2(58.42,156.67) ; JU3AC.1 v1(128.66,55.67) ; CA40.2 v1(190.02,50.38) ; JU3AC.10 v1(133.16,55.67) ; RV13.2 43.13,173.26 v1(43.13,174.07) ; CV70.2 61.82,153.09 v1(61.82,153.39) 61.26,153.95 CV28.2 ; CA12.2 v1(192.31,50.38) ; CA1.2 193.94,59.87 v1(193.94,60.31) ; CV54.2 56.33,154.26 v2(56.77,153.83) ; CV58.2 61.11,156.8 v2(60.53,157.38) ; R120.2 R118.2 141.48,67.55 v1(141.69,67.75) ; v2(127.33,94.03) 127.33,93.73 125.84,92.24 RC295.2 ; CV142.2 48.22,173.26 47.81,173.26 v1(47.53,173.54) ; v2(62.16,143.8) 62.16,144.39 CV66.2 ; RV17.2 20.25,129.55 ; v2(52,148.95) 52.5,149.45 CV52.2 ; CD21.2 161.1,120.33 161.1,119.99 160.42,119.3 CD41.2 ; RV12.2 50.27,172.12 v1(50.27,171.53) ; v1(45.55,171.18) 45.47,171.1 45.47,170.95 CV21.2 ; v1(193.94,61.56) 194.16,61.79 RA13.2 ; DL1.3 v1(264.45,96.17) ; RM18.2 v1(253.73,140.49) ; Q28.1 v1(179.36,145.08) ; v1(174.36,108.63) 174.43,108.56 175.25,108.56 RC292.1 ; J1.1 267.46,149.21 266.82,149.21 266.58,148.97 v1(266.58,148.95) ; v1(259.16,139.48) CM9.2 ; RL7.2 254.79,98.41 255.18,98.03 v1(255.18,97.47) ; CV90.2 27.53,129.64 v1(27.79,129.38) ; D17.3 v1(282.71,115.86) ; CA43.2 v1(190.94,52.15) ; v2(113.7,133.35) 114.04,133.35 RC385.2 ; v1(225.79,92.23) 228.28,92.23 228.63,92.59 R45.1 ; Q28.4 v1(178.06,141.67) ; CV49.2 CV48.2 70.57,156.37 70.31,156.63 v1(70.25,156.63) ; CC538.2 v1(194.02,55.62) ; v1(245.85,83.61) 245.85,83.22 245.52,82.89 RRE28.2 ; CV56.2 62.28,155.02 62.73,154.57 v2(62.73,154.56) ; v2(49.98,159.97) 49.98,159.73 CV8.2 ; v1(262.95,151.8) 262.74,151.59 RM26.2 ; v1(192.74,54.11) 192.54,54.11 192.29,54.36 CA6.1 ; CV61.2 54.35,149.4 v2(54.11,149.17) ; CV50.2 59,151.83 v2(58.77,151.83) ; v1(112.46,144.57) 112.46,143.73 112.41,143.68 RC386.2 ; RL8.2 v1(258.93,88.42) ; CA5.2 v1(189.1,63.29) ; RC361.2 115.32,134.65 v2(114.54,134.65) ; JU3AC.4 v1(130.16,55.67) ; v1(18.53,165.78) 18.09,165.33 CV108.2 ; v1(253.74,143.3) RM25.2 RM19.1 ; v1(59.85,113.06) 59.06,113.06 JLCD.34 ; v1(284.51,35.77) 284.51,35.14 283.57,34.2 282.58,34.2 282.32,34.46 D8.2 ; CV7.2 49.25,147.86 49.25,147.36 v2(49.36,147.25) ; JCR.3 v1(165.45,53.88) ; v2(47.74,156.61) 47.74,156.63 CV1.2 ; R107.1 v1(278.54,110.32) ; CV34.2 CV32.2 57.88,145.01 57.51,144.63 v2(57.25,144.63) ; CA42.2 v1(193.02,58.07) ; v2(58.57,156.03) 59,155.6 CV38.2 ; v2(57.9,148.14) 57.33,147.57 CV39.2 ; CA15.2 182.05,55.4 181.85,55.2 v1(181.85,55.02) ; CV43.2 53.2,156.76 53.2,157.33 v2(53.68,157.81) ; v2(62.16,152.15) 62.21,152.1 CV9.2 ; D16.3 282.28,112.43 282.36,112.51 282.36,112.5 v1(282.38,112.48) ; CV51.2 57.35,148.78 v2(56.84,149.29) ; CL8.2 v1(258.44,87.28) ; JCR.6 v1(166.95,53.85) ; CV55.2 53.9,151.62 v2(54.11,151.83) ; DL2.3 v1(272.19,98.2) ; CA4.2 v1(185.78,63.15) ; v2(62.74,149.89) 62.74,149.47 62.66,149.39 CV26.2 ; CV62.2 59.46,152.91 v2(59.97,153.42) ; v2(106.22,130.58) 106.22,130.23 CC50.2 ; v2(53.99,155.77) 54.47,155.28 CV47.2 ; JU3AC.7 v1(131.66,55.67) ; CM10.2 v1(259.11,138.59) ; CV46.2 52.11,151.8 v2(52.16,151.85) CV57.2 ; CV4.2 48.79,155.12 49.36,154.55 v2(49.36,154.51) ; CV98.2 17.96,145.7 v1(18.08,145.83) ; RRE20.2 v1(250.06,81.75)
  TOP w0.457: v2(52.11,147.17) 51.99,147.05 CV35.2 ; v2(54.96,143.11) CV30.2 ; CV42.2 57.5,155.73 56.83,155.05 v2(56.81,155.05) ; v2(61.41,146.22) 61.78,146.59 CV145.2 ; v2(56.11,143.36) CV71.2 ; v2(56.13,156.44) 56.44,156.75 CV41.2 ; CV37.2 57.83,152.78 v2(57.83,153.05) ; CV27.2 59.65,144.65 v2(59.71,144.58) ; v2(54.11,147.17) 53.77,146.83 CV31.2 ; CV64.2 53.69,153.7 v2(54.05,154.05) ; CV29.2 53.63,143.96 53.64,143.94 ; CV67.2 62.21,145.6 62.84,146.22 v2(62.84,146.24)
  TOP w0.508: R83.2 v1(274.56,113.44) ; RD18.2 145.02,87.41 v1(145.14,87.28) ; PD7.1 253.75,122.36 v1(254.47,121.63) ; v1(16.54,128.95) 16.56,128.98 CV96.2 ; v1(137.27,128.83) 137.69,128.42 CC26.2 ; RC71.2 113.05,144.57 v1(112.46,144.57) ; C29.2 204.25,92.14 204.25,93.05 v1(204.46,93.26) ; RV53.1 87.64,142.5 v1(87.48,142.65) ; R267.1 v1(130.54,165.14) ; SW1.2 v1(265.7,164.21) ; JCP.14 124.57,59.85 v1(124.2,59.48) ; C749.1 78.63,113.2 v1(79.04,112.8) ; v1(210.88,92.16) 211.44,91.6 R30.1 ; JTOUCH1.12 v1(245.4,158.46) ; CV112.2 v1(27.87,165.78) ; RC317.1 151.9,148.51 v1(151.93,148.54) ; v1(58.2,176.31) 58.08,176.19 CV176.2 ; v1(154.49,127.51) 154.49,127.7 154.96,128.18 155.68,128.18 156.06,127.79 CD45.2 ; CL12.2 v1(280.99,93.7) ; v2(53.74,143.84) 53.64,143.94 CV36.2 ; v1(265.24,117.09) 265.4,116.94 C184.2 ; PQ105.3 267.77,109.14 v1(267.77,108.52) ; YL1.2 v1(256.6,84.06) ; RC55.1 119.69,129.19 v2(119.8,129.08) ; CV5.2 48.53,143.24 v2(48.53,142.19) ; v1(16.67,149.09) 16.82,149.24 CV115.2 15.75,149.83 15.73,149.86 CV107.2 ; v2(100.24,124.52) 100.06,124.52 99.83,124.75 CC68.2 ; v1(269.74,134.16) 269.88,134.02 R69.2 270.54,132.98 Q26.3 ; RC159.2 104.28,132.57 v2(103.83,132.12) ; C748.2 73.27,114.09 v1(73.27,113.61) ; CD39.2 CD38.2 157.39,118.27 157.18,118.06 156.28,118.06 155.73,118.6 v1(155.73,118.73) ; v1(280.85,120.12) 280.85,120.78 R98.1 ; v2(103.18,100.87) 103.16,100.9 RC56.1 ; CV111.2 v1(24.31,149.09) ; v1(128.19,155.65) 128.34,155.65 C8497.2 ; v1(36.54,126.24) 36.56,126.26 36.56,127.29 37.19,127.92 38.34,127.92 38.72,128.3 39.99,128.3 40.7,127.59 C1.2 ; PC483.1 95.04,120.87 94.41,121.5 v1(94.34,121.5) ; CE11.2 v1(173.59,124.62) ; C28.2 207.88,100.62 207.37,101.12 v1(206.86,101.12) ; v1(190.93,135.3) 190.74,135.1 CE14.2 ; CV99.2 15.67,128.96 v1(15.65,128.94) ; CE13.1 173.82,118.74 v1(173.6,118.52) ; PR307.2 v1(183.47,168.2) ; v1(20.86,149.09) 20.86,149.79 RV31.2 ; IT4.1 195.28,132.24 v1(194.96,131.92) ; v1(167.26,114.99) 167.26,115.71 CD15.2 ; v2(106.19,132.73) 106.19,132.63 106.36,132.47 RC209.2 ; RC300.2 123.6,149.01 v1(124.48,149.01) ; RD3.2 CD1.2 162.54,87.48 162.63,87.4 v1(162.63,87.39) ; v1(267.77,108.52) 267.67,108.52 PR110.1 ; v1(267.77,108.52) 268.03,108.26 PR105.1 ; CV113.2 21.06,166.52 v1(20.69,166.89) ; 146.04,163.37 145.66,163.75 145.66,164.13 ; C75.2 v1(267.37,129.07) ; C53.2 v1(298.23,42.32) ; C35.2 220.73,90.46 v1(220.34,90.85) ; v1(53.91,119.62) 53.22,118.93 JLCD.37 ; CC5.2 v1(132.95,137.19) ; v1(138.94,122.82) 141.61,122.82 144.38,120.05 UC4M1.4 ; LE2.2 IT5.1 v1(201.15,119.81) ; CV114.2 25.78,149.11 v1(25.76,149.09) ; SW1.1 262.25,161.82 v1(262.74,161.32) ; 136.7,117.78 CC528.1 ; 136.7,117.78 136.7,117.93 138.45,119.68 138.45,121.49 v1(138,121.94) ; 136.7,117.78 136.52,117.78 135.18,119.12 134.6,119.12 UC8M1.4 ; v1(173.19,103.85) 173.58,103.85 174.26,103.17 CC101.2 C8527.2 ; v1(221.71,101.01) 221.71,100.4 R9468.1 R9467.1 ; CD40.2 156.95,124.37 156.02,125.3 v1(156.02,125.66) ; CD47.2 168.38,128.56 CD11.2 169.12,128.15 v1(169.45,127.82) ; C751.2 177.54,152.37 v1(177.59,152.32) ; C74.2 v1(216.92,128.38) ; v1(246.42,92.68) 246.22,92.88 245.92,92.88 RRE30.2 ; v1(99.46,149.5) 100.55,148.41 100.55,147.54 100.81,147.29 RC410.2 ; CE8.2 CE9.2 v1(186.54,135.3) ; CE17.2 v1(200.46,122.02) ; CE6.2 v1(187.05,111.21) ; CM11.2 RM24.2 v1(255.12,148.5) ; C115.2 C116.2 v1(254.44,152.48) ; D4.1 197.02,105.48 v1(197.53,105.48) ; RC301.2 135.13,113.88 135.41,114.15 135.42,114.15 135.64,114.38 v1(135.64,114.65) 135.79,114.51 RC302.2 ; JU3AC.27 125.7,53.56 v1(125.34,53.92) ; CV92.2 23.8,129.16 v1(23.46,128.82) ; PC318.2 PR313.1 ; PR313.1 v1(185.99,169.48) ; PR313.1 PC319.2 ; C183.2 v1(271.25,154.46) ; 101.71,89.06 101.38,89.39 RC184.2 ; JFPB.3 177.96,77.84 v1(177.96,78.08) ; C68.2 141.82,67.88 v1(141.69,67.75) ; v1(116.58,59.61) 116.34,59.85 JCP.13 ; CV91.2 25.2,129.64 24.82,129.26 v1(24.82,128.81) ; v1(148.57,87.33) CD32.2 ; RC166.1 v1(128.63,154.16) ; v1(222.59,167.49) 222.21,167.88 PC8.2 ; 161.97,131.12 163.18,129.92 CD22.2 161.56,129.5 v1(161.27,129.78) 161.27,129.5 160.75,128.98 159.35,128.98 CRF4.2 ; 161.97,131.12 160.66,131.12 160.37,131.41 CD18.2 ; 161.97,131.12 v1(161.97,132.17) ; CE5.2 v1(180.3,134.6) ; C182.2 v1(266.61,155.3) ; CD42.2 CD48.2 156.7,122.09 156.06,121.46 v1(156.06,120.63) ; CL7.2 254.79,87.67 v1(255.17,88.04) ; R9459.1 R9460.1 v1(269.21,114.7) ; C67.2 248.16,152.05 v1(247.26,152.05) ; RC9.2 119.23,125.84 RC10.2 119.59,126.42 v2(119.83,126.66) ; v1(157.13,132.49) 157.54,132.09 RD12.2 ; v1(160.46,115) 160.68,115.22 CD19.2 ; RC189.2 130.44,147.32 129.93,147.82 v1(129.93,148.09) 129.62,148.09 RC32.1 ; RE7.1 v1(198.1,117.13) 198.46,117.13 IT3.1 ; 145.66,164.13 145.66,164.47 147.44,166.25 v1(149.21,166.25) ; 145.66,164.13 145.64,164.1 C8538.2 ; U17.2 v1(181.22,157.02) ; JTOUCH1.11 v1(252.84,157) ; v1(151.98,111.67) 151.61,111.3 CD46.2 ; v2(101.29,133.03) 101.29,132.44 CC527.1 ; v1(137.61,142.35) 137.61,142.35 138.12,142.86 RC27.1 138.43,142.71 139.15,142.71 CC529.1 ; CV169.2 v1(70.34,157.44) ; RM31.2 CM12.2 268.29,146.48 v1(268.31,146.46) ; RC74.2 110.46,143.94 v1(110.09,144.3) ; v1(173.22,106.22) 172.33,106.22 171.76,106.79 CG3.2 ; v1(130.87,129.19) 130.87,128.46 CC25.2 ; CV97.2 16.56,145.66 16.67,145.77 v1(16.67,145.83) ; RC366.1 v1(115.82,149.02) ; CL11.2 v1(284.91,67.32) ; RC98.2 RC100.2 120,153.58 v1(118.22,151.8) ; CA19.1 v1(172.93,55.33) ; v1(149.46,87.33) CD33.2 ; v1(171.95,170.05) 171.95,170.05 PC304.2 ; CD60.2 v1(173.16,101.58) ; CG4.2 175.24,113.34 175.34,113.44 v1(176,113.44) ; C69.2 v1(219.58,139.75) ; v1(182.15,63.18) 182.1,63.18 181.44,62.52 CA14.2 ; CD58.2 CD57.2 168.51,152.56 v1(168.98,153.03) ; RE32.2 v1(194.55,135.29) ; CD14.2 162.48,118.14 161.97,118.65 161.97,119.15 v1(161.84,119.27) 161.84,119.92 161.33,120.43 CD21.2 ; C34.2 v1(225.25,101.05) ; C73.2 v1(217.04,139.75) ; C750.2 181.25,157.93 v1(181.09,157.78) ; CV103.2 22.79,145.87 v1(22.68,145.97) ; D15.2 279.9,119.19 v1(280.17,119.46) ; CC9.2 73.9,115.96 v1(74.39,115.46) 74.4,115.46 74.91,115.97 CC102.2 ; v2(101.33,97.67) 101.33,97.86 101.68,98.22 RC200.1 ; CV127.2 22.43,149.93 RV28.2 23.32,149.35 v1(23.05,149.09) ; v1(168.18,123.43) 168.26,123.35 CD10.2 ; v1(254.25,85.77) 254.54,86.07 YL1.4 ; v1(24.09,145.88) 24.06,145.85 CV93.2 ; v1(157.07,99.38) 157.29,99.6 CD59.2 ; v2(85.25,118.78) 84.08,118.78 RC143.2 83.98,119.77 RC369.2 ; v1(75.81,152.57) 76.01,152.78 RV2.2 ; C8496.2 133.84,161.07 v1(134.27,161.5) 133.78,162 C8499.2 ; C70.2 v1(220.59,129.88) ; v1(284.09,16.3) 282.8,15.01 D9.2 ; R91.2 v1(255.51,153.96) ; CC94.2 119.49,114.12 v2(119.65,114.28) ; CE12.2 v1(188.45,135.29) ; v1(19.33,166.31) 19.92,165.72 CV105.2 ; v1(295.46,45.75) 295.51,45.71 U8.1 ; RC316.1 164.33,153.59 RC315.1 164.2,153.58 163.7,154.08 v1(163.7,154.72) ; CV179.2 58.16,173.02 v1(58.79,172.39) ; C189.2 v1(269.49,127.43) ; PC3.2 PC2.2 v1(277.37,108.69) ; CE16.2 v1(198.1,116.11) ; RC307.2 RC84.1 106.15,143.75 v1(106.15,144.3) ; v1(279.86,108.72) 279.22,108.72 PD5.2 ; CA13.2 181.52,59.14 v1(181.62,59.24) ; v1(20.8,131.2) 21.13,130.87 CV104.2 ; R9461.1 v1(201.72,102.71) ; 152.01,122.6 152.01,123.76 v1(152.18,123.93) ; CRF3.2 157.74,114.27 v1(157.46,113.99) ; v1(242.31,80.95) 242.31,81.07 242.81,81.57 RRE26.2 RRE27.2 ; v1(183.38,135.24) 183.5,135.12 CE1.2 ; v1(19.16,149.16) 19.16,149.45 CV109.2 ; C72.2 v1(217.91,131.35) ; JFPB.2 176.96,75.08 ; RC363.2 110.73,133.2 110.61,133.32 v2(110.43,133.32) ; 152.01,131.11 152.01,132.24 v1(151.78,132.48) ; CE10.2 v1(197.42,129.64) ; RM33.2 259.2,151.43 v1(259.58,151.81) ; R105.2 277.51,113.86 v1(277.4,113.97) ; v2(100.24,121.83) 99.61,121.21 PC477.1 ; RC152.2 100.57,104.19 v2(100.27,104.48) ; QE1.3 v1(197.59,122.19) ; CC4.2 124.06,145.9 v1(123.6,145.45) ; RRE29.2 v1(248.27,81.11) ; CE4.2 v1(178.21,134.6) ; C8498.2 127.32,163.93 127.78,164.38 128.39,164.38 v1(128.64,164.64) ; v1(157.97,87.33) RD4.2 ; RV152.2 v1(54.13,175.31) ; CD3.2 v1(161.65,87.33) ; CC3.2 v1(123.6,142.83) ; RV25.2 21.9,145.65 v1(22.06,145.81) ; 20.25,129.55 v1(20.25,128.94) ; v1(150.35,87.33) RD16.2 ; R9455.1 v1(272.03,116.25) ; R9462.1 v1(206.04,102.71) ; C71.2 v1(218.8,131.35) ; RD24.2 v1(176.27,133.02) ; CV141.2 v1(83.67,143.54)
  GND1 w0.076: 126.26,124.85 126.26,124.4
  IN2 w0.076: 126.26,124.79 126.26,124.5
  IN2 w0.508: v1(181.85,55.02) 182.43,55.61 184.25,55.61 185.43,54.43 192.42,54.43 v1(192.74,54.11)
  IN3 w0.508: v1(181.62,59.24) 181.26,59.6 181.26,62.29 v1(182.15,63.18)
  BOTTOM w0.076: UC1.AN43 v2(116.09,112) ; v2(122.1,98.1) 121.96,98.31 121.96,98.31 121.56,98.71 121.56,98.73 UC1.BB67
  BOTTOM w0.114: UV8.D8 25.7,159.89
  BOTTOM w0.152: UV3.B14 44.5,153.04 43.77,153.04 v2(43.76,153.03) ; UV3.B16 43.95,151.4 v2(43.94,151.39) ; v2(113.63,130.75) 113.06,130.75 112.86,130.96 112.86,131.53 112.65,131.74 UC1.AF10 111.79,131.42 110.77,131.42 110.71,131.36 ; 115.38,128.65 115.38,129.15 ; 110.28,130.1 109.84,130.1 109.84,130.09 109.72,130.09 ; UV3.F12 46.93,154.2 46.93,153.62 46.81,153.49 46.81,153.27 UV3.F14 ; 110.2,130.73 110.12,130.73 110.1,130.75 109.74,130.75 ; 109.8,131.42 110.23,131.42 ; v2(43.52,149.92) 43.6,149.84 44.49,149.84 UV3.B18 ; 111.35,130.75 110.74,130.75 ; 111.85,130.75 112.44,130.75 ; UV3.B12 44.38,154.75 43.78,154.75 43.64,154.61 v2(43.63,154.61) ; UC1.BB60 121.11,103.19 121.98,103.19 v2(122.01,103.17)
  BOTTOM w0.178: UC1.BB30 121.74,120.56 122.13,120.56 v2(122.26,120.69) ; v2(115.34,95.66) 115.26,95.75 115.26,96.48 UC1.AM71 ; UC1.BB55 121.48,105.81 121.97,105.81 v2(122.01,105.85) ; UC1.BB43 122.02,112.98 v2(122.04,112.96) ; v2(112.38,95.66) 112.44,95.68 112.6,95.84 UC1.AG71 ; UC1.H71 103,95.84 v1(102.92,95.76) ; UC1.BB38 121.1,115.59 122.05,115.59 v2(122.08,115.62) ; UC1.BB26 121.49,122.92 122,122.92 v2(122.05,122.97) ; UC1.AT71 v2(117.61,95.92) ; UC1.BB34 121.36,117.93 122.65,117.93 v2(122.69,117.89) ; v2(122.01,126.69) 121.98,126.66 UC1.BB18 ; v2(122.01,100.86) 122,100.86 121.62,100.86 UC1.BB64
  BOTTOM w0.203: UC1.K71 104.36,95.86 v1(104.37,95.76) ; v2(101.65,137.67) 101.64,137.66 UC1.F1 ; UC1.AL66 114.95,99.78 114.99,99.83 114.99,100.21 114.95,100.25 UC1.AL65 114.99,100.38 114.99,100.84 114.95,100.89 UC1.AL64 ; v2(104.35,121.59) 104.26,121.59 103.78,122.06 UC1.J25 ; UV3.B10 44.51,156.2 44.46,156.15 v2(43.96,156.15) ; UC1.K70 104.36,97.75 v2(104.15,97.9) ; UC1.AM68 114.77,98.71 114.73,98.76 114.45,98.76 114.08,98.39 UC1.AK68 113.81,98.39 UC1.AH67 ; UC1.AM68 115.64,98.71 115.67,98.74 115.97,98.74 116,98.71 UC1.AP68 116.87,98.71 116.9,98.74 117.19,98.74 117.22,98.71 UC1.AT68 118.03,98.71 118.2,98.76 118.39,98.76 118.43,98.72 UC1.AV68 ; UC1.AM68 115.16,98.9 v2(115.46,99.2) ; v2(99.55,137.79) 99.55,137.67 99.75,137.46 UC1.C1 ; UC1.AU20 119.08,126.18 119.11,126.2 ; UC1.J35 v2(103.97,116.57) ; v2(46.94,146.2) 46.54,146.6 UV3.F22 ; UC1.J32 v2(103.97,118.4) ; UC1.AF63 112.36,101.75 113.06,101.75 UC1.AH63 ; UC1.AV1 118.93,137.52 v2(118.98,137.57) ; UC1.F40 v2(102.56,114.75) UC1.F38 ; v1(15.68,133.92) 15.68,133.92 UV5.T1 ; 21.71,159.9 22.09,160.28 22.09,160.91 21.63,161.37 v1(21.53,161.37) ; UC1.D48 UC1.D47 100.75,110.12 100.75,110.51 100.77,110.53 100.77,110.82 100.75,110.85 100.75,111.23 UC1.D45 UC1.D44 ; UV3.C32 44.94,139.84 v2(44.7,139.6) ; UC1.F37 v2(102.56,116.57) UC1.F35 ; UC1.J28 v2(101.84,120.23) ; UC1.K63 103.74,101.93 UC1.K61 ; UC1.F33 v2(102.56,118.4) UC1.F32 ; v2(44.28,138.86) 44.28,138.87 43.71,139.44 43.71,140.57 UV3.A30 ; 119.11,126.2 119.11,125.91 119.14,125.88 UC1.AW21 119.14,125.08 119.11,125.05 119.11,124.76 119.14,124.73 UC1.AW23 119.14,123.76 119.11,123.73 119.11,123.43 119.14,123.4 UC1.AW26 119.14,122.53 119.11,122.5 119.11,122.2 119.14,122.17 UC1.AW28 119.14,121.3 119.11,121.27 119.11,120.98 119.14,120.95 UC1.AW30 119.14,120.08 119.11,120.05 119.11,119.75 119.14,119.72 UC1.AW32 119.14,118.9 v2(118.65,118.4) 119.02,118.03 UC1.AW34 119.14,117.55 119.11,117.52 119.11,117.22 119.14,117.19 UC1.AW36 119.14,116.32 119.11,116.29 119.11,116 119.14,115.97 UC1.AW38 119.14,115.25 v2(118.63,114.75) 119.1,114.28 UC1.AW41 119.14,113.82 119.11,113.79 119.11,113.5 119.14,113.46 UC1.AW43 119.14,112.59 119.11,112.56 119.11,112.27 119.14,112.24 UC1.AW45 119.14,111.37 119.11,111.34 119.11,111.04 119.14,111.01 UC1.AW47 119.14,110.2 119.11,110.17 119.11,109.88 119.14,109.85 UC1.AW49 119.14,108.94 119.11,108.91 119.11,108.62 119.14,108.59 UC1.AW51 119.14,107.78 119.11,107.75 119.11,107.46 119.14,107.42 UC1.AW53 119.14,106.55 119.11,106.52 119.11,106.23 119.14,106.2 UC1.AW55 119.14,105.33 119.11,105.3 119.11,105 119.14,104.97 UC1.AW57 119.14,104.05 119.11,104.02 119.11,103.73 119.14,103.7 UC1.AW60 119.14,102.82 119.11,102.79 119.11,102.5 119.14,102.47 UC1.AW62 119.14,101.6 119.11,101.57 119.11,101.27 119.14,101.24 UC1.AW64 119.09,100.71 119.09,99.75 UC1.AW66 119,99.48 119.09,99.39 119.09,99.38 v2(119.27,99.2) UC1.AY66 UC1.BA66 ; 119.11,126.2 119.14,126.23 UC1.AW18 119.14,127.15 119.11,127.18 119.11,127.47 119.14,127.5 UC1.AW16 119.14,127.9 v2(118.58,128.46) 119.14,129.02 UC1.AW14 119.14,129.57 119.11,129.6 119.11,129.89 119.14,129.92 UC1.AW12 119.14,130.7 v2(118.63,131.2) 118.93,131.5 UC1.AW10 119.14,131.99 119.11,132.02 119.11,132.31 119.14,132.34 UC1.AW8 119.14,133.14 119.11,133.17 119.11,133.46 119.14,133.49 UC1.AW6 ; UV3.H20 47.93,148 47.42,147.49 47.36,147.49 47.35,147.48 47.24,147.48 47.14,147.38 ; v2(119.65,109.4) 119.65,108.95 UC1.AW50 ; v2(114.54,134.65) 114.23,134.96 UC1.AJ4 ; 47.14,147.38 47.14,147.55 46.54,148.15 UV3.F20 ; 47.14,147.38 v2(47.14,147.33) ; v2(112.26,137.67) 112.24,137.66 UC1.AF1 ; UC1.F42 v2(102.56,112.92) ; UC1.J38 v2(103.97,114.75) ; UV3.J27 v2(48.53,142.19) ; UV3.E28 45.73,141.8 v2(45.34,142.19) ; UC1.BA2 UC1.BA1 ; UC1.G10 v2(102.56,131.2)
  BOTTOM w0.229: v2(43.64,157.86) 43.64,157.83 43.66,157.81 44.52,157.81 UV3.B8 ; 151.7,170.36 PU701.19
  BOTTOM w0.23: UV3.K32 49.81,140.13 49.81,139.87 v2(50.04,139.63)
  BOTTOM w0.25: UV3.F18 46.22,149.48 46.07,149.48 v2(46.05,149.46) ; UV3.J31 48.94,140.28
  BOTTOM w0.254: v2(115.44,110.17) UC1.AM46 114.59,110.17 UC1.AL48 ; PC636.1 PR642.2 PR643.2 v1(122.89,168.46) ; UC1.AW57 v2(119.65,104.51) UC1.BA57 ; UC1.R13 106.77,129.81 106.22,130.36 v2(106.22,130.58) 106.22,130.57 106.17,130.19 105.71,129.83 UC1.N13 ; UC1.U66 v2(108.13,99.36) UC1.U67 ; v1(25.15,167.85) 25.15,167.85 25.58,168.28 26.83,168.28 27.09,168.54 CV150.2 ; UC1.AW10 v2(119.65,131.5) UC1.BA10 ; UC1.AP35 v2(116.73,116.57) ; v2(101.77,106.5) 101.77,106.71 UC1.E53 ; UC1.AB21 110.09,124.31 v2(110.15,124.25) ; v2(116.68,133.93) 116.68,134.09 UC1.AR5 ; UC1.AM55 v2(115.44,105.6) ; UC1.D6 100.3,134.19 v2(100.27,134.22) 100.14,134.34 100.14,134.38 100.09,134.43 UC1.C5 ; UC1.K63 v2(104.45,101.29) UC1.K64 ; v1(64.65,50.15) 64.65,50.78 PR448.1 ; v1(64.65,50.15) 64.57,50.15 63.89,50.83 PC408.2 ; v1(64.65,50.15) 64.24,49.74 PR418.1 ; UC1.BA49 v2(119.65,109.4) UC1.AW49 ; QV8.1 80.99,154.25 80.46,154.78 v1(80.26,154.78) ; UV3.B24 43.95,145 v1(43.94,145.01) ; v2(113.06,125.98) 112.7,126.34 UC1.AG19 ; v2(113.06,125.98) 113.35,125.69 UC1.AJ20 ; v2(113.06,125.98) UC1.AG20 ; v2(103.18,100.87) 103.18,101 UC1.G63 ; UC1.AW41 v2(119.65,114.28) UC1.BA41 ; v2(118.63,114.75) UC1.AU38 ; UC1.T15 107.81,128.94 v2(108.31,129.45) ; UC1.B10 v2(100.27,131.74) UC1.D10 UC1.D11 ; UC1.F23 102.16,123.45 102.81,124.1 UC1.G22 102.56,124.6 102.56,124.74 ; UC1.AN35 v2(116.09,116.57) ; PR447.1 PR446.1 66.5,50.88 v1(67.04,50.35) PR445.1 ; v1(121.48,171.19) 121.32,171.03 PC601.2 ; v2(47.34,140.03) UV3.G31 ; UC1.AR15 v2(117.36,128.46) ; v2(101.33,97.67) 101.13,97.87 UC1.D69 UC1.F68 ; PRT6.2 v1(78.54,52.31) ; UC1.N65 106.28,100.77 v2(106.28,101.25) ; PC606.2 111.51,163.02 v1(111.11,163.43) ; UC1.G60 v2(102.56,102.86) ; UC1.D66 v2(100.27,99.53) UC1.B66 ; UC1.AD20 UC1.AD19 110.74,126.34 UC1.AB18 109.7,126.59 v2(109.7,126.58) ; PR640.2 119.16,174.35 v1(119.21,174.3) ; v1(64.85,72.88) 64.95,72.79 PU402.6 ; v2(101.84,130.28) 101.84,130.42 UC1.E11 ; UC1.D34 100.68,116.97 v2(100.27,116.97) 99.86,116.97 UC1.B34 ; UC1.AR53 v2(117.36,106.52) ; UC1.F13 102.08,129.81 101.91,129.49 v2(101.95,129.38) ; UC1.AW62 v2(119.65,102.03) UC1.BA62 ; v1(58.12,54.36) 58.12,54.79 PR420.1 ; v1(58.12,54.36) 57.66,53.91 PR419.1 ; v1(58.12,54.36) 58.5,53.98 PC409.1 ; UC1.AM13 114.62,129.41 v2(114.62,129.38) ; UV3.AH10 63.91,155.97 v2(63.91,155.18) ; v2(101.85,110.17) 101.85,110.29 UC1.E46 ; v1(36.54,126.24) 36.54,126.58 37.05,127.08 38.21,127.08 39.33,128.2 39.33,133.21 40.51,134.39 42.66,134.39 42.92,134.13 QV10.1 42.36,133.9 42.13,133.68 42.13,132.86 41.88,132.6 QV10.4 ; R26.2 57.39,119.16 v1(57.64,119.16) ; v2(116.73,126.63) 116.37,127.07 UC1.AP18 ; UC1.AP58 v2(116.73,103.77) ; v2(104.15,97.9) UC1.K68 UC1.K67 v2(104.45,99.34) ; JDIMM2.19 153.94,95.75 154.51,95.17 v1(154.51,94.86) ; UC1.AF2 112.24,135.78 112.42,135.61 112.42,135.61 ; UC1.AT28 v2(117.36,120.23) UC1.AR28 ; UC1.AR46 v2(117.36,110.17) ; 106.76,125.04 UC1.P21 ; UC1.G58 v2(102.56,103.77) ; PC604.2 110.19,170.54 v1(109.76,170.97) 109.79,170.97 110.24,171.43 PC605.2 ; v2(115.46,99.2) 114.97,99.69 UC1.AL66 ; UC1.AT58 v2(117.36,103.77) UC1.AR58 ; UC1.AK68 113.93,97.96 v2(113.88,97.91) 113.88,97.89 113.93,97.84 UC1.AK69 ; v1(101.07,95.76) 101.2,95.88 UC1.E71 ; UC1.AN38 v2(116.09,115.66) UC1.AN37 ; PR436.1 71.86,54.49 v1(71.67,54.68) 71.38,54.39 PC424.2 ; UV3.C1 44.94,162.42 v2(44.73,162.63) ; UC1.AW6 119.18,133.92 v2(119.65,133.92) UC1.BA6 120.52,133.76 120.93,133.76 UC1.BB6 ; v2(43.56,143.18) 43.7,143.31 44.13,143.31 44.21,143.4 UV3.B26 ; v2(118.65,118.4) UC1.AU32 ; UC1.E65 v2(101.29,99.91) ; 112.42,135.61 v2(112.46,135.61) ; 112.42,135.61 112.24,135.42 UC1.AF4 ; PR413.1 70.22,66.15 70.48,65.89 v1(70.48,65.3) ; UC1.AN32 v2(116.09,118.4) ; UC1.J11 v2(103.83,130.29) UC1.J13 ; UC1.AT4 117.55,135.3 117.75,135.51 v2(117.75,135.63) 117.55,135.83 UC1.AT2 ; v1(71.61,56.5) 71.38,56.27 PC417.2 ; PR805.2 v1(194.63,176.35) ; UC1.AL45 114.59,112 UC1.AM43 v2(115.44,112) ; UC1.F2 101.64,135.78 v2(101.81,135.6) 101.64,135.42 UC1.F4 ; v2(113.63,130.75) 113.63,130.07 113.35,129.78 UC1.AH13 ; UC1.L18 105.17,126.99 v2(105.52,127.34) 105.39,127.34 105.09,127.64 UC1.L17 ; v2(100.24,121.83) UC1.D26 100.74,121.87 UC1.D25 UC1.C25 ; v2(108.86,127.28) 108.9,127.28 UC1.Y17 ; UV3.AG27 63.34,142.24 v2(63.6,141.98) 63.78,141.8 UV3.AH28 ; PC619.1 118.22,163.3 117.58,162.67 v1(117.53,162.67) ; v2(43.55,161.44) 43.99,161 UV3.A3 ; UC1.AK16 114.56,128.57 v2(114.67,128.57) ; UC1.AP68 v2(116.43,98.1) UC1.AP70 ; UC1.A5 98.46,134.8 v2(97.55,135.7) ; RC6.2 87.76,106.1 v1(87.76,106.08) ; PR440.1 64.42,65.92 ; PC128.2 221.83,116.44 PC122.2 v1(221.47,115.37) 222.1,115.37 PR132.2 ; UC1.B71 UC1.A70 98.41,96.52 v2(98.41,96.43) ; v2(113.62,101.29) UC1.AK63 UC1.AM61 v2(115.44,101.94) ; v2(113.62,101.29) UC1.AH64 ; v2(113.62,101.29) UC1.AH63 ; UC1.T4 106.94,135.42 v2(107.12,135.6) 106.94,135.78 UC1.T2 ; v2(106.33,124.29) 105.9,124.72 UC1.N21 ; UC1.L4 104.29,135.42 v2(104.47,135.6) 104.29,135.78 UC1.L2 ; UC1.AR50 v2(117.36,108.34) UC1.AR52 v2(117.36,107.43) ; UC1.L20 105.23,125.69 v2(105.56,126.02) 105.88,126.34 UC1.N19 ; UC1.U64 v2(108.13,101.31) UC1.U63 ; UC1.AU15 118.29,128.86 v2(118.58,128.46) ; UC1.B18 v2(100.27,126.78) UC1.D18 ; 48.94,140.28 v2(48.94,139.98) ; UC1.AL2 UC1.AL4 114.89,135.01 v2(114.54,134.65) ; v2(103.19,126.63) UC1.H18 103.66,127.24 104.08,127.18 UC1.K18 ; UC1.U70 v2(108.13,97.41) UC1.U69 ; UC1.D30 v2(100.27,119.35) UC1.B30 ; v2(104.25,124.37) 104.23,124.35 UC1.K22 ; UC1.AR42 v2(117.36,112.92) UC1.AT42 ; v2(117.36,130.29) UC1.AR11 ; PC463.2 v1(77.07,96.91) ; v2(62.05,142.13) 62.05,142.28 UV3.AE27 ; UC1.BA18 v2(119.83,126.66) UC1.AW18 ; UC1.AP10 116.71,132.02 v2(116.71,132.13) 117,132.42 UC1.AR8 ; v1(56.9,57.61) 57.03,57.74 PC411.1 ; UC1.G43 v2(102.56,112) 102.81,111.75 UC1.G45 ; UC1.D39 100.56,114.61 v2(100.25,114.61) 99.98,114.61 UC1.B39 ; v2(61.31,158.22) 61.69,158.6 UV3.AE7 ; UC1.AR43 v2(117.36,112) ; UC1.AP63 v2(116.73,101.03) ; UC1.AL38 113.97,115.66 v2(113.65,115.98) ; UC1.N68 v2(106.31,98.71) ; UC1.AL58 v2(115.29,104.69) ; UC1.AW53 v2(119.65,106.99) UC1.BA53 ; UC1.B44 v2(100.27,111.92) UC1.D44 ; v1(117.53,162.67) 117.89,162.31 118.16,162.31 PC637.1 ; v1(117.53,162.67) 117.33,162.87 PC622.2 ; UC1.G52 v2(102.56,107.43) ; UC1.P19 106.7,126.34 106.35,125.98 v2(106.33,125.98) 106.62,125.69 UC1.P20 ; UC1.AP38 v2(116.73,114.75) ; UV3.K22 49.39,147.15 49.39,147.21 49.35,147.25 v2(49.36,147.25) ; UC1.BA32 v2(119.65,119.24) UC1.AW32 ; UC1.E50 v2(101.29,108.34) ; v2(43.49,148.14) 43.55,148.2 UV3.B20 ; UC1.AU20 v2(118,125.72) UC1.AT20 ; 108.9,132.39 UC1.W9 ; 108.9,132.39 108.57,132.05 v2(108.29,132.05) UC1.U10 ; 108.9,132.39 108.99,132.39 109.37,132.76 109.37,133.87 UC1.W6 ; v2(116.05,114.7) 116.05,114.64 UC1.AN40 ; UC1.E56 v2(101.29,104.69) ; 102.56,124.74 UC1.F22 ; 102.56,124.74 v2(102.56,124.77) ; v2(101.95,129.38) 101.99,129.33 103.12,129.33 103.46,128.99 UC1.H15 ; v2(101.95,129.38) 101.95,129.34 101.57,128.92 UC1.E15 ; UC1.B14 100.09,129.38 100.68,129.36 UC1.D14 101.17,129.26 v2(101.29,129.38) ; UC1.AR16 v2(117.36,127.55) ; UC1.AW14 v2(119.8,129.08) UC1.BA14 ; v2(43.48,159.61) 43.63,159.46 44.47,159.46 UV3.B6 ; UC1.AM21 114.51,125.26 UC1.AK21 114.08,124.84 113.89,124.84 v2(113.58,124.53) 113.77,124.35 UC1.AK22 ; v2(102.46,109.32) 102.61,109.36 UC1.G48 ; UC1.AM45 v2(115.44,111.09) ; v2(101.92,99.91) 102.1,100.09 UC1.F65 UC1.G65 ; UC1.AT63 v2(117.36,101.03) UC1.AR63 ; UV7.M1 19.36,160.75 19.36,161.3 18.92,161.74 18.92,161.76 ; v2(107.12,128) 107.09,127.97 107.07,127.97 106.74,127.64 UC1.P17 ; UC1.E6 v2(101.29,133.03) ; UC1.L11 v2(105.22,131.42) ; v1(152.58,170.24) 152.46,170.36 151.7,170.36 ; UC1.AL35 113.88,117.49 113.65,117.25 v2(113.65,117) ; v1(48.17,162.2) 48.14,162.2 UV3.H2 ; UC1.AN23 v2(116.09,122.98) ; UC1.G55 v2(102.56,105.6) ; PR425.1 v1(72.37,62.57) ; v2(46.94,144.6) 46.93,144.6 UV3.F24 ; UC1.AF17 v2(112.23,127.93) 112.51,127.64 UC1.AG17 ; v2(46.26,161.88) 46.28,161.88 46.28,161.83 46.54,161.56 UV3.F2 ; UC1.D48 100.58,109.64 v2(100.22,109.64) 100.06,109.64 99.86,109.44 UC1.B48 ; UC1.AK11 114.13,131.22 114.47,131.48 v2(114.54,131.47) ; UC1.AH6 113.53,133.98 v2(113.61,133.98) ; v1(20.68,171.91) UV9.4 ; UC1.AM25 v2(115.44,122.06) ; v2(109.96,102.65) 110.14,102.65 110.68,102.11 UC1.AD62 ; UC1.AF15 111.75,128.94 v2(111.39,128.58) UC1.AD16 UC1.AB16 ; UC1.AG18 UC1.AG17 ; UC1.AG17 112.73,127.64 113.39,126.99 UC1.AJ18 UC1.AK18 ; UC1.D58 v2(100.27,104.48) UC1.B58 ; UC1.AT23 v2(117.36,122.98) UC1.AR23 ; UC1.AF63 111.75,101.28 ; 111.75,101.28 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 111.01,97.41 v2(110.84,97.41) ; 111.75,101.28 v1(111.75,101.28) ; v1(73.06,99.98) 73.14,99.9 PU404.6 ; UC1.BA71 120.95,96.14 v2(121.17,95.92) 121.42,96.17 UC1.BB70 ; v1(215.07,106.81) 215.07,106.56 214.31,105.8 PC125.1 ; UV3.F8 46.54,157.83 v2(46.92,158.21) 47.33,157.8 UV3.G8 ; UC1.AP23 v2(116.73,122.98) ; UC1.AN30 v2(116.09,119.32) ; UC1.AP28 v2(116.73,120.23) ; v2(121.03,137.7) 121.03,137.14 UC1.BA1 ; v2(109.39,124.28) 109.25,124.41 UC1.Y21 ; UC1.AT35 v2(117.36,116.57) UC1.AR35 ; UC1.AA68 v2(109.96,98.71) ; v2(43.94,146.6) UV3.B22 ; UC1.AR45 v2(117.36,111.09) ; v1(78.37,151.42) 78.45,151.5 78.45,152.31 78.94,152.8 QV8.4 ; v2(109.96,100.66) UC1.AA65 ; UC1.K66 v2(104.45,99.99) UC1.K65 ; v2(115.46,100.12) 115.23,100.34 UC1.AL65 ; UC1.AN58 v2(116.09,103.77) ; UC1.AR55 v2(117.36,105.6) ; v2(98.13,98.53) 98.27,98.53 98.6,98.85 UC1.A67 ; UC1.AB15 110.09,128.96 v2(110.56,129.43) 110.91,129.78 UC1.AD13 ; UC1.AM8 v2(115.46,132.12) ; v2(113.62,99.38) UC1.AH67 ; UC1.BA28 v2(119.65,121.74) UC1.AW28 ; UC1.K16 UC1.L16 105.43,127.92 v2(105.52,127.92) ; UC1.V16 108.42,128.26 108.08,127.93 v2(108.03,127.93) ; v2(47.74,156.61) 47.34,156.21 UV3.G10 ; PC402.2 69.01,53.95 69.01,53.68 v1(69.37,53.32) PC401.2 ; PR442.1 60.08,65.18 v1(60.41,65.51) 60.97,64.95 PC430.1 ; UC1.AR48 v2(117.36,109.26) ; v2(102.56,112.92) UC1.J42 ; v2(105.22,133.32) UC1.L8 ; UC1.AG21 111.82,124.25 v2(110.76,124.25) 110.93,124.42 UC1.AD21 ; UC1.BA23 v2(119.65,124.22) UC1.AW23 ; UC1.BA36 v2(119.65,116.76) UC1.AW36 ; v1(63.79,70.31) 63.79,69.48 PC444.2 ; UC1.F8 101.95,132.18 v2(101.97,132.11) ; PR444.1 PR443.1 v1(70.09,50.93) ; UC1.D53 v2(100.27,106.96) UC1.B53 ; UC1.AJ15 113.39,128.94 v2(113.05,129.28) ; UC1.AA2 109.59,135.78 109.74,135.63 v2(109.8,135.63) 109.59,135.42 UC1.AA4 ; UC1.AL28 114.57,121.15 UC1.AK27 113.76,121.26 v2(113.68,121.26) ; v2(46.09,159.84) 46.35,159.57 46.36,159.57 UV3.F6 ; UC1.N6 v2(106.16,134.61) 106.43,134.34 UC1.R6 ; UC1.AP32 v2(116.73,118.4) ; UC1.B22 99.97,124.52 v2(100.24,124.52) 100.57,124.52 UC1.D22 101.51,125.04 UC1.E21 ; UC1.AB8 v2(110.43,133.32) ; v2(113.7,133.35) 113.8,133.35 UC1.AK8 ; v2(119.13,95.66) 119,95.79 UC1.AV71 UC1.AV70 UC1.AV69 119.06,97.79 v2(119.06,98.24) 118.99,98.27 UC1.AV68 118.85,98.72 119.27,99.17 v2(119.27,99.2) ; v2(106.19,132.73) 106.06,131.98 UC1.N10 ; UC1.AN33 v2(116.09,117.49) ; v2(119.65,111.8) UC1.BA45 ; UC1.AD8 111.17,133 111.64,133.3 v2(111.64,133.32) ; UC1.AN63 115.8,101.37 115.94,101.23 115.94,101.21 v2(116.09,101.03) ; UC1.AL32 v1(113.27,119.32) ; UC1.AP42 v2(116.73,112.92) ; UC1.G5 v2(102.56,133.95) ; v2(101.29,101.94) 101.23,102 UC1.D62 v2(100.27,102) UC1.B62 ; UC1.AN42 v2(116.09,112.92) ; UC1.F28 v2(101.92,121.15) UC1.F27 ; UC1.G6 v2(102.56,133.03) ; UC1.AL55 v2(115.37,106.52) ; UC1.G66 v2(102.56,98.9) ; UC1.AL52 v2(115.42,108.34) ; v2(18.92,154.7) 19.26,154.36 19.26,154.34 UV7.M9 ; UC1.J8 v2(103.83,132.12) ; UC1.AT56 v2(118,104.69) ; UC1.E18 v2(101.29,126.63) ; UC1.AM60 v2(115.44,102.86) ; UC1.AN28 v2(116.09,120.23) ; UC1.AM27 v2(115.44,121.15) ; v2(118.63,131.2) UC1.AU10
  BOTTOM w0.3: v2(52.41,141.87) 52.42,141.87 52.42,141.91 52.14,142.2 UV3.N27
  BOTTOM w0.305: UV3.T6 54.54,159.47 54.86,159.79 54.88,159.79 v2(54.94,159.85) ; JDIMM1.43 v1(165,102.95) ; v1(259.83,156.51) 260.2,156.14 JWLBT.36 ; 21.71,135.16 21.71,135.16 v1(22.11,134.76) ; JDIMM1.133 164.9,132.35 v1(165.05,132.5) ; CV95.2 26.09,145.81 v1(25.93,145.97) ; JDIMM1.9 164.97,92.75 v1(165.05,92.67) ; v2(27.71,136.37) 27.31,135.97 UV5.B3 ; v1(27.71,156.36) 27.71,156.3 27.31,155.9 UV8.B3 ; v2(25.3,154.7) 24.91,154.32 UV8.E1 ; v2(25.3,154.7) 24.91,155.09 UV7.E8 ; v2(25.3,154.7) 25.7,154.3 UV8.D1 ; JDIMM1.38 v1(170.36,101.45) ; v1(23.71,134.76) 23.71,134.76 UV5.G1 ; JDIMM1.37 v1(161.98,101.15) ; v1(23.11,161.35) 23.11,160.9 UV7.G1 23.31,160.69 v1(23.71,160.29) ; v1(170.37,141.05) 171.75,141.05 JDIMM1.162 ; UV8.G8 23.31,159.9 23.71,160.29 v1(23.71,160.29) ; JDIMM1.189 164.9,149.15 v1(164.96,149.21) ; UV3.M32 51.34,140.11 v1(51.8,139.66) ; JDIMM1.127 163.55,130.55 167.27,130.55 v1(167.34,130.48) ; v2(53.68,157.81) 53.68,157.7 53.6,157.61 53.6,157.61 53.33,157.34 53.32,157.34 53.14,157.16 UV3.P9 ; JDIMM1.61 164.67,108.35 v1(164.93,108.09) ; v2(48.01,153.38) 48.02,153.38 48.02,153.24 48.08,153.1 48.08,152.86 UV3.H14 ; JDIMM1.32 v1(170.33,99.65) ; UV8.A9 28.11,161.1 27.87,161.34 27.56,161.34 ; v1(23.71,160.29) 24.11,160.69 UV8.F9 ; UV5.E8 v2(25.32,139.55) 25.32,139.56 UV5.D8 ; UV3.V18 56.54,149.6 56.85,149.29 56.85,149.29 v2(56.84,149.29) ; v2(25.29,134.78) UV5.E2 ; v2(25.29,134.78) 24.91,134.4 UV5.E1 ; v2(25.29,134.78) UV5.D1 ; JDIMM1.196 171.75,151.25 v1(170.37,151.25) ; v2(52,148.95) 51.97,148.95 51.97,148.97 51.99,149 51.97,149.02 UV3.N18 ; v1(165.09,133.95) 164.9,134.15 163.55,134.15 JDIMM1.139 ; JWLBT.51 v1(256.45,164.12) ; JDIMM1.150 171.75,137.45 v1(170.36,137.45) ; UV5.B9 27.31,140.72 27.65,140.38 v2(27.7,140.38) 27.7,140.33 28.11,140.74 UV5.A9 ; v1(166.17,97.62) 166.1,97.7 165,97.7 164.85,97.55 163.55,97.55 JDIMM1.25 ; UV3.F14 46.5,153 v2(46.12,153.38) ; v1(165.11,141.13) 164.72,140.75 163.55,140.75 JDIMM1.161 ; JDIMM1.63 162.45,108.95 v1(162.19,109.21) 162.52,109.55 JDIMM1.65 ; JDIMM1.13 164.86,93.95 v1(164.92,93.89) 164.92,93.83 164.9,93.81 164.9,93.65 164.59,93.35 JDIMM1.11 ; v2(62.73,154.56) 62.77,154.6 UV3.AG12 ; v2(17.3,140.35) 17.71,140.76 UV5.P9 ; v2(54.11,147.17) UV3.T21 ; JDIMM1.3 v1(165.03,90.95) ; UV5.M1 19.31,134.36 v2(18.91,134.76) ; JDIMM1.145 163.55,135.95 v1(165,135.95) ; v1(23.05,149.09) 23.17,149.2 23.17,149.23 23.5,149.56 CV130.2 ; v1(46.06,151.74) 46.05,151.74 46.05,151.76 46.17,151.64 46.3,151.64 UV3.F16 ; JDIMM1.31 163.55,99.35 v1(164.92,99.35) ; UV3.R17 v2(53.11,150.17) ; JDIMM1.26 v1(170.36,97.85) ; JWLBT.1 268.95,162.69 268.95,163.77 v1(269.27,164.09) ; v1(263.45,164.12) JWLBT.23 ; JDIMM1.138 171.75,133.85 170.3,133.85 v1(170.23,133.78) ; UV3.P25 53.39,144.2 v2(53.74,143.84) 54.1,144.2 UV3.T25 ; JDIMM1.66 170.4,109.85 v1(170.09,110.16) ; UV3.T32 v1(54.54,139.59) ; v1(170.33,132.71) 170.4,132.65 171.75,132.65 JDIMM1.134 ; JDIMM1.190 171.75,149.45 172.93,149.45 v1(173.11,149.27) ; JDIMM1.71 164.91,111.35 v1(165.07,111.19) ; JDIMM1.178 171.75,145.85 170.46,145.85 v1(170.39,145.91) ; UV3.T16 v2(54.11,151.83) ; v2(57.14,141.89) 56.94,142.1 UV3.W27 ; JDIMM1.195 v1(164.98,150.95) ; JDIMM1.49 163.55,104.75 165,104.75 v1(165.02,104.72) ; v2(52.63,139.61) 52.94,139.92 UV3.P32 ; v1(170.37,144.05) 171.75,144.05 JDIMM1.172 ; v1(162.13,148.48) 163.49,148.48 JDIMM1.187 ; v1(164.98,144.78) 164.55,144.35 JDIMM1.173 ; JWLBT.39 v1(259.45,164.12) ; 25.7,159.89 25.7,159.86 25.36,159.52 v2(25.29,159.52) 25.16,159.65 25.16,159.65 UV7.E2 ; v1(162.08,142.81) 162.34,142.55 JDIMM1.167 ; JDIMM1.19 164.66,95.75 v1(165.02,96.1) ; v1(173.14,143.45) 171.75,143.45 JDIMM1.170 ; UV5.B1 27.31,134.31 v1(27.7,133.93) ; CL13.2 266.02,95.76 v1(266.02,95.13) ; JDIMM1.54 v1(170.39,106.25) ; JWLBT.57 v1(254.95,161.45) ; JWLBT.24 v1(263.2,156.5) ; JDIMM1.184 171.75,147.65 v1(170.37,147.65) ; JWLBT.63 v1(253.45,161.45) ; UV3.H17 48.14,150.19 47.77,149.83 v2(47.77,149.67) ; UV7.G9 23.62,154.61 23.62,154.63 v1(23.7,154.71) ; 21.71,139.96 21.71,139.98 22.07,140.35 22.12,140.35 v1(22.14,140.37) ; UV3.W26 56.91,143.4 v2(57.38,143.87) ; v1(164.95,138.95) JDIMM1.155 ; JDIMM1.72 171.75,111.65 170.26,111.65 v1(170.23,111.68) ; v1(170.23,130.86) 170.24,130.85 171.75,130.85 JDIMM1.128 ; UV3.N25 51.63,144.5 v2(51.28,144.5) ; JWLBT.18 v1(264.7,156.5) ; UV5.M9 19.31,140.75 18.92,140.35 v2(18.92,140.35) ; JDIMM1.48 170.24,104.45 v1(170.23,104.44) ; v1(153.92,93.24) 153.84,93.24 153.26,93.83 151.85,93.83 151.73,93.95 JDIMM2.13 ; JDIMM1.151 162.67,137.75 162.5,137.58 v1(162.1,137.58) 162.1,137.8 162.65,138.35 JDIMM1.153 ; UV5.T9 15.93,140.94 v1(15.57,140.94) ; v1(170.27,139.25) 171.75,139.25 JDIMM1.156 ; UV3.M12 v2(52.11,153.83) UV3.N13 ; v2(22.15,155.49) 21.75,155.1 21.71,155.1 ; UV7.P1 17.52,160.88 17.25,161.15 v1(17.25,161.2) ; UV7.P9 17.32,154.69 v2(17.31,154.69) ; v1(164.95,106.55) JDIMM1.55 ; UV3.G27 47.34,142.6 v2(46.95,142.99) 46.54,143.4 UV3.F26 ; v1(26.59,165.88) 26.47,165.76 CV110.2 ; JDIMM1.179 163.55,146.15 v1(162.1,146.15) ; v1(170.37,142.85) 171.75,142.85 JDIMM1.168 ; UV3.AA27 v2(58.54,143.16) ; v2(54.11,149.17) UV3.T18 ; UV3.N16 52.54,151.47 v2(52.16,151.85) ; v1(170.39,135.65) 171.75,135.65 JDIMM1.144 ; UV3.G10 47.27,156.26 46.6,156.26 UV3.F10 ; 27.56,161.34 v1(27.56,161.36) ; 27.56,161.34 27.48,161.26 27.48,160.86 UV7.B1 ; UV7.T1 16.11,160.71 15.7,161.12 v1(15.68,161.12) ; JWLBT.30 261.7,156.14 v1(261.35,156.5) ; JWLBT.45 v1(257.95,164.12) ; v1(164.98,147.66) 164.98,147.66 164.7,147.95 163.55,147.95 JDIMM1.185 ; v1(18.11,133.85) 17.91,134.05 17.91,134.16 UV5.P1 ; UV3.Y25 57.51,144.63 v2(57.25,144.63) 56.82,144.2 UV3.W25 ; UV3.V32 v1(56.14,139.57) ; JDIMM1.20 v1(170.37,96.05) ; v2(52.11,147.17) UV3.N21 ; v1(18.8,162.03) 18.8,161.88 18.92,161.76 ; UV5.G9 23.31,140.88 v1(23.65,141.22) 23.65,141.21 UV5.F9 24.11,140.76 UV5.G8 ; v1(27.77,153.72) 27.31,154.19 UV7.B9 ; JWLBT.29 v1(261.95,164.12) ; JWLBT.33 v1(260.95,164.12) ; v2(55.77,148.17) UV3.U20 ; JDIMM1.44 v1(170.34,103.25) ; UV3.Y32 v1(57.74,139.58) ; JWLBT.69 v1(251.95,161.45) ; JWLBT.75 v1(250.45,161.45)
  BOTTOM w0.356: v1(156.08,151.3) 156.11,151.34 157.41,151.34 157.5,151.25 JDIMM2.196 ; JDIMM2.155 149.3,138.95 v1(148.84,139.41) ; v1(170.38,90.65) 170.38,90.65 JDIMM1.2 ; JDIMM2.128 155.92,130.85 154.67,132.1 v1(154.67,132.49) ; v1(152.16,106.19) 151.8,106.55 JDIMM2.55 ; JDIMM2.168 157.39,142.85 v1(157.22,143.01) 157.22,143.09 157.58,143.45 JDIMM2.170 ; JDIMM2.179 151.53,146.15 v1(151.96,145.72) ; JDIMM2.173 151.4,144.35 151.55,144.21 v1(153.05,144.21) ; JDIMM2.38 157.52,101.45 v1(157.17,101.1) ; v1(148.25,135.67) 148.53,135.95 JDIMM2.145 ; JDIMM2.32 157.34,99.65 v1(157.07,99.38) ; JDIMM2.178 157.44,145.85 v1(157.11,146.18) ; JDIMM2.150 157.41,137.45 v1(157.13,137.73) ; v1(157.16,108.19) 157.29,108.05 JDIMM2.60 ; JDIMM1.8 170.38,92.45 v1(170.38,92.45) ; JDIMM1.14 170.55,94.25 v1(170.4,94.1) ; JDIMM2.187 150.36,148.54 v1(151.93,148.54) 151.34,147.95 JDIMM2.185 ; JDIMM2.25 v1(152.53,97.55) ; v1(152.16,143) 152.09,143 151.64,142.55 JDIMM2.167 ; JDIMM2.138 v1(156.57,133.85) 157.17,133.25 JDIMM2.136 ; JDIMM1.136 170.76,133.25 v1(170.23,133.78) ; JDIMM2.54 157.27,106.25 v1(156.94,106.58) ; JDIMM2.134 157.29,132.65 v1(157.13,132.49) ; v1(157.11,111.72) 157.43,111.72 157.5,111.65 JDIMM2.72 ; JDIMM2.61 151.78,108.35 151.81,108.38 ; v1(156.48,91.47) 156.48,90.98 156.81,90.65 JDIMM2.2 ; v1(153.68,91.47) 153.68,92 152.93,92.75 JDIMM2.9 ; JDIMM2.66 157.35,109.85 v1(157,109.51) ; JDIMM2.31 v1(153.17,99.35) ; 151.81,108.38 v1(151.81,108.24) ; 151.81,108.38 151.24,108.95 JDIMM2.63 ; JDIMM2.46 157.58,103.85 v1(157.17,103.44) 157.36,103.25 JDIMM2.44 ; JDIMM2.65 149.22,109.55 148.92,109.85 148.92,111 149.26,111.35 JDIMM2.71 151.66,111.35 v1(151.98,111.67) ; v1(152.97,103.41) 152.1,103.41 151.64,102.95 JDIMM2.43 ; v1(156.99,144.12) 157.06,144.05 JDIMM2.172 ; v1(286.7,53.36) 286.68,53.37 D2.3 ; v1(156.44,94.85) 156.44,94.6 156.79,94.25 JDIMM2.14 159.73,94.25 160,94.52 160,95.66 159.62,96.05 JDIMM2.20 ; JDIMM2.184 157.16,147.65 v1(156.36,148.45) ; JDIMM2.153 151.37,138.35 v1(151.94,137.79) 151.3,137.79 151.26,137.75 JDIMM2.151 ; v1(151.78,132.48) 151.65,132.35 JDIMM2.133 ; v1(151.76,140.81) 151.7,140.75 JDIMM2.161 149.25,140.75 149.24,140.74 ; v1(152.14,133.82) 152.02,133.82 151.69,134.15 JDIMM2.139 ; JDIMM2.156 157.1,139.25 v1(156.96,139.11) ; 151.85,93.83 151.37,93.35 JDIMM2.11 ; v1(155.79,149.84) 156.83,149.84 157.22,149.45 JDIMM2.190 ; JDIMM2.37 v1(153.2,101.15) ; JDIMM2.189 v1(148.89,149.15) ; JDIMM2.144 156.63,135.65 v1(156.43,135.85) ; JDIMM2.195 151.54,150.95 v1(151.84,151.25) ; JDIMM2.127 151.35,130.55 151.64,130.26 152.84,130.26 153.25,129.85 v1(153.25,129.65) ; v1(155.88,104.62) 156.05,104.45 JDIMM2.48 ; JDIMM2.26 157.37,97.85 v1(157.12,97.6) 157.12,98.12 157.45,98.45 JDIMM2.28 ; v1(152,90.33) 151.38,90.95 JDIMM2.3 ; JDIMM1.60 v1(170.23,108.05) ; v1(170.42,98.58) 170.55,98.45 JDIMM1.28 ; JDIMM2.162 157.42,141.05 v1(157.12,140.74) ; v1(157.02,92.62) 157.2,92.45 JDIMM2.8 ; v1(153.77,104.58) 153.6,104.75 JDIMM2.49
  BOTTOM w0.381: v2(53.99,155.77) 54.36,155.4 UV3.T11 ; v1(51.54,132.37) 51.29,132.11 CV22.2 ; PC1.1 v1(240.47,128.1) 241.28,127.29 PQ2.3 ; QV3.3 55.21,127.86 v1(55.63,127.44) ; UV3.AF32 v2(62.54,139.58) ; CV72.2 50.15,133.61 49.56,133.03 v1(49.36,133.03) 49.13,133.26 RV6.2 CV73.2 RV8.2 ; RV44.2 65.39,130.97 v1(65.46,130.89) 65.46,130.37 UV4.3 ; v1(18.08,145.83) 18.08,145.53 CV85.2 ; v1(48.19,168.66) 48.24,168.61 RV74.1 ; PC123.2 218.12,115.78 217.74,115.4 v1(217.74,115.2) ; RV14.1 52.18,133.03 52.61,132.59 v1(52.74,132.59) ; JWLBT.7 v1(266.74,162.77) ; UV3.AD6 60.94,159.77 v1(61.14,159.97) ; D1.1 63,124.09 v1(63.56,123.53) ; UV3.AD32 v2(60.94,139.61) ; PC126.1 213.62,109.25 v1(213.09,108.72) 212.76,109.05 PC127.1 ; v2(49.74,161.96) UV3.K2 ; v1(67.99,145.7) 68.57,145.7 68.97,145.31 CV143.2 ; v1(58.66,118.02) 58.57,118.02 58.09,117.53 C180.2 ; v1(60.48,120.02) 60.15,119.69 C181.2 ; v1(75.81,152.57) 75.86,152.62 76.4,152.62 76.84,153.07 RV137.2 ; v1(173.19,103.85) 171.75,103.85 JDIMM1.46 ; v2(57.83,153.05) 57.83,152.89 UV3.Y15 ; UV3.K28 49.77,141.76 50.15,141.76 v2(50.33,141.94) 50.56,142.17 50.56,142.58 UV3.L27 ; CV17.2 46.39,173.64 v1(45.98,174.05) ; v2(55.77,150.17) UV3.U17 ; PC702.1 149.71,165.74 v1(149.21,166.25) 149.21,166.1 148.6,165.49 PC701.2 ; v2(58.57,156.03) 58.57,155.63 UV3.AA11 ; v1(62.53,118.8) 62.53,118.84 U4.2 ; RV16.2 22.68,145.26 v1(22.68,145.97) ; v2(52.88,159.97) 52.94,159.91 UV3.P6 ; UV3.AH32 64.14,139.69 v2(64.14,139.69) ; CV144.2 69.23,143.1 68.37,143.1 v1(68.18,143.29) ; RV81.1 65.69,167.62 v1(65.89,167.82) ; UV3.AD25 60.91,144.17 v2(60.52,143.78) ; v2(53.09,154.88) 53.09,154.92 53.54,155.36 UV3.R11 ; UV3.H6 48.53,159.01 48.56,159.01 48.94,158.63 UV3.J7 UV3.K6 49.98,159.64 v2(49.98,159.97) ; UV3.AA13 58.34,153.5 v2(58.72,153.88) ; v1(25.19,165.88) 24.94,165.64 CV122.2 ; RV67.2 47.35,168.49 47.27,168.57 v1(47.27,168.76) 47.12,168.9 RV40.1 ; UV3.N11 52.47,155.46 v2(52.47,156.01) ; UV3.AE14 61.82,152.88 v1(61.82,153.39) ; v2(60.56,151.14) 60.5,151.08 60.5,150.8 60.14,150.44 UV3.AC17 ; UV3.R15 53.34,152.4 53.06,152.68 53.06,152.7 v2(53.05,152.71) ; RV99.1 v1(69.32,151.37) RV103.2 ; RV83.1 69.59,147.39 69.32,147.66 RV105.2 CV156.2 68.43,148.06 68.41,148.04 v1(67.72,148.04) ; v2(56.77,153.83) UV3.V13 ; UV3.AC24 59.72,144.58 v2(59.71,144.58) 59.29,145 UV3.AB24 ; v2(58.42,156.67) 57.95,156.2 UV3.Y10 ; CV25.2 CV24.2 49.46,130.72 v1(49.46,130.31) ; RV84.1 62.46,167.79 63.36,168.7 v1(63.36,169) ; v2(56.11,143.36) 56.11,143.74 55.65,144.2 UV3.U25 ; PC403.2 56.29,61.55 v1(56.51,61.77) 56.64,61.9 PC441.2 ; v1(67.75,154.67) CV154.2 RV101.2 ; PQ3.3 v1(237.61,128.85) ; PC109.2 224.06,106.18 v1(224.49,105.75) 224.06,105.32 PC106.2 ; CV162.2 48.09,129.57 48.62,129.04 48.62,129.01 v1(48.7,128.94) ; UV3.R27 v2(53.74,143.21) ; v2(59.66,156.62) 59.56,156.52 59.41,156.52 59.14,156.25 UV3.AB10 ; v1(29.39,172.63) CV152.2 27.35,171.77 CV151.2 ; v1(75.17,154.85) 74.81,154.85 74.66,154.69 RV122.1 ; CV84.2 24.73,145.38 24.73,145.92 v1(24.72,145.93) ; RV106.1 75.56,146.41 v1(75.1,145.96) ; CV155.2 v1(68.43,151.37) CV153.2 ; v2(54.96,143.11) 55.34,142.73 UV3.U27 ; UV7.T9 15.69,154.3 v1(15.47,154.07) ; UV3.K11 49.73,155.2 49.36,154.82 v2(49.36,154.51) ; UV3.AB6 59.34,159.84 v2(59.15,160.02) ; UV3.AD8 60.94,157.79 v2(60.53,157.38) 60.52,157.38 UV3.AC9 ; PC631.2 v1(81.9,157.59) PC615.2 ; v1(27.79,129.38) 27.74,129.43 CV88.2 ; UV3.Y17 v2(57.77,150.17) ; v2(53.06,148.02) 53.06,148.12 UV3.R20 ; v1(58.91,129.7) 59.42,129.19 RV88.2 ; v2(51.34,160.02) UV3.M6 ; v2(56.77,151.83) UV3.V16 ; CV18.2 44.69,173.69 v1(44.69,174.02) ; v1(64.62,123.63) 65.27,124.27 C10.2 ; UV3.AB15 v2(58.77,151.83) UV3.AA16 ; CV117.2 RV37.2 ; RV19.2 19.88,145.2 19.88,146.39 v1(19.87,146.41) ; v1(43.69,126.45) 44.1,126.85 44.1,130.87 44.61,131.38 CV160.2 ; UV3.AC26 59.99,143.4 59.65,143.07 v2(59.65,143.07) 60.11,142.6 UV3.AC27 ; C118.2 v1(279.89,31.78) ; C176.2 v1(59.82,116.77) ; UV3.AB32 59.34,139.95 v2(59.04,139.64) ; v1(70.93,160.51) 70.9,160.49 70.9,160.46 70.24,159.8 RV79.1 ; v1(10.74,161.95) 10.75,161.96 11.54,161.96 CV116.2 11.79,161.58 11.41,161.2 10.64,161.2 v1(10.62,161.18) ; PR208.2 218.22,163.53 v1(218.65,163.96) 218.22,164.4 PC213.1 ; PC437.2 76.82,69.7 v1(77.21,70.1) 76.74,70.57 PC436.2
  BOTTOM w0.406: D7.3 v1(284.59,34.31)
  BOTTOM w0.457: v2(55.77,152.83) UV3.U15 ; v2(56.81,155.05) 56.47,155.4 UV3.V11 ; UV3.R12 53.09,154.84 v2(53.09,154.88) ; v2(54.05,154.05) 54.05,153.89 UV3.T13 ; v2(57.9,148.14) 57.44,148.6 UV3.Y20 ; v2(56.13,156.44) 55.57,157 UV3.U9
  BOTTOM w0.508: CV86.2 24.44,129.19 v1(24.82,128.81) ; JRTC.4 v1(230.53,170.61) ; v1(16.67,145.83) 16.67,145.77 16.56,145.66 CV97.2 ; CV126.2 27.55,165.47 v1(27.87,165.78) ; v1(205.73,118.79) 205.48,118.79 205.09,119.18 USROM1.7 ; v1(20.86,149.09) 20.87,149.09 21.13,149.35 RV37.2 ; CV125.2 12.74,153.72 10.23,153.72 10.21,153.74 v1(10.19,153.74) ; PR703.1 152.19,167.64 152.29,167.74 ; U15.2 281.92,25.05 282.48,25.61 C120.2 282.48,26.37 v1(282.81,26.7) ; v1(18.4,170.69) 18.44,170.73 RV94.2 ; RC144.1 v1(86.14,91.83) ; v1(47.53,173.54) 47.4,173.42 CV166.2 ; 152.29,167.74 v1(152.27,167.76) ; 152.29,167.74 153.08,167.74 PC703.2 ; v1(258.92,89.07) 258.56,89.07 258.01,89.63 CL6.1 ; JME1.2 JCMOS1.2 127.09,138.5 126.73,138.86 v1(125.98,138.86) ; v1(53.37,132.26) 53.4,132.26 53.74,131.92 QV11.3 ; v1(86.98,96.68) 86.98,96.68 RC201.1 ; CV148.2 57.59,128.1 v1(56.78,127.29) ; v1(20.69,166.89) 20.69,166.7 20.96,166.43 CV131.2 ; JDIMM2.205 144.37,87.28 v1(145.14,87.28) ; RC4.2 88.51,102.46 88.45,102.52 v1(87.76,102.52) ; v1(225.05,109.18) 224.59,109.18 224.34,108.92 PC115.2 ; CV100.2 21.62,145.37 v1(22.06,145.81) ; JLINK.30 JLINK.32 ; CV119.2 22.02,166.69 v1(21.36,167.35) ; R67.1 v1(122.66,71.03) ; C40.2 C41.2 v1(275.96,126.92) ; C204.2 C205.2 241.09,80.87 v1(241.23,81.01) ; PC225.2 PC218.1 205.44,175.35 v1(205.99,174.8) ; v1(16.67,149.09) 17.02,149.44 CV118.2 ; v1(222.22,170.81) 221.81,170.4 PR19.1 ; CV149.2 v1(22.7,168.67) ; CL9.2 267.68,96.68 267.32,96.31 v1(267.32,96.15) ; C45.2 v1(124.95,71.03) ; JHDD.1 v1(225.57,77.37) ; R9458.1 R9457.1 v1(263.8,123.85) ; v1(49,125.38) 48.67,125.38 CV161.2 ; PC116.2 225.46,113.04 v1(225.05,113.44) ; v1(70.25,156.63) RV124.1 71.03,156.65 RV126.1 70.67,157.77 v1(70.34,157.44) ; v1(160.01,163.24) 160.01,163.14 159.5,162.63 PC313.2 PC312.2 ; JDIMM1.205 182.39,89.2 v1(182.39,89.2) ; JRTC.2 v1(233.07,171.46) ; v1(276.22,100.76) 276.22,101.04 PC6.2 PC7.2 ; v1(155.15,171.71) 155.15,171.03 PC705.1 ; v1(155.15,171.71) PC709.2 ; v1(155.15,171.71) 155.15,172.33 154.91,172.57 PC710.2 ; R61.1 v1(119.74,71.03) ; v1(222.24,164.38) 221.72,163.86 PQ201.1 ; v1(19.23,128.95) 19.74,129.46 CV81.2 ; v1(278.81,25.62) 278.42,26.02 C127.2 ; v1(271.08,162) JWLBT.76 ; v1(19.33,166.31) 19.33,165.41 19.02,165.1 RV29.2 ; JDIMM1.206 179.65,152.83 179.14,152.32 v1(177.59,152.32) ; PR201.2 215.62,169.7 v1(215.77,169.85) ; PQ201.4 v1(218.83,162.36) ; CV19.2 46.03,170.59 45.55,171.08 v1(45.55,171.18) ; JRTC.3 v1(236.88,170.58) ; CV120.2 v1(10.18,152.03) ; QL3.3 241.09,101.65 RL23.2 v1(240.32,101.71) ; JSPK.6 233.98,94.03 v1(233.33,93.38) ; JSPK.5 v1(242.83,97.47) ; v1(74.89,56.62) 76,55.51 PRT404.2 ; RC372.2 RC6.2 ; v1(277.37,108.69) 277.4,108.72 PC4.2 PC5.2 v1(279.86,108.72) ; CV87.2 18,129.64 18.34,129.3 v1(18.34,128.94) ; PC120.1 v1(255.51,102.19) 256.8,102.19 PC119.1 ; PC9.2 v1(265.75,110.33) ; C129.2 283.12,11.74 281.98,12.87 v1(281.22,12.87) ; CV78.2 v1(14.53,128.8) ; JBATT1.8 v1(243.7,120.18) ; v1(24.09,145.88) 23.61,145.41 CV80.2 ; CV79.2 28.63,129.4 v1(28.7,129.33) ; JHDD.7 v1(233.19,77.41) ; CL17.2 v1(246.31,98.38) ; RV93.2 v1(18.4,169.84) ; JWLBT.77 v1(249.35,163.81) ; v1(203.07,116.48) 202.96,116.48 202.55,116.06 USROM1.4 ; RC296.2 v1(118.22,151.8) ; CV109.2 18.98,149.34 v1(19.16,149.16) ; CV121.2 23.29,165.51 v1(23.56,165.78) ; R18.2 v1(67.88,119.23) ; JHDD.4 v1(229.38,77.41) ; PC10.1 v1(260.92,109.25) ; PC107.2 v1(219.03,104.02) ; PC307.2 v1(171.95,170.05) ; JLINK.31 JLINK.33 ; C44.2 v1(123.93,71.03) ; CC22.2 v1(208.52,119.21)
  vias: v1(1.02,163.28) v1(2.25,159.37) v1(2.33,156.23) v1(2.31,153.27) v1(2.25,147.18) v1(2.28,141.91) v1(3.64,165.08) v1(3.79,161.95) v1(3.83,140.7) v1(3.8,136.32) v1(3.85,143.65) v1(8.63,143.56) v1(8.64,134.08) v1(8.55,128.83) v1(8.74,160.72) v1(8.7,137.67) v1(8.68,131.13) v1(8.76,141.24) v1(11.83,165.04) v1(12.23,127.37) v1(15.17,165.08) v1(16.71,171.18) v1(16.65,167.73) v1(16.89,126.99) v1(21.06,126.91) v1(23.48,174.68) v1(23.68,177.1) v1(24.16,173.36) v1(25.18,175.8) v1(26.27,126.81) v1(26.52,177.1) v1(28.38,177.15) v1(28.44,175.94) v1(30.34,126.08) v1(33.71,125.15) v1(34.55,55.2) v1(36.66,56.01) v1(38.55,123.16) v1(40.47,177.04) v1(40.82,58.07) v1(41.21,142.6) v1(41.73,177.07) v1(41.78,121.36) v1(42.53,54.77) v1(43.06,47.48) v1(43.53,49.17) v1(43.78,59.93) v1(44.28,177.04) v1(44.9,53.59) v1(45.68,56.25) v1(45.82,61.57) v1(46.14,118.22) v1(47.35,58.56) v1(47.67,51.63) v1(48.09,177.04) v1(48.26,63.77) v1(49.35,115.07) v1(49.92,119.44) v1(49.9,49.58) v1(50.34,66.01) v1(51.16,123.63) v1(51.21,122.89) v1(51.16,113.06) v1(51.75,122.31) v1(51.9,177.04) v1(51.95,123.65) v1(52.41,66.1) v1(52.56,111.03) v1(52.74,121.39) v1(53.46,49.22) v1(53.65,124.47) v1(54.16,108.62) v1(54.49,47.48) v1(54.95,107.25) v1(54.92,65.95) v1(54.97,123.17) v1(55.07,118.45) v1(55.57,105.89) v1(55.71,177.04) v1(55.85,74.68) v1(56.04,122.1) v1(56.5,103.87) v1(56.62,72.65) v1(56.86,77.26) v1(57.13,177.01) v1(57.18,67.67) v1(57.26,122.16) v1(57.49,101.11) v1(57.77,70.52) v1(57.79,45.55) v1(58.1,121.37) v1(58.05,99.01) v1(58.23,81.96) v1(58.3,47.48) v1(58.91,86.14) v1(59.01,120.53) v1(59.29,110.19) v1(59.52,177.1) v1(60,110.17) v1(60.32,132.76) v1(60.55,171.85) v1(60.51,79.69) v1(60.51,79.05) v1(60.51,78.42) v1(60.51,77.78) v1(60.51,77.15) v1(60.51,76.51) v1(60.51,75.88) v1(60.51,75.24) v1(60.51,74.61) v1(60.51,73.97) v1(60.51,73.34) v1(60.64,100.21) v1(60.64,72.65) v1(60.84,110.01) v1(60.84,101.48) v1(60.76,100.84) v1(61.02,102.09) v1(61.14,115.53) v1(61.14,80.02) v1(61.14,79.38) v1(61.14,78.75) v1(61.14,78.11) v1(61.14,77.48) v1(61.14,76.84) v1(61.14,76.21) v1(61.14,75.57) v1(61.14,74.94) v1(61.14,74.3) v1(61.14,73.67) v1(61.14,73.03) v1(61.2,174.53) v1(61.2,173.77) v1(61.23,83.28) v1(61.17,82.56) v1(61.17,81.92) v1(61.17,81.29) v1(61.17,80.65) v1(61.25,72.35) v1(61.32,171.86) v1(61.32,131.86) v1(61.35,101.1) v1(61.35,100.46) v1(61.57,110.13) v1(61.55,101.71) v1(61.83,115.5) v1(61.83,102.29) v1(61.91,83.32) v1(61.86,82.68) v1(61.86,82.05) v1(61.86,81.41) v1(61.86,80.78) v1(61.86,80.14) v1(61.86,79.51) v1(61.86,78.87) v1(61.86,78.24) v1(61.86,77.6) v1(61.86,76.97) v1(61.86,76.33) v1(61.86,75.7) v1(61.86,75.06) v1(61.86,74.43) v1(61.86,73.79) v1(61.86,73.16) v1(61.86,72.52) v1(61.98,101.23) v1(61.98,100.59) v1(62.08,133.13) v1(62.11,47.48) v1(62.16,45.45) v1(62.34,101.89) v1(62.47,130.54) v1(62.52,73.64) v1(62.52,73.01) v1(62.52,72.35) v1(62.62,101.3) v1(62.62,100.64) v1(62.95,59.82) v1(62.91,58.87) v1(62.92,57.74) v1(62.88,56.79) v1(63.15,73.64) v1(63.15,73.01) v1(63.2,72.37) v1(63.33,177.04) v1(63.86,133) v1(63.95,56.76) v1(64.01,59.8) v1(63.97,58.84) v1(63.99,57.72) v1(64.12,113.57) v1(64.58,136.57) v1(64.83,71.2) v1(65.14,58.84) v1(65.12,56.76) v1(65.18,59.8) v1(65.16,57.72) v1(65.27,135.3) v1(65.56,71.2) v1(65.92,47.48) v1(66.25,59.8) v1(66.21,58.84) v1(66.22,57.72) v1(66.18,56.76) v1(66.53,87.31) v1(66.55,88.58) v1(66.55,87.94) v1(66.71,45.5) v1(67.11,177.07) v1(67.14,88.83) v1(67.14,88.2) v1(67.11,87.56) v1(67.47,90.51) v1(67.72,130.84) v1(67.75,91.09) v1(67.75,86.39) v1(67.77,89.95) v1(67.98,95.76) v1(68.1,90.51) v1(68.18,115.48) v1(68.38,91.09) v1(68.41,89.95) v1(68.41,86.39) v1(68.61,95.76) v1(68.82,115.48) v1(69.25,95.92) v1(69.46,130.48) v1(69.64,172.05) v1(69.65,170.9) v1(69.73,47.48) v1(69.95,171.49) v1(69.98,168.43) v1(70.28,172.04) v1(70.29,170.9) v1(70.35,167.91) v1(70.58,171.48) v1(70.68,168.47) v1(70.95,177.04) v1(70.99,167.91) v1(71.01,64.92) v1(71.32,168.46) v1(71.55,95.74) v1(71.65,64.92) v1(72.23,95.74) v1(72.27,174.78) v1(72.52,119.22) v1(72.89,95.74) v1(73.13,112.05) v1(73.09,111.4) v1(73.17,119.22) v1(73.54,47.48) v1(74.58,62.77) v1(74.56,61.02) v1(74.99,112.12) v1(74.99,103.36) v1(75.04,100.51) v1(75.04,99.85) v1(75.14,57.23) v1(75.18,123.36) v1(75.22,62.77) v1(75.19,61.02) v1(75.65,112.12) v1(75.62,103.36) v1(75.56,64.94) v1(75.69,117.89) v1(75.7,117.25) v1(75.81,123.36) v1(76.19,64.94) v1(76.28,112.12) v1(76.26,103.36) v1(76.79,161.2) v1(76.78,160.56) v1(76.92,103.36) v1(77.35,47.48) v1(77.48,161.17) v1(77.47,160.53) v1(78.22,160.45) v1(80.25,108.74) v1(80.25,108.11) v1(80.25,107.47) v1(80.25,106.84) v1(80.8,47.48) v1(81.82,74.45) v1(81.82,73.82) v1(81.82,73.18) v1(83.19,60.84) v1(83.19,60.2) v1(83.19,51.21) v1(83.85,60.71) v1(83.88,51.21) v1(84.21,61.88) v1(84.21,61.25) v1(84.3,133.5) v1(84.61,47.48) v1(84.96,75.23) v1(85.2,70.9) v1(85.2,70.26) v1(85.2,69.63) v1(85.2,68.99) v1(85.45,123.73) v1(85.45,48.17) v1(85.72,74.72) v1(85.72,74.09) v1(85.84,138.39) v1(85.81,49.82) v1(85.96,71.91) v1(86.24,48.22) v1(86.27,49.33) v1(86.51,138.4) v1(86.6,49.89) v1(86.57,48.77) v1(86.72,71.91) v1(86.9,49.33) v1(86.87,48.22) v1(87.23,49.89) v1(87.21,48.77) v1(87.31,174.86) v1(87.48,71.91) v1(87.54,49.33) v1(87.51,48.22) v1(87.66,176.11) v1(87.84,48.77) v1(87.87,49.89) v1(88.04,115.73) v1(88.14,177.02) v1(88.14,48.22) v1(88.17,49.33) v1(88.42,47.48) v1(88.5,49.89) v1(88.48,48.77) v1(88.81,49.33) v1(88.78,48.22) v1(88.96,165.7) v1(89.14,49.89) v1(89.11,48.77) v1(89.29,165.09) v1(89.44,49.33) v1(89.41,48.22) v1(89.59,165.69) v1(89.71,113.78) v1(89.75,48.77) v1(89.85,166.45) v1(89.77,49.89) v1(89.89,167.58) v1(89.92,165.09) v1(90,117.15) v1(90.05,48.22) v1(90.08,49.33) v1(90.19,167.03) v1(90.23,165.87) v1(90.35,71.28) v1(90.41,49.89) v1(90.38,48.77) v1(90.52,167.58) v1(90.53,166.43) v1(90.56,165.08) v1(90.71,49.33) v1(90.68,48.22) v1(90.83,167.03) v1(90.87,165.86) v1(91.04,49.89) v1(91.02,48.77) v1(91.16,167.58) v1(91.17,166.43) v1(91.18,165.3) v1(91.35,49.33) v1(91.32,48.22) v1(91.46,167.02) v1(91.51,165.86) v1(91.65,48.77) v1(91.68,49.89) v1(91.8,167.57) v1(91.8,166.43) v1(91.82,165.3) v1(91.95,177.12) v1(91.98,49.33) v1(91.95,48.22) v1(92.1,167.01) v1(92.14,165.86) v1(92.23,47.48) v1(92.31,49.89) v1(92.29,48.77) v1(92.44,166.42) v1(92.45,167.58) v1(92.45,165.29) v1(92.62,49.33) v1(92.59,48.22) v1(92.76,167.03) v1(92.8,165.87) v1(92.79,164.7) v1(92.95,49.89) v1(92.92,48.77) v1(93,112.69) v1(93.09,167.58) v1(93.1,166.43) v1(93.09,165.29) v1(93.17,71.74) v1(93.25,49.33) v1(93.22,48.22) v1(93.39,167.03) v1(93.44,165.86) v1(93.43,164.69) v1(93.58,49.89) v1(93.56,48.77) v1(93.72,167.58) v1(93.73,166.43) v1(93.75,165.3) v1(93.89,49.33) v1(93.86,48.22) v1(94.03,167.02) v1(94.07,165.86) v1(94.09,164.71) v1(94.19,127.8) v1(94.22,49.89) v1(94.19,48.77) v1(94.36,167.57) v1(94.37,166.43) v1(94.38,165.3) v1(94.43,124.28) v1(94.52,49.33) v1(94.49,48.22) v1(94.67,167.01) v1(94.71,165.86) v1(94.72,164.71) v1(94.85,49.89) v1(94.83,48.77) v1(94.92,112.7) v1(95.01,167.57) v1(95.01,166.42) v1(95.02,165.29) v1(95.05,108.02) v1(95.05,61.78) v1(95.13,48.22) v1(95.16,49.33) v1(95.32,167.01) v1(95.35,165.85) v1(95.36,164.7) v1(95.38,62.34) v1(95.49,49.89) v1(95.46,48.77) v1(95.65,167.57) v1(95.66,166.41) v1(95.66,165.29) v1(95.69,61.78) v1(95.76,177.12) v1(95.79,49.33) v1(95.76,48.22) v1(95.95,167.01) v1(95.99,165.84) v1(96,164.69) v1(96.02,62.34) v1(96.04,47.48) v1(96.12,49.89) v1(96.1,48.77) v1(96.28,167.56) v1(96.29,166.41) v1(96.32,165.28) v1(96.32,61.78) v1(96.43,49.33) v1(96.4,48.22) v1(96.59,167) v1(96.63,165.84) v1(96.65,62.34) v1(96.73,48.77) v1(96.76,49.89) v1(96.92,167.55) v1(96.93,166.41) v1(97.03,108) v1(96.96,61.78) v1(97.03,48.22) v1(97.06,49.33) v1(97.23,166.99) v1(97.26,165.84) v1(97.29,62.34) v1(97.39,49.89) v1(97.37,48.77) v1(97.59,167.57) v1(97.57,166.4) v1(97.7,49.33) v1(97.67,48.22) v1(97.9,167.01) v1(98.03,49.89) v1(98,48.77) v1(98.15,79.81) v1(98.15,78.65) v1(98.25,164.29) v1(98.33,49.33) v1(98.3,48.22) v1(98.58,167.32) v1(98.64,48.77) v1(98.66,49.89) v1(98.86,164.52) v1(98.91,79.81) v1(98.91,78.65) v1(98.99,167.82) v1(99.09,165.13) v1(99.57,177.12) v1(99.63,165.58) v1(99.68,79.81) v1(99.68,78.65) v1(99.85,47.48) v1(100.01,70.9) v1(100.01,70.26) v1(100.01,69.63) v1(100.01,68.99) v1(100.32,166.29) v1(100.29,165.65) v1(100.33,165.01) v1(100.92,165.68) v1(100.96,165.04) v1(101.34,51.86) v1(101.34,49.07) v1(102.62,88.2) v1(102.62,87.08) v1(102.72,89.06) v1(103.21,88.58) v1(103.16,87.61) v1(103.16,86.62) v1(103.38,177.12) v1(103.66,47.48) v1(106.66,170.31) v1(106.74,80.83) v1(106.74,75.98) v1(106.92,77.73) v1(106.97,170.87) v1(107.19,177.12) v1(107.25,75.42) v1(107.3,170.31) v1(107.27,80.3) v1(107.42,77.22) v1(107.47,47.48) v1(109.89,157.87) v1(110,106.42) v1(110,105.66) v1(110.75,157.89) v1(111,177.12) v1(110.95,158.5) v1(111.28,47.48) v1(114.81,177.12) v1(115.09,47.48) v1(115.63,170.59) v1(115.65,171.94) v1(115.65,171.28) v1(116.05,69.11) v1(116.54,170.59) v1(116.57,171.94) v1(116.57,171.28) v1(116.62,51.54) v1(116.62,48.88) v1(116.75,56.62) v1(116.75,53.96) v1(117.51,171.94) v1(117.51,171.28) v1(117.48,170.59) v1(117.8,70.23) v1(118.35,170.59) v1(118.37,171.94) v1(118.37,171.28) v1(118.62,177.12) v1(118.9,47.48) v1(120.43,51.54) v1(120.43,48.88) v1(120.52,56.56) v1(122.43,177.12) v1(122.71,47.48) v1(124.24,51.54) v1(124.24,48.88) v1(124.99,138.1) v1(125.29,136.32) v1(126.02,142.02) v1(126.24,177.12) v1(126.52,47.48) v1(127.36,158.53) v1(127.41,144.18) v1(128.05,54.34) v1(128.05,51.54) v1(128.05,48.88) v1(128.47,58.42) v1(128.63,160.94) v1(128.63,158.53) v1(129.9,160.94) v1(129.9,158.53) v1(130.05,177.12) v1(130.35,58.42) v1(130.33,47.48) v1(131.86,54.34) v1(131.86,51.54) v1(131.86,48.88) v1(132.07,143.61) v1(133.86,177.12) v1(134.14,47.48) v1(135.25,61.34) v1(135.32,132.99) v1(135.88,133.62) v1(137.4,68.46) v1(137.67,177.12) v1(137.79,76.63) v1(138.39,87.78) v1(139.02,87.78) v1(139.66,87.78) v1(139.95,152.6) v1(140.06,76.61) v1(140.58,152.65) v1(141.22,152.65) v1(141.26,164.14) v1(141.48,177.12) v1(141.89,164.14) v1(142.53,164.14) v1(143.16,164.14) v1(143.82,164.14) v1(144.69,71.89) v1(144.7,68.88) v1(145.29,177.12) v1(145.41,68.88) v1(145.66,70.96) v1(146.82,174.84) v1(147.17,56.93) v1(147.38,175.16) v1(147.37,174.51) v1(148.01,175.16) v1(148.01,174.51) v1(148.02,173.85) v1(148.34,173.29) v1(148.65,175.16) v1(148.64,174.51) v1(148.65,173.85) v1(148.86,170.56) v1(148.98,173.29) v1(149.1,177.12) v1(149.15,171.29) v1(149.12,169.97) v1(149.28,175.16) v1(149.28,174.5) v1(149.29,173.85) v1(149.47,170.73) v1(149.61,173.29) v1(149.6,157.4) v1(149.83,171.27) v1(149.78,169.87) v1(149.92,173.85) v1(150.06,170.48) v1(150.25,173.28) v1(150.36,157.4) v1(150.83,168.23) v1(151.12,157.4) v1(152.27,157.4) v1(152.91,177.12) v1(153.09,135.92) v1(153.12,108.19) v1(153.37,145.69) v1(153.58,109.46) v1(153.74,144.19) v1(153.82,99.41) v1(154.36,124.09) v1(154.54,140.77) v1(154.46,135.92) v1(154.46,108.19) v1(154.5,101.14) v1(154.64,133.81) v1(154.57,111.61) v1(154.74,143.01) v1(154.78,152.4) v1(155.02,137.8) v1(155.06,91.54) v1(155.51,116.47) v1(155.49,96.41) v1(155.8,144.22) v1(155.85,111.6) v1(155.86,108.19) v1(155.97,97.56) v1(156.72,177.12) v1(159.38,82.86) v1(160.53,177.12) v1(160.7,55.2) v1(162.46,166.05) v1(162.77,166.61) v1(162.75,165.49) v1(163.03,53.45) v1(163.1,166.05) v1(163.19,66.72) v1(163.42,166.61) v1(163.4,165.49) v1(163.84,53.45) v1(163.95,66.72) v1(164.38,177.18) v1(164.73,176.62) v1(165.04,177.19) v1(165.35,159.43) v1(165.36,176.62) v1(165.47,74.52) v1(165.67,177.19) v1(165.71,176.05) v1(165.91,133.97) v1(166.01,176.62) v1(166.25,143.54) v1(166.22,108.08) v1(166.32,177.19) v1(166.27,144.81) v1(166.35,106.56) v1(166.37,176.06) v1(166.36,159.43) v1(166.4,135.95) v1(166.4,102.95) v1(166.52,150.72) v1(166.47,124.03) v1(166.47,111.21) v1(166.47,99.37) v1(166.67,176.63) v1(166.67,90.5) v1(166.92,147.82) v1(166.98,177.2) v1(167.01,176.06) v1(167.19,126.56) v1(167.24,104.66) v1(167.2,75.36) v1(167.31,176.63) v1(167.34,132.53) v1(167.34,118.09) v1(167.51,159.43) v1(167.62,177.2) v1(167.65,176.06) v1(167.7,96.09) v1(167.8,138.97) v1(167.84,94.21) v1(167.95,176.62) v1(167.89,137.59) v1(167.96,146.68) v1(168.05,92.49) v1(168.05,122.1) v1(168.08,110.35) v1(168.07,90.66) v1(168.18,141.82) v1(168.16,115.93) v1(168.26,177.19) v1(168.31,176.06) v1(168.26,143.49) v1(168.36,132.72) v1(168.52,159.43) v1(168.61,176.63) v1(168.69,149.44) v1(168.79,129.47) v1(168.79,108.03) v1(168.92,177.2) v1(168.94,176.06) v1(168.92,166) v1(168.89,133.84) v1(168.96,111.7) v1(168.96,106.2) v1(168.97,103.19) v1(168.96,99.68) v1(169.06,147.61) v1(169.07,135.69) v1(169.09,96.08) v1(169.24,176.63) v1(169.48,165.21) v1(169.54,159.43) v1(169.48,126.68) v1(169.51,98.09) v1(169.54,70.84) v1(169.55,177.2) v1(169.64,176.12) v1(169.64,150.06) v1(169.97,176.67) v1(170.11,165.21) v1(170.29,177.23) v1(170.3,176.12) v1(170.63,176.68) v1(170.55,159.43) v1(170.95,177.24) v1(170.95,176.09) v1(171.26,176.68) v1(171.41,53.4) v1(171.58,177.24) v1(171.57,159.43) v1(171.71,52) v1(172.07,53.4) v1(172.53,71.32) v1(172.73,75.09) v1(172.68,53.68) v1(173.08,122.21) v1(173.08,121.57) v1(173.08,120.94) v1(173.08,120.3) v1(173.11,116.52) v1(173.14,115.87) v1(173.39,75.11) v1(173.7,71.32) v1(173.84,129.32) v1(173.84,128.68) v1(173.84,128.05) v1(174.95,75.41) v1(174.97,77.59) v1(175.72,78.06) v1(175.77,177.02) v1(176.18,167.93) v1(176.73,168.26) v1(176.73,167.61) v1(178.95,164.9) v1(179.58,177.02) v1(179.61,164.9) v1(179.93,150.62) v1(180.08,170.76) v1(180.08,169.79) v1(180.27,164.9) v1(180.4,139.63) v1(180.56,170.26) v1(180.79,149.53) v1(181.04,170.76) v1(181.04,169.79) v1(183.39,177.02) v1(183.41,70.51) v1(185.41,72.31) v1(185.92,107.11) v1(185.86,58.3) v1(185.86,57.03) v1(185.86,55.86) v1(186.05,73.07) v1(186.93,58.33) v1(186.93,57.06) v1(186.93,55.89) v1(187.2,177.02) v1(187.69,66.83) v1(187.89,176.94) v1(188.2,58.33) v1(188.2,57.06) v1(188.2,55.89) v1(188.59,161.72) v1(188.84,173.94) v1(188.9,172.14) v1(189.22,161.72) v1(189.36,173.03) v1(189.57,175.17) v1(189.8,172.13) v1(189.86,173.94) v1(189.86,142.59) v1(189.98,161.72) v1(190.24,143.94) v1(190.34,126) v1(190.75,161.72) v1(191.01,177.02) v1(191.25,147.49) v1(191.25,146.22) v1(191.25,143.94) v1(191.36,78.38) v1(191.51,161.72) v1(192.51,66.26) v1(192.78,139.67) v1(193.13,147.49) v1(193.06,146.23) v1(193.72,173.2) v1(193.69,170.32) v1(193.69,169.68) v1(194.67,142.53) v1(194.82,177.02) v1(195.69,54.17) v1(195.69,53.54) v1(196.58,141.89) v1(196.75,159.51) v1(196.75,158.88) v1(196.65,66.4) v1(196.65,61.68) v1(196.68,57.72) v1(196.68,54.03) v1(197.12,146.2) v1(197.38,159.51) v1(197.38,158.88) v1(197.48,170.86) v1(197.48,169.74) v1(197.73,171.5) v1(197.84,170.28) v1(198.08,158.62) v1(198.14,140.1) v1(198.16,170.83) v1(198.16,169.73) v1(198.46,171.4) v1(198.49,170.29) v1(198.46,93.45) v1(198.47,80.39) v1(198.63,177.02) v1(198.74,94.9) v1(198.82,170.84) v1(198.81,169.72) v1(198.9,169.09) v1(199.12,171.41) v1(199.14,170.27) v1(199.15,176.24) v1(199.2,143.94) v1(199.49,171.99) v1(199.46,170.84) v1(199.47,169.72) v1(199.8,176.23) v1(199.75,171.41) v1(199.8,170.3) v1(200.18,172.09) v1(200.45,176.24) v1(200.82,172.09) v1(201.47,172.09) v1(201.85,143.02) v1(202.06,177.07) v1(202.41,143.89) v1(202.65,98.08) v1(205.03,160.58) v1(205.22,123.85) v1(205.28,124.53) v1(205.49,96.27) v1(205.47,95.36) v1(205.51,94.46) v1(205.59,106.97) v1(205.66,160.58) v1(205.71,125.01) v1(205.87,177.07) v1(205.94,158.96) v1(205.94,158.33) v1(205.94,124.4) v1(205.97,156.45) v1(206.28,96.25) v1(206.36,95.36) v1(206.41,94.44) v1(206.5,158.65) v1(206.5,158.01) v1(206.86,107.09) v1(207.25,95.36) v1(207.26,96.21) v1(207.27,94.49) v1(207.94,144.04) v1(208.21,169.09) v1(208.39,107.09) v1(208.59,153.27) v1(208.62,152.61) v1(208.72,167.06) v1(208.69,166.38) v1(208.85,169.09) v1(209.23,153.91) v1(209.23,153.27) v1(209.3,167.37) v1(209.28,166.71) v1(209.28,166.07) v1(209.33,165.41) v1(209.25,152.61) v1(209.25,151.98) v1(209.68,177.07) v1(209.89,167.06) v1(209.88,166.38) v1(209.89,165.72) v1(209.89,165.08) v1(209.89,164.45) v1(210.42,104.91) v1(210.49,166.78) v1(210.5,166.12) v1(210.5,165.49) v1(210.5,164.85) v1(210.51,107.03) v1(211.08,166.48) v1(211.09,165.82) v1(211.09,165.18) v1(211.06,95.84) v1(211.72,166.71) v1(212.35,166.71) v1(212.48,96.02) v1(212.99,166.71) v1(213.49,177.07) v1(216.62,105.54) v1(217.3,177.07) v1(217.8,135.68) v1(218.42,92.23) v1(218.55,157.72) v1(218.55,157.08) v1(218.7,152.86) v1(218.7,152.23) v1(218.7,112.48) v1(218.68,110.87) v1(218.78,168.03) v1(218.94,135.68) v1(219.18,157.72) v1(219.18,157.08) v1(219.32,167.56) v1(219.41,111.66) v1(219.46,152.86) v1(219.46,152.23) v1(220.22,112.48) v1(220.34,110.85) v1(221.11,177.07) v1(221.55,113.52) v1(221.56,153.89) v1(221.61,149.02) v1(221.66,157.09) v1(222.9,96.16) v1(222.87,95.26) v1(222.89,94.34) v1(223.79,96.16) v1(223.76,95.26) v1(223.81,94.34) v1(224.67,96.12) v1(224.67,95.26) v1(224.67,94.39) v1(224.92,177.07) v1(225.04,175.31) v1(225.34,157.09) v1(225.54,149.02) v1(225.79,97.19) v1(226.14,118.78) v1(226.14,118.09) v1(226.51,121.64) v1(226.81,115.36) v1(227.17,121.66) v1(227.7,144.06) v1(228.73,177.07) v1(228.72,175.31) v1(228.72,144.06) v1(228.97,153.92) v1(229.08,157.65) v1(229.23,164.51) v1(229.23,161.46) v1(229.65,95.97) v1(232.54,177.07) v1(232.53,175.18) v1(232.66,153.92) v1(232.76,157.65) v1(232.91,164.51) v1(232.91,161.46) v1(233.69,120.1) v1(233.76,118.88) v1(233.99,120.68) v1(234.07,119.46) v1(234.35,120.1) v1(234.42,118.88) v1(234.65,120.68) v1(234.73,119.46) v1(235.01,120.1) v1(235.08,118.88) v1(236.35,177.07) v1(236.57,157.53) v1(236.72,164.38) v1(236.72,161.34) v1(236.66,141.98) v1(237.66,86.21) v1(238.88,122.22) v1(239.26,115.36) v1(239.63,87.15) v1(239.69,90.85) v1(239.66,88.63) v1(240.16,177.07) v1(240.53,120.82) v1(241.55,115.24) v1(241.95,156.96) v1(242.04,82.71) v1(242.05,165.91) v1(243.71,122.09) v1(243.97,177.07) v1(244.85,165.91) v1(244.96,88.17) v1(244.96,87.03) v1(244.96,85.88) v1(246.11,87.03) v1(246.11,85.88) v1(246.49,176.59) v1(246.75,164.13) v1(247.38,88.17) v1(247.38,87.03) v1(247.38,85.88) v1(248.66,165.78) v1(250.1,173.01) v1(250.2,167.34) v1(250.94,81.25) v1(251.71,81.25) v1(252.72,82.22) v1(253.09,94.01) v1(253.09,92.87) v1(253.09,91.73) v1(253.24,119.67) v1(253.24,118.52) v1(253.55,119.11) v1(253.91,119.67) v1(253.91,118.52) v1(254.21,119.11) v1(254.24,94.01) v1(254.24,92.87) v1(254.24,91.73) v1(254.57,119.67) v1(254.57,118.52) v1(254.58,80.21) v1(254.87,119.11) v1(255.23,119.67) v1(255.23,118.52) v1(255.38,94.01) v1(255.38,92.87) v1(255.38,91.73) v1(255.53,119.11) v1(255.81,158.07) v1(255.86,119.67) v1(255.86,118.52) v1(257.6,161.27) v1(257.9,158.09) v1(258.99,159.94) v1(259.65,161.27) v1(259.7,145.96) v1(259.7,144.56) v1(259.7,143.29) v1(260.26,153.32) v1(260.51,135.8) v1(261.22,159.93) v1(261.22,145.96) v1(261.22,144.56) v1(261.22,143.29) v1(261.66,96.19) v1(261.8,153.32) v1(262.06,135.8) v1(262.62,145.96) v1(262.62,144.56) v1(262.62,143.29) v1(262.92,135.8) v1(263.53,153.35) v1(264.47,135.8) v1(264.67,103.08) v1(264.67,102.42) v1(265.13,153.32) v1(265.42,122.86) v1(265.42,121.97) v1(265.41,121.12) v1(266.31,122.86) v1(266.27,121.95) v1(266.32,121.12) v1(266.57,138.86) v1(267.19,122.82) v1(267.18,121.94) v1(267.19,121.09) v1(267.34,161.02) v1(268.71,95.71) v1(268.85,138.86) v1(269.07,161.07) v1(269.22,143.36) v1(269.37,140.8) v1(270.25,122.98) v1(270.61,155.73) v1(270.67,141.59) v1(270.8,95.23) v1(270.9,145.57) v1(270.92,143.54) v1(271.01,114.73) v1(271.43,96.04) v1(272.71,163.46) v1(272.69,159.88) v1(272.71,156.61) v1(272.73,153.48) v1(272.71,149.9) v1(272.73,146.63) v1(272.71,139.22) v1(272.77,143) v1(273.18,136.2) v1(273.51,103.89) v1(273.51,95.23) v1(275.44,135.57) v1(275.55,66.43) v1(275.55,27.79) v1(275.57,64.8) v1(275.57,62.41) v1(275.6,60.41) v1(275.6,58.15) v1(275.6,55.3) v1(275.57,52.61) v1(275.6,49) v1(275.6,45.04) v1(275.62,40.8) v1(275.6,36.63) v1(275.62,32.62) v1(275.58,17.26) v1(275.6,15.22) v1(275.69,25.53) v1(275.88,95.66) v1(276.44,33.53) v1(276.44,32.32) v1(276.4,12.82) v1(276.73,12.11) v1(276.82,17.91) v1(277.25,24.7) v1(277.76,125.15) v1(277.86,123.22) v1(278,121.18) v1(278.01,15.86) v1(278.72,36.25) v1(278.75,14.66) v1(278.82,135.52) v1(278.78,41.25) v1(278.98,34.17) v1(280.4,19.59) v1(280.55,31.4) v1(280.58,32.04) v1(280.92,41.96) v1(280.92,40.56) v1(282,14.87) v1(282.6,135.55) v1(282.69,19.86) v1(282.69,18.46) v1(282.69,17.06) v1(282.82,8.17) v1(282.87,109.51) v1(283.32,99.22) v1(283.34,44.02) v1(283.37,109.04) v1(283.57,96.68) v1(283.61,24.3) v1(283.61,19.66) v1(283.83,99.6) v1(284.03,109.06) v1(284.04,24.86) v1(284.35,18.97) v1(284.37,6.02) v1(284.51,99.52) v1(284.59,2.55) v1(284.68,109.06) v1(284.85,66.21) v1(284.85,64.44) v1(285.2,99.52) v1(285.23,41.32) v1(285.23,39.29) v1(285.23,37.77) v1(285.37,109.06) v1(285.36,49.7) v1(286.02,126.52) v1(286.25,66.21) v1(286.25,64.44) v1(286.25,50.97) v1(286.9,135.44) v1(286.87,1) v1(286.98,95.78) v1(287.03,17.28) v1(287.28,5.59) v1(288.44,95.78) v1(289.29,126.52) v1(289.86,65.77) v1(289.87,51.5) v1(290.07,95.86) v1(290.99,0.97) v1(291.07,126.55) v1(291.07,95.84) v1(292.08,40.7) v1(292.08,3.28) v1(292.4,66.29) v1(293.35,40.8) v1(294.51,66.34) v1(294.48,48.79) v1(295.59,0.95) v1(295.71,129.47) v1(295.84,48.77) v1(297.52,25) v1(297.45,18.94) v1(297.6,23.49) v1(297.62,20.12) v1(297.77,3.18) v1(297.93,69.26) v1(297.92,67.47) v1(297.9,1.43) v1(298.1,127.36) v1(299.15,47.26) v1(299.15,44.39) v1(299.17,41.28) v2(41.15,153.02) v2(42.53,141.66) v2(49.94,149.71) v2(57.4,132.63) v2(58.69,137.84) v2(58.79,131.36) v2(60.04,137.31) v2(61.67,137.67) v2(64.54,141.45) v2(71.99,129.47) v2(73.03,128.68) v2(84.83,121.44) v2(85.74,122.47) v2(85.95,116.99) v2(87.74,124.85) v2(87.72,123.46) v2(89.77,125.76) v2(92.42,130.69) v2(95,117.61) v2(95.4,110.74) v2(95.64,117.61) v2(95.78,130.76) v2(96.15,109.49) v2(96.32,127.54) v2(96.27,117.61) v2(96.72,124.3) v2(96.91,117.61) v2(97.5,110.69) v2(97.57,111.92) v2(101.9,127.55) v2(105.39,110.32) v2(105.89,120.14) v2(106.66,110.32) v2(106.9,120.11) v2(106.98,106.7) v2(106.98,105.58) v2(107,104.41) v2(107.03,103.35) v2(107.17,124.29) v2(107.76,120.14) v2(107.93,110.32) v2(108.03,127.28) v2(108.3,102.69) v2(108.53,120.14) v2(109.24,120.14) v2(109.2,110.32) v2(109.2,102.65) v2(109.85,120.14) v2(110.47,110.32) v2(110.61,120.14) v2(111.31,93.4) v2(111.32,91.46) v2(111.74,110.29) v2(112.42,93.8) v2(112.44,92.05) v2(112.74,110.26) v2(113.54,139.17) v2(113.92,94.23) v2(113.93,92.41) v2(115.05,139.59) v2(115.54,94.09) v2(116.06,139.13) v2(119.32,94.55) v2(120.15,95.09) v2(121.81,93.29) v2(124.41,122.69) v2(124.61,113.17) v2(124.66,117.41) v2(124.85,119.18) v2(124.82,106.88) v2(124.82,96.84) v2(124.77,94.37) v2(125.06,121.09) v2(125.26,124.64) v2(125.31,115.63) v2(125.41,98.97) v2(125.55,100.11) v2(125.99,94.77) v2(126.23,111.6) v2(126.3,108.93) v2(126.36,122.69) v2(126.52,103.82) v2(126.61,117.41) v2(126.74,113.17) v2(126.8,119.18) v2(126.78,106.88) v2(126.78,105.66) v2(126.78,96.84) v2(127.01,121.09) v2(127.17,100.9) v2(127.26,115.63) v2(127.39,98.97) v2(127.82,103.57) v2(127.96,124.64) v2(128.18,111.6) v2(128.31,122.69) v2(128.56,117.41) v2(128.73,106.88) v2(128.94,121.09) v2(128.9,108.93) v2(129.12,103.57) v2(129.12,100.9) v2(129.17,115.63) v2(129.38,105.66) v2(130.42,103.57) v4(5.35,132.91) v4(5.63,136.75) v4(6.14,162.3) v4(6.14,162.1) v4(49.22,61.06) v4(62.88,110.18) v4(64.07,114.89) v4(75.56,115.82) v4(78.96,58.14) v4(95.24,55.24) v4(95.4,64.97) v4(98.24,76.58) v4(98.52,81.33) v4(98.6,166.34) v4(100.7,58.36) v4(101.64,87.93) v4(107.54,171.78) v4(131.92,100.5) v4(147.77,93.82) v4(148.05,107.39) v4(165.96,161.03) v4(171.9,161.13) v4(189.38,57.76) v4(197.15,170.28) v4(204.77,122.6) v4(206.55,99.18) v4(208.35,168.17) v4(210.86,168.7) v4(212.01,152.52) v4(216.68,168.75) v4(219.86,97.15) v4(221.48,159.13) v4(224.22,166.24) v4(227.32,173.93) v4(232.38,119.25) v4(234,109.67) v4(235.93,120.47) v4(246.68,86.69) v4(253.69,92.38) v4(279.37,115.95)
