# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_REQ_GPU#: length 67.5
  TOP w0.114: v1(47.25,171.62) v4(47.25,169.59) 47.73,169.11 47.73,168.18 48.24,167.67 RV112.1 ; QV7.3 85.96,141.1 RV51.2 RV53.2 88.53,141.99 RV52.2 88.53,142.75 87.99,143.29 86.91,143.29 86.15,144.05 84.94,144.05 83.3,145.69 v1(83.3,146.48)
  IN1 w0.14: v1(47.25,171.62) 47.25,171.74 48.01,172.5 50.02,172.5 50.39,172.13 56.42,172.13 58.07,170.48 58.07,167.47 60.41,165.13 64.58,165.13 68.34,161.37 68.34,161.36 72.78,156.92 72.78,152.66 75.97,149.47 80.31,149.47 v1(83.3,146.48)
CLKOUT_ITPXDP_N: length 1.1
  TOP w0.114: v2(101.92,112) 102.22,111.71 T52.1
  BOTTOM w0.076: UC1.F43 102.16,112.24 v2(101.92,112)
CLKOUT_ITPXDP_P: length 1.3
  TOP w0.114: T53.1 100.82,111.54 v2(101.29,112)
  BOTTOM w0.076: v2(101.29,112) 101.51,112.23 UC1.E43
CLKREQ_PCIE2_WLAN#: length 180.4
  TOP w0.114: v1(124.44,150.02) 124.96,150.54 RPC200.8
  IN1 w0.14: v1(146.8,164.64) 149.09,164.64 149.9,163.83 159.17,163.83 159.75,164.4 175.35,164.4 175.84,163.92 179.84,163.92 190.16,153.6 195.36,153.6 196.06,154.3 198.16,154.3 198.73,153.74 v1(198.73,152.45)
  IN3 w0.076: v2(118,132.12) 118.4,132.52 119.05,132.52
  IN3 w0.114: 119.05,132.52 119.23,132.52 120.02,133.31 120.02,136.13 121.64,137.75 121.64,140.07 124.04,142.48 124.04,146.46 123.57,146.93 123.57,149.14 v1(124.44,150.02)
  BOTTOM w0.076: v2(118,132.12) 117.65,132.47 UC1.AT8
  BOTTOM w0.114: JWLBT.53 255.95,161.87 255.9,161.82 255.9,160.7 255,159.8 243.06,159.8 229.72,146.46 v4(217.16,146.46) 207.81,146.46 203.03,151.24 199.93,151.24 v1(198.73,152.45) ; v1(146.8,164.64) 147.06,164.38 147.06,163.1 145.5,161.55 138.12,161.55 133.54,156.97 133.54,156.07 130.64,153.17 126.68,153.17 126.11,152.61 126.11,151.52 124.61,150.02 v1(124.44,150.02)
CLKREQ_PCIE3_LAN#: length 201.8
  TOP w0.114: RPC200.7 124.72,151.04 v1(124.44,150.76) ; v1(250.59,90.11) 250.59,90.37 250.87,90.64 UL1.48
  IN1 w0.14: v1(250.59,90.11) 250.59,90.31 250.86,90.57 250.86,91.78 250.61,92.02 250.03,92.02 246.12,95.93 234.4,95.93 227.54,102.79 222.67,102.79 221.73,103.73 221.73,105.68 220.09,107.32 218.85,107.32 215.38,110.79 212.62,110.79 210.94,112.47 200.84,112.47 199.97,113.33 v1(190.29,113.33)
  IN3 w0.114: v2(118,131.2) 118.49,131.69 118.73,131.69 120.37,133.33 120.37,135.97 122.14,137.74 122.14,139.87 124.68,142.41 124.68,147.29 125.14,147.75 125.14,150.06 v1(124.44,150.76) 124.44,150.77 124.75,151.08 126.43,151.08 126.56,150.95 129.01,150.95 129.44,151.38 130.69,151.38 132.12,152.81 136.33,152.81 139.78,156.26 146.33,156.26 146.99,156.92 153.05,156.92 153.55,157.41 170.48,157.41 174.02,153.87 175.42,153.87 189.38,139.91 v1(189.38,139.82)
  BOTTOM w0.076: UC1.AT10 117.65,131.55 v2(118,131.2)
  BOTTOM w0.114: v1(190.29,113.33) 189.07,114.55 189.07,119.15 188.73,119.49 188.73,123.55 187.55,124.73 187.55,128.67 187.1,129.12 187.1,131.91 188.97,133.78 188.97,139.42 v1(189.38,139.82)
CLKREQ_PCIE4_VGA#: length 82.8
  TOP w0.114: RC165.2 RC166.2 128.07,153.25 128.45,152.87 v1(128.45,152.65) ; v1(86.09,142.65) 86.09,142.15 86.21,142.02 RV51.1 86.75,142.75 85.96,143.54 CV141.1 84.84,143.11 QV7.1
  IN1 w0.14: v2(118.63,132.12) 119.08,132.12 120.91,133.95 120.91,135.65 123,137.74 123,139.98 124.1,141.07 125.88,141.07 127.22,142.41 127.22,143.26 128.45,144.49 v1(128.45,152.65)
  IN3 w0.076: v2(118.63,132.12) 118.61,132.12 118.24,131.76 115.3,131.76 115.04,132.01 115.04,132.32
  IN3 w0.114: v1(86.09,142.65) 89.12,139.62 100.17,139.62 101.45,138.34 102.04,138.34 103.07,137.3 109.7,137.3 110.36,137.96 110.36,140.43 111.6,141.68 114.29,141.68 116.48,139.49 116.48,135.91 115.42,134.86 115.42,132.7 115.04,132.32
  BOTTOM w0.076: UC1.AU8 118.3,132.45 v2(118.63,132.12)
CLKREQ_PCIE5_CR#: length 227.2
  TOP w0.114: v1(188.84,101.01) 189.1,100.76 189.1,97.32 184.43,92.65 183.06,92.65 181.17,90.76 181.17,87.76 177.72,84.31 177.72,83.75 176.04,82.07 175.46,82.07 169.03,75.64 v4(169.03,56.88) 169.03,56.18 169.45,55.76 JCR.11 ; RPC200.5 124.58,152.04 v1(124.44,152.18)
  IN1 w0.14: v1(146.3,164.13) 146.31,164.12 148.87,164.12 149.69,163.3 159.39,163.3 159.96,163.88 175.14,163.88 175.62,163.4 179.62,163.4 189.94,153.08 195.57,153.08 196.26,153.77 197.95,153.77 198.09,153.63 v1(198.09,152.47)
  IN3 w0.114: v2(118.63,133.03) 119.06,133.46 119.06,137.07 119.37,137.38 119.37,137.71 120.77,139.11 120.77,140.6 122.57,142.41 122.57,149.57 123.4,150.39 123.4,151.14 v1(124.44,152.18) ; v1(188.84,101.01) 189.73,101.01 196.59,107.87 198.85,107.87 201.24,110.26 201.24,113.25 201.01,113.48 201.01,113.91 200.2,114.73 200.2,116.1 202.08,117.99 202.08,122.22 201.44,122.86 201.44,124.2 202.08,124.84 202.08,128.79 201.33,129.54 201.33,144.38 198.09,147.62 v1(198.09,152.47)
  BOTTOM w0.076: v2(118.63,133.03) 118.3,133.37 UC1.AU7
  BOTTOM w0.114: v1(124.44,152.18) 125.95,153.68 130.45,153.68 133.05,156.28 133.05,157.18 137.91,162.04 145.3,162.04 146.3,163.04 v1(146.3,164.13)
CLKRUN#: length 13.1
  TOP w0.114: v1(125.93,134.38) 126.22,134.08 129.18,134.08 RC52.1
  BOTTOM w0.076: UC1.AW11 119.61,130.89 119.92,131.21 121.6,131.21 121.75,131.05 122.08,131.05 122.35,131.31 122.35,131.92
  BOTTOM w0.114: 122.35,131.92 122.35,132.77 124.02,134.44 125.87,134.44 v1(125.93,134.38)
CONFIGER1: length 8.3
  TOP w0.114: R105.1 279.58,113.86 279.83,114.1 v3(282.45,114.1) 283.28,113.28 283.28,112.88 283.6,112.55 284.2,112.55 284.66,113.02 284.66,113.64 285.29,114.27 JLINK.19
CP_BYPASS: length 275.9
  TOP w0.114: v1(109.84,153.45) 109.84,154.21 110.47,154.84 RPC10.2 ; RC406.2 111.45,144.07 111.27,144.25 111.27,145.41 109.64,147.04 v2(109.39,147.04) ; v1(113.53,81.52) 113.53,75.1 v1(112.64,74.21)
  IN1 w0.14: v1(109.84,153.45) 109.84,153.44 109.09,152.68 109.09,152.19 108.12,151.23 108.12,150.01 ; 108.12,150.01 109.39,148.74 v2(109.39,147.04) ; 108.12,150.01 106.9,150.01 106.49,149.6 106.06,149.6 104.7,148.24 104.35,148.24 103.28,147.17 103.28,145.9 103.61,145.57 103.61,142.27 v1(103.87,142.02)
  BOTTOM w0.114: v1(103.87,142.02) 103.68,142.21 101.42,142.21 100.16,143.47 100.16,146.62 98.24,148.53 94.52,148.53 91.89,145.9 85.27,145.9 78.55,139.19 78.55,126.06 82.81,121.8 82.81,117.76 84.87,115.7 84.87,101.35 85.46,100.76 85.46,99.69 84.9,99.13 84.9,87.96 91.15,81.71 97.13,81.71 98.15,82.72 101.24,82.72 101.88,83.36 107.57,83.36 109.42,81.52 v1(113.53,81.52) ; RE51.2 201.03,111.81 200.45,111.22 199.46,111.22 198.9,111.78 197.93,111.78 v1(197.07,110.92) 196.84,110.69 196.84,108.66 195.98,107.79 195.98,104.34 189.17,97.53 189.17,90.75 180.46,82.04 173.7,82.04 168.44,76.78 162.81,76.78 162.02,75.99 142.66,75.99 140.89,74.21 v1(112.64,74.21) 112.64,73.71 114.06,72.28 118.66,72.28 118.85,72.09 118.85,71.94 v3(118.86,71.93) 118.85,71.92 R108.1
CP_BYPASS_EC: length 14.5
  TOP w0.114: UE1.67 194.43,117.57 194.61,117.39 194.61,117.22 194.84,116.99 194.84,116.53 196.26,115.11 197.86,115.11 197.99,115.24 199.48,115.24 200.07,115.82 v1(200.68,115.82)
  BOTTOM w0.114: RE51.1 203.12,112.34 202.74,112.72 201.92,112.72 201.29,113.36 201.29,115.34 200.81,115.82 v1(200.68,115.82)
CP_BYPASS_R: length 9.9
  TOP w0.114: RC406.1 111.45,142.28 111.4,142.23 111.4,141.5 109.99,140.1 109.84,140.1 v2(109.58,139.83)
  BOTTOM w0.076: v2(109.58,139.83) 109.97,139.44 109.97,138.86 110.13,138.7 110.13,137.39 109.99,137.25 109.99,136.96 110.11,136.71 110.25,136.56 UC1.AB2
  BOTTOM w0.114: v2(109.58,139.83) 109.31,140.1 109.31,141.42 109.14,141.6 109.14,142.01 v4(109.16,142.03)
CP_CLK: length 133.9
  TOP w0.114: JCP.4 119.16,64.67 119.16,65.17 122.23,68.24 122.23,68.92 122.48,69.18 123.5,69.18 v1(123.93,68.74) ; v1(199.54,125.93) 198.9,125.93 198.44,126.39 197,126.39 RE5.1 195.15,126.88 194.64,126.37 UE1.89
  IN3 w0.114: v2(199.13,109.01) 199.13,111.65 197.03,113.75 197.03,123.17 199.54,125.67 v1(199.54,125.93)
  BOTTOM w0.114: v1(123.93,68.74) C44.1 124.24,69.43 124.44,69.63 124.44,72.04 v4(125.21,72.82) 125.8,73.41 141.18,73.41 143.02,75.25 162.35,75.25 163.15,76.05 168.73,76.05 173.98,81.3 180.78,81.3 189.91,90.43 189.91,96.5 198.86,105.46 198.86,108.75 v2(199.13,109.01)
CP_DATA: length 138.3
  TOP w0.114: v1(124.58,68.75) 123.91,69.42 122.38,69.42 121.98,69.02 121.98,68.34 118.66,65.01 118.66,64.62 JCP.3 ; UE1.90 194.66,126.77 195.79,127.9 RE6.1 196.5,128.13 196.77,128.39 197.99,128.39 v4(198.58,127.8) 199.38,127 v1(199.61,127)
  IN3 w0.114: v2(199.64,109.52) 199.64,109.6 200.73,110.69 200.73,112.47 200.4,112.8 198.75,112.8 197.28,114.27 197.28,121.19 198.21,122.12 198.21,123.73 199.97,125.49 199.97,126.63 v1(199.61,127)
  BOTTOM w0.114: v2(199.64,109.52) 199.64,108.45 199.1,107.92 199.1,105.36 190.15,96.4 190.15,90.33 180.88,81.06 174.08,81.06 168.83,75.81 163.25,75.81 162.45,75.01 143.12,75.01 141.28,73.17 128.1,73.17 126.48,71.55 125.98,71.55 125.46,71.03 125.46,69.63 125.25,69.43 C45.1 124.95,69.12 v1(124.58,68.75)
CP_RESET#: length 261.2
  TOP w0.114: JCP.5 119.66,63.36 119.49,63.53 119.49,65.16 122.66,68.33 v1(122.66,68.74) ; v2(108.4,143.15) 108.27,143.15 RC405.1
  IN3 w0.114: v2(108.4,143.15) 107.14,144.41 107.14,152.7 109.05,154.61 114.59,154.61 118.99,159.01 125.27,159.01 126.52,160.26 143.7,160.26 144.52,161.08 160.94,161.08 161.51,161.65 180.87,161.65 192.27,150.26 192.27,142.6 198.86,136.01 198.86,128.29 196.31,125.74 196.31,113.11 197.81,111.62 197.81,110.31 v1(197.99,110.13)
  BOTTOM w0.114: RE50.2 199.08,110.03 198.72,109.67 198.44,109.67 v1(197.99,110.13) 197.36,109.51 197.36,108.35 196.49,107.47 196.49,104.11 189.67,97.29 189.67,90.53 180.68,81.54 173.88,81.54 168.63,76.29 163.05,76.29 162.25,75.49 142.92,75.49 141.08,73.65 125.28,73.65 v4(123.56,71.93) 123.3,71.66 123.3,70.06 R67.2 v1(122.66,68.74)
CP_RESET#_EC: length 29.5
  TOP w0.114: v2(180.45,113.88) 180.26,114.07 UE1.35
  IN1 w0.14: v2(180.45,113.88) 180.45,114.31 181.02,114.88 186.07,114.88 187.06,113.89 199.59,113.89 199.99,114.3 201.36,114.3 v2(202.05,113.61)
  BOTTOM w0.114: v2(202.05,113.61) 202.43,113.23 203.14,113.23 203.85,112.52 203.85,110.76 RE50.1
CP_RESET#_R: length 8.1
  TOP w0.114: v2(105.63,137.72) 105.63,137.72 105.63,138.2 107.38,139.95 107.38,142.31 RC405.2
  BOTTOM w0.076: v2(105.63,137.72) 105.66,137.72 105.74,137.66 106.07,136.82 106.07,136.7 106,136.47 106,136.34 106.08,136.12 106.08,135.97 UC1.P3
CPU_EDP_AUX: length 55.9
  IN3 w0.114: v1(57.87,122.41) 57.87,122.15 57.33,121.6 57.33,120.45 58.16,119.62 59.38,119.62 60.15,118.85 61.65,118.85 62.04,119.24 62.91,119.24 64.25,117.89 68.43,117.89 68.93,118.4 75.84,118.4 76.34,117.89 82.18,117.89 89.09,110.98 91.15,110.98 92.15,111.98 96.7,111.98 97.38,111.3 98.79,111.3 99.69,110.4 101.49,110.4 101.79,110.7 101.79,110.96 v2(101.92,111.09)
  BOTTOM w0.076: UC1.F45 v2(101.92,111.09)
  BOTTOM w0.114: C18.1 56.75,121.01 57.87,122.13 v1(57.87,122.41)
CPU_EDP_AUX#: length 55.9
  IN3 w0.114: v2(101.29,111.09) 101.43,111.09 101.59,110.92 101.59,110.79 101.4,110.6 99.78,110.6 98.88,111.5 97.46,111.5 96.78,112.18 92.06,112.18 91.07,111.18 89.18,111.18 82.26,118.1 76.43,118.1 75.93,118.6 68.85,118.6 68.35,118.1 64.34,118.1 62.99,119.44 61.96,119.44 61.57,119.06 60.23,119.06 59.47,119.82 58.25,119.82 57.53,120.54 57.53,121.51 58.02,122 58.36,122 v1(58.58,121.78)
  BOTTOM w0.076: UC1.E45 v2(101.29,111.09)
  BOTTOM w0.114: v1(58.58,121.78) 58.33,122.03 58.1,122.03 56.82,120.75 C17.1
CPU_EDP_AUX#_CON: length 4.1
  TOP w0.114: v1(55.42,119.14) 55.4,119.17 55,119.17 54.81,118.98 54.52,118.98 53.63,118.09 53.25,118.09 52.99,117.83 JLCD.20
  BOTTOM w0.114: v1(55.42,119.14) 55.42,119.41 55.73,119.72 C17.2
CPU_EDP_AUX_CON: length 4.2
  TOP w0.114: JLCD.21 52.71,118.11 52.91,118.32 53.53,118.32 54.42,119.21 54.72,119.21 54.94,119.43 v1(54.94,119.6)
  BOTTOM w0.114: C18.2 55.54,119.85 55.29,119.6 v1(54.94,119.6)
CPU_EDP_HPD: length 70.1
  TOP w0.114: v2(105.22,132.05) 104.82,131.66 RC159.1 101.76,131.66 101.68,131.57 101.04,131.57 v4(100.75,131.29) 100.7,131.24 99.81,131.24 98.16,132.89 97.44,132.89 v1(94.73,135.6) ; v1(76.18,128.96) 76.18,126.15 72.85,122.82 67.52,122.82 65.64,120.94 62.49,120.94 60.33,123.1 57.13,123.1 56.65,122.61 56.65,122.08 55.66,121.09 54.08,121.09 52.64,119.64 52.64,118.61 JLCD.22
  IN3 w0.114: v1(76.18,128.96) 76.8,128.96 77.95,130.11 77.95,134.25 80.2,136.5 86.44,136.5 87.22,135.71 94.62,135.71 v1(94.73,135.6)
  BOTTOM w0.076: UC1.L10 v2(105.22,132.05)
CPU_EDP_TX0+: length 59.5
  IN3 w0.114: v1(54.36,124.37) 54.36,124.13 53.91,123.68 53.91,121.66 55.86,119.7 55.86,118.68 57.26,117.28 61.31,117.28 62.1,116.5 70.05,116.5 70.64,115.9 76.88,115.9 77.47,116.5 80.33,116.5 83.6,113.23 84.8,113.23 87.6,110.43 87.6,109.26 87.99,108.86 91.61,108.86 92.73,109.98 96.77,109.98 96.92,109.84 96.92,109.61 v2(96.8,109.49)
  BOTTOM w0.076: v2(96.8,109.49) 96.95,109.64 96.95,109.85 97.24,110.14 98.3,110.14 98.58,109.85 98.9,109.85 98.99,109.88 99.24,109.88 99.34,109.85 99.53,109.85 99.61,109.87 99.76,110.03 UC1.C46
  BOTTOM w0.114: C16.1 54.03,123.67 54.36,124 v1(54.36,124.37)
CPU_EDP_TX0+_CON: length 4.1
  TOP w0.114: JLCD.29 50.44,120.38 50.47,120.4 50.49,120.4 50.71,120.61 50.71,120.74 51.36,121.39 51.59,121.39 51.67,121.47 51.67,121.62 v1(51.63,121.66)
  BOTTOM w0.114: v1(51.63,121.66) 51.99,121.66 52.87,122.54 C16.2
CPU_EDP_TX0-: length 59.4
  IN3 w0.114: v1(54.89,123.83) 54.78,123.95 54.46,123.95 54.11,123.6 54.11,121.74 56.06,119.79 56.06,118.76 57.34,117.48 61.4,117.48 62.18,116.7 70.13,116.7 70.73,116.11 76.79,116.11 77.39,116.7 80.42,116.7 83.69,113.43 84.88,113.43 87.8,110.51 87.8,109.34 88.07,109.07 91.53,109.07 92.64,110.19 96.86,110.19 97.12,109.92 97.12,109.67 97.3,109.49 v2(97.45,109.49)
  BOTTOM w0.076: UC1.C47 100,110.11 99.93,110.04 99.93,109.96 99.7,109.73 99.58,109.69 99.55,109.68 99.3,109.68 99.21,109.72 99.02,109.72 98.94,109.69 98.94,109.68 98.52,109.68 98.23,109.97 97.31,109.97 97.12,109.78 97.12,109.64 97.27,109.49 v2(97.45,109.49)
  BOTTOM w0.114: v1(54.89,123.83) 54.52,123.83 54.15,123.47 C15.1
CPU_EDP_TX0-_CON: length 4.1
  TOP w0.114: v1(52.11,121.2) 51.84,121.2 51.79,121.16 51.45,121.16 50.93,120.64 50.93,120.3 50.72,120.09
  BOTTOM w0.114: C15.2 53.05,122.39 52.11,121.46 v1(52.11,121.2)
CPU_EDP_TX1+: length 56.9
  IN3 w0.114: v1(55.63,123.28) 55.78,123.13 55.96,123.13 56.18,123.35 56.59,123.35 56.82,123.11 56.82,119.32 57.44,118.7 58.93,118.7 59.28,118.36 61.52,118.36 62.47,117.4 68.64,117.4 69.14,117.9 72.31,117.9 73.4,116.8 76.5,116.8 77.1,117.4 81.9,117.4 88.82,110.49 91.36,110.49 92.35,111.48 96.23,111.48 96.51,111.2 96.51,110.91 96.68,110.74 v1(96.89,110.74)
  BOTTOM w0.076: 97,111.32 97.02,111.32 97.05,111.35 98.47,111.35 98.63,111.51 98.9,111.51 98.99,111.47 99.24,111.47 99.34,111.51 99.53,111.51 99.78,111.42 UC1.C45
  BOTTOM w0.114: v1(55.63,123.28) 55.76,123.14 55.76,122.92 55.25,122.4 C14.1 ; v1(96.89,110.74) 96.68,110.74 96.51,110.9 96.51,111.12 96.71,111.32 97,111.32
CPU_EDP_TX1+_CON: length 7.4
  TOP w0.114: JLCD.26 51.29,119.51 50.89,119.12 50.89,119.01 50.5,118.61 v1(50.13,118.61)
  BOTTOM w0.114: v1(50.13,118.61) 50.27,118.48 50.46,118.48 51.17,119.18 51.37,119.18 52.13,119.95 52.97,119.95 54.14,121.11 C14.2
CPU_EDP_TX1-: length 56.9
  IN3 w0.114: v1(96.09,110.77) 96.3,110.97 96.3,111.12 96.15,111.28 92.44,111.28 91.44,110.28 88.73,110.28 81.82,117.2 77.18,117.2 76.59,116.6 73.32,116.6 72.22,117.7 69.22,117.7 68.72,117.2 62.39,117.2 61.43,118.15 59.19,118.15 58.85,118.5 57.35,118.5 56.62,119.23 56.62,123.03 56.5,123.14 56.26,123.14 56.16,123.05 v1(56.16,122.74)
  BOTTOM w0.076: UC1.D46 100.41,111.33 100.24,111.5 100.16,111.53 100.03,111.53 99.55,111.67 99.3,111.67 99.21,111.64 99.02,111.64 98.92,111.67 98.56,111.67 98.4,111.52 97.05,111.52 97.02,111.55 97,111.55
  BOTTOM w0.114: C13.1 55.42,122.25 55.91,122.74 v1(56.16,122.74) ; v1(96.09,110.77) 96.28,110.95 96.28,111.21 96.62,111.55 97,111.55
CPU_EDP_TX1-_CON: length 7.4
  TOP w0.114: v1(50.45,118.04) 50.45,118.25 51.05,118.85 51.18,118.85 51.57,119.24 JLCD.25
  BOTTOM w0.114: C13.2 54.47,121.12 53.07,119.72 52.23,119.72 51.47,118.96 51.26,118.96 50.45,118.15 v1(50.45,118.04)
CSB_1B: length 66.8
  TOP w0.254: PR460.2 65.31,104.55 60.51,104.55 59.77,103.82 v1(59.77,103.79)
  IN1 w0.254: v1(63.33,66.68) 62.82,66.68 62.72,66.58 60.46,66.58 58.67,68.37 58.67,81.05 59.29,81.67 59.29,84.19 59.84,84.74 59.84,90.03 59.46,90.42 59.46,97.86 58.91,98.41 58.91,102.93 v1(59.77,103.79)
  BOTTOM w0.203: PC439.2 62.74,65.16 63.16,65.57 63.16,66.51 v1(63.33,66.68) ; PC429.2 62.74,63.3 63.86,62.19 PU401.41
  BOTTOM w0.254: v1(59.77,103.79) 59.77,104.27 62.75,107.25 62.75,107.55 v4(63.15,107.96) 63.15,108.14 65.36,110.34 PRT405.2 ; PC439.2 PC429.2
CSN1: length 14.3
  TOP w0.254: v1(73.59,56.98) 80.07,63.46 81.94,63.46 v4(82.29,63.8) 82.63,63.46 83.82,63.46 PR456.2
  BOTTOM w0.254: PR423.2 72.9,56.98 v1(73.59,56.98)
CSN_1A: length 101.7
  TOP w0.254: v1(57.04,55.7) 56.55,55.2 52.97,55.2 v1(52.46,55.71) 52.31,55.71 51.85,56.17 51.85,61.71 v4(53.46,63.32) 54.46,64.32 54.94,64.32 58.4,67.77 58.4,80.03 59.31,80.95 59.31,84.31 60.7,85.71 67.22,85.71 71.04,81.89 71.04,80.51 PR452.2
  BOTTOM w0.203: PC440.2 57.74,55.91 PC405.2 59.65,55.91 60.89,57.16 PU401.28
  BOTTOM w0.254: v1(52.46,55.71) 52.23,55.71 51.8,56.14 51.8,61.07 58.62,67.89 58.62,77.72 59.09,78.19 59.09,80.25 59.61,80.77 59.61,84.32 61.47,86.19 64.9,86.19 65.31,85.78 69.55,85.78 69.73,85.61 PRT401.2 ; PC440.2 57.28,55.94 v1(57.04,55.7)
CSP1: length 15.6
  TOP w0.254: PR455.2 83.55,63.08 80.93,63.08 v4(80.76,62.91) 80.6,63.07 80.24,63.07 74.2,57.03 v1(74.2,56.45)
  BOTTOM w0.254: PR426.2 74.12,57.46 74.12,56.52 v1(74.2,56.45) 74.02,56.45 73.87,56.29 PR422.2
DDR3_DRAMRST#: length 176.8
  TOP w0.114: v1(160.36,99.47) 160.23,99.6 CD59.1 RD21.2 ; v1(173.21,99.05) 173.97,99.81 CD60.1 174.4,100.67 174.61,100.87 174.61,101.15 v4(175.37,101.91) 177.69,104.23 184.06,104.23 190.61,110.78 192.78,110.78 v1(193.03,111.03)
  IN3 w0.114: v1(173.21,99.05) 167.83,99.05 167.63,98.85 164.2,98.85 163.58,99.47 v1(160.36,99.47) ; v1(193.03,111.03) 193.03,117.88 191.33,119.58 189.32,119.58 188.7,120.2 188.7,121.8 193.53,126.63 193.53,133.02 191.38,135.16 191.38,137.2 175.2,153.37 173.82,153.37 170.27,156.92 153.88,156.92 153.28,156.32 147.09,156.32 146.53,155.76 139.99,155.76 136.38,152.15 132.16,152.15 130.89,150.88 129.65,150.88 128.97,150.2 128.97,147.92 128.72,147.67 128.72,143.15 126.99,141.42 125.29,141.42 123.16,139.29 123.16,137.13 121.23,135.2 121.23,133.61 119.28,131.66 119.28,130.41 118.71,129.84 118.36,129.84 118,129.48 v2(118,129.38)
  BOTTOM w0.076: v2(118,129.38) 117.65,129.72 UC1.AT13
  BOTTOM w0.114: v1(160.36,99.47) 159.99,99.47 159.56,99.05 JDIMM2.30 ; JDIMM1.30 v1(173.21,99.05)
DDR_A_BS0: length 61.2
  IN1 w0.076: v2(118.63,107.43) 118.88,107.68 120.22,107.68 122.92,110.38 130.37,110.38
  IN1 w0.165: 130.37,110.38 139.31,110.38 151.35,122.42 157,122.42 159.12,124.54 160.89,124.54 161.29,124.14 163.83,124.14 164.55,124.86 166.42,124.86 167.13,124.14 v1(167.13,124.03)
  BOTTOM w0.076: UC1.AU52 v2(118.63,107.43)
  BOTTOM w0.178: JDIMM1.109 166.19,125.15 167.13,124.2 v1(167.13,124.03)
DDR_A_BS1: length 63.3
  IN1 w0.076: v2(118,109.26) 118.46,108.8 120.13,108.8 120.42,109.09 120.42,109.58 122.11,111.28 124.92,111.28 125.21,110.99 129.79,110.99 130.07,111.27 130.37,111.27
  IN1 w0.165: 130.37,111.27 132.56,111.27 138.94,111.27 150.99,123.31 156.63,123.31 158.75,125.43 161.25,125.43 161.66,125.03 163.46,125.03 164.18,125.75 166.79,125.75 167.25,125.29 168.48,125.29 v1(169.45,124.31)
  BOTTOM w0.076: UC1.AT48 v2(118,109.26)
  BOTTOM w0.178: v1(169.45,124.31) 169.45,124.37 169.93,124.85 JDIMM1.108
DDR_A_BS2: length 59.9
  IN1 w0.076: v2(125.87,103.82) 126.38,104.33 126.87,104.33 127.21,103.99 130.49,103.99 130.81,103.67 130.81,102.75 131.72,101.85
  IN1 w0.165: v1(166.52,114.97) 166.52,115.29 166.36,115.45 162.83,115.45 161.01,113.63 160.3,113.63 157.35,110.67 151.66,110.67 142.83,101.85 131.72,101.85
  BOTTOM w0.076: UC1.AY55 119.89,105.71 120.18,106 120.34,106.08 120.52,106.08 120.68,106.03 120.83,106.03 121.04,106.09 121.16,106.09 121.24,106.06 121.27,106.04 121.64,106.04 121.82,106.23 122.81,106.23 124.06,104.98 124.22,104.98 124.97,104.23 125.21,104.23
  BOTTOM w0.102: v2(125.87,103.82) 125.46,104.23 125.21,104.23
  BOTTOM w0.178: v1(166.52,114.97) 166.77,115.21 166.77,115.56 166.59,115.74 165.07,115.74 164.66,116.15 JDIMM1.79
DDR_A_CAS#: length 61.2
  IN1 w0.076: 130.47,111.72 129.99,111.72 129.72,111.99 125.25,111.99 124.87,111.6 122.01,111.6 120.1,109.7 120.1,109.1 120,109 119.48,109 119.23,109.26 v2(118.63,109.26)
  IN1 w0.165: 130.47,111.72 138.77,111.72 151.63,124.58 157.27,124.58 158.57,125.88 161.44,125.88 161.85,125.47 163.27,125.47 163.99,126.19 166.34,126.19 166.51,126.36 v1(166.51,126.72)
  BOTTOM w0.076: UC1.AU48 v2(118.63,109.26)
  BOTTOM w0.178: JDIMM1.115 164.52,126.95 165.12,127.55 166.55,127.55 166.72,127.37 166.72,126.94 v1(166.51,126.72)
DDR_A_D0: length 80.6
  IN1 w0.114: v2(113.93,94.8) 113.44,95.28 113.44,95.43 112.76,96.12 112.27,96.12 111.95,95.8 111.95,90.31 111.89,90.25 111.89,86.44 115.9,82.43 156.79,82.43 161.25,86.89 161.9,86.89 162.16,87.15 162.16,87.65 162.34,87.83 164.01,87.83 164.32,88.14 164.32,88.3 163.98,88.65 163.98,88.81 164.14,88.97 164.3,88.97 164.65,88.63 164.81,88.63 164.97,88.79 164.97,88.95 164.62,89.3 164.62,89.46 164.79,89.62 164.95,89.62 165.29,89.27 165.45,89.27 165.62,89.44 165.62,89.6 165.27,89.94 165.27,90.1 165.43,90.27 165.59,90.27 165.94,89.92 166.1,89.92 166.25,90.07 166.25,90.35 165.71,90.89 v1(165.71,90.96)
  BOTTOM w0.076: v2(113.93,94.8) 114.61,95.49 114.61,96.42 UC1.AL71
  BOTTOM w0.114: v1(165.71,90.96) 165.12,91.55 JDIMM1.5
DDR_A_D1: length 81.4
  IN1 w0.114: v1(167.11,90.96) 167.28,91.13 167.28,91.31 166.92,91.66 166.08,91.66 165.83,91.41 164.86,91.41 164.46,91 164.46,90.75 164.74,90.47 164.74,90.09 163.51,88.86 163.34,88.86 163.08,89.13 162.9,89.13 162.75,88.97 162.75,88.81 163.02,88.54 163.02,88.38 162.8,88.16 162.58,88.16 162.32,88.41 161.87,88.41 161.11,87.65 161.11,87.21 156.65,82.76 116.03,82.76 112.22,86.57 112.22,90.02 v2(112.43,90.23)
  BOTTOM w0.076: UC1.AL68 115.25,98.39 115.45,98.18 115.45,97.67 115.53,97.51 115.53,97.33 115.47,97.17 115.47,97.03 115.53,96.81 115.53,96.69 115.5,96.61 115.49,96.58 115.49,96.08 115.73,95.83 115.73,95.5 115.11,94.88 115.11,93.5 114.71,93.1
  BOTTOM w0.114: JDIMM1.7 165.56,92.15 166.75,90.96 v1(167.11,90.96) ; 114.71,93.1 114.32,92.7 114.32,92.12 v2(112.43,90.23)
DDR_A_D2: length 82.1
  IN1 w0.114: v1(165.64,93.91) 165.2,94.35 164.32,94.35 160.79,90.82 160.79,90.31 158.68,88.2 157.87,88.2 154.57,84.9 137.24,84.9 136.7,85.44 135.86,85.44 135.74,85.33 135.74,85 135.63,84.88 135.4,84.88 135.28,85 135.28,85.33 135.17,85.44 134.94,85.44 134.83,85.33 134.83,85 134.71,84.88 134.48,84.88 134.37,85 134.37,85.33 134.26,85.44 133.55,85.44 133.37,85.26 132.98,85.26 132.87,85.38 132.87,85.63 132.76,85.75 132.53,85.75 132.41,85.63 132.41,85.38 132.3,85.26 132.07,85.26 131.96,85.38 131.96,85.63 131.84,85.75 131.61,85.75 131.5,85.63 131.5,85.38 131.38,85.26 131.16,85.26 131.04,85.38 131.04,85.63 130.93,85.75 130.7,85.75 130.58,85.63 130.58,85.38 130.47,85.26 130.24,85.26 130.13,85.38 130.13,85.63 130.01,85.75 129.78,85.75 129.67,85.63 129.67,85.38 129.56,85.26 129.33,85.26 129.21,85.38 129.21,85.63 129.1,85.75 128.87,85.75 128.76,85.63 128.76,85.38 128.64,85.26 128.41,85.26 128.3,85.38 128.3,85.63 128.18,85.75 127.96,85.75 127.84,85.63 127.84,85.38 127.73,85.26 127.5,85.26 127.38,85.38 127.38,85.63 127.27,85.75 127.04,85.75 126.93,85.63 126.93,85.38 126.81,85.26 126.58,85.26 126.47,85.38 126.47,85.63 126.36,85.75 126.13,85.75 126.01,85.63 126.01,85.38 125.9,85.26 125.67,85.26 125.56,85.38 125.56,85.63 125.44,85.75 125.21,85.75 125.1,85.63 125.1,85.38 124.98,85.26 124.76,85.26 124.64,85.38 124.64,85.63 124.53,85.75 124.3,85.75 124.18,85.63 124.18,85.38 124.07,85.26 123.84,85.26 123.73,85.38 123.73,85.63 123.61,85.75 123.38,85.75 123.27,85.63 123.27,85.38 123.15,85.26 122.93,85.26 122.81,85.38 122.81,85.63 122.7,85.75 122.47,85.75 122.35,85.63 122.35,85.38 122.24,85.26 122.01,85.26 121.9,85.38 121.9,85.63 121.78,85.75 121.55,85.75 121.44,85.63 121.44,85.38 121.33,85.26 116.5,85.26 114.36,87.41 114.36,90.71 115.58,91.93 v2(115.58,92.77)
  BOTTOM w0.076: UC1.AN68 116.11,97.81 116.11,97.32 116.35,97.08 116.35,96.15 116.39,96.1 116.39,93.43
  BOTTOM w0.114: 116.39,93.43 115.73,92.77 v2(115.58,92.77) ; v1(165.64,93.91) 165,94.55 JDIMM1.15
DDR_A_D3: length 81.1
  IN1 w0.114: v1(166.93,93.88) 167.1,93.71 167.1,93.38 166.83,93.11 164.01,93.11 163.86,92.95 163.86,92.79 163.94,92.71 163.94,92.54 163.78,92.38 163.62,92.38 163.53,92.46 163.37,92.46 163.21,92.3 163.21,92.14 163.29,92.06 163.29,91.9 163.13,91.74 162.97,91.74 162.89,91.82 162.73,91.82 162.56,91.66 162.56,91.49 162.65,91.41 162.65,91.25 162.48,91.09 162.32,91.09 162.24,91.17 162.08,91.17 161.45,90.54 161.45,90.04 159.42,88.01 159.42,87.57 156.05,84.2 132.35,84.2 132.14,84.41 132.14,84.49 132.03,84.6 131.8,84.6 131.69,84.49 131.69,84.32 131.57,84.2 131.34,84.2 131.23,84.32 131.23,84.49 131.11,84.6 130.88,84.6 130.77,84.49 130.77,84.32 130.66,84.2 130.43,84.2 130.31,84.32 130.31,84.49 130.2,84.6 129.97,84.6 129.86,84.49 129.86,84.32 129.74,84.2 129.51,84.2 129.4,84.32 129.4,84.49 129.28,84.6 129.06,84.6 128.94,84.49 128.94,84.32 128.83,84.2 128.6,84.2 128.48,84.32 128.48,84.49 128.37,84.6 128.14,84.6 128.03,84.49 128.03,84.32 127.91,84.2 127.68,84.2 127.57,84.32 127.57,84.49 127.46,84.6 127.23,84.6 127.11,84.49 127.11,84.32 127,84.2 126.77,84.2 126.66,84.32 126.66,84.49 126.54,84.6 126.31,84.6 126.2,84.49 126.2,84.32 126.08,84.2 125.86,84.2 125.74,84.32 125.74,84.49 125.63,84.6 125.4,84.6 125.28,84.49 125.28,84.32 125.17,84.2 116.63,84.2 113.66,87.17 113.66,90.58 113.49,90.75 113.49,91.29 113.78,91.57 114.3,91.57 115.05,92.32 115.05,94.22 v2(115.54,94.71)
  BOTTOM w0.076: v2(115.54,94.71) 115.89,95.06 115.89,95.9 115.65,96.14 115.65,96.54 115.71,96.66 115.71,96.68 115.71,96.69 115.71,96.7 115.71,96.8 115.64,97.03 115.64,97.17 115.72,97.38 115.72,97.64 UC1.AN69
  BOTTOM w0.114: v1(166.93,93.88) 165.8,95.01 164.8,95.01 164.66,95.15 JDIMM1.17
DDR_A_D4: length 81
  IN1 w0.114: v2(113.93,95.38) 112.91,96.4 112.2,96.4 111.73,95.94 111.73,90.6 111.3,90.16 111.3,86.56 115.76,82.1 156.92,82.1 161.39,86.56 163.36,86.56 167.06,90.26 167.15,90.26 167.63,90.74 167.63,90.83 167.91,91.12 168.89,91.12 169.28,90.72 169.77,90.72 170.16,91.12 v1(170.16,91.35)
  BOTTOM w0.076: UC1.AL70 114.59,96.94 114.42,96.77 114.36,96.64 114.33,96.52 114.33,96.44 114.28,96.4 114.28,95.74 v2(113.93,95.38)
  BOTTOM w0.114: JDIMM1.4 170.26,91.25 v1(170.16,91.35)
DDR_A_D5: length 81.8
  IN1 w0.114: v1(168.7,90.57) 167.96,89.82 167.08,89.82 163.5,86.23 161.53,86.23 157.06,81.77 115.62,81.77 110.9,86.49 110.9,95.46 112.13,96.69 113.18,96.69 v2(113.93,95.94)
  BOTTOM w0.076: v2(113.93,95.94) 113.93,96.33 114.17,96.58 114.19,96.63 114.2,96.7 114.21,96.78 114.25,96.91 114.25,96.91 114.33,97.1 114.33,97.27 114.59,97.53 UC1.AL69
  BOTTOM w0.114: JDIMM1.6 169.99,91.85 169.99,91.85 v1(168.7,90.57)
DDR_A_D6: length 80.6
  IN1 w0.114: v1(169.77,94.27) 169.96,94.07 169.96,93.51 169.74,93.29 168.15,93.29 167.09,94.35 166.61,94.35 166.35,94.09 166.35,93.71 166.08,93.44 163.88,93.44 161.12,90.68 161.12,90.18 159.09,88.15 159.09,87.71 155.92,84.53 133.11,84.53 132.71,84.93 124.87,84.93 124.76,84.82 124.76,84.67 124.64,84.55 124.41,84.55 124.3,84.67 124.3,84.82 124.19,84.93 123.96,84.93 123.84,84.82 123.84,84.67 123.73,84.55 123.5,84.55 123.39,84.67 123.39,84.82 123.27,84.93 123.04,84.93 122.93,84.82 122.93,84.67 122.81,84.55 122.59,84.55 122.47,84.67 122.47,84.82 122.36,84.93 122.13,84.93 122.01,84.82 122.01,84.67 121.9,84.55 121.67,84.55 121.56,84.67 121.56,84.82 121.44,84.93 121.21,84.93 121.1,84.82 121.1,84.67 120.99,84.55 120.76,84.55 120.64,84.67 120.64,84.82 120.53,84.93 120.3,84.93 120.19,84.82 120.19,84.67 120.07,84.55 119.84,84.55 119.73,84.67 119.73,84.82 119.61,84.93 119.39,84.93 119.27,84.82 119.27,84.67 119.16,84.55 118.93,84.55 118.81,84.67 118.81,84.82 118.7,84.93 118.47,84.93 118.36,84.82 118.36,84.67 118.24,84.55 116.75,84.55 114.03,87.27 114.03,90.99 v2(113.91,91.11)
  BOTTOM w0.076: 115.22,93.13 115.68,93.13 116.23,93.67 116.23,96.04 116.19,96.08 116.19,96.82 UC1.AN70
  BOTTOM w0.114: JDIMM1.16 170.35,94.85 v1(169.77,94.27) ; 115.22,93.13 114.66,92.57 114.66,91.87 v2(113.91,91.11)
DDR_A_D7: length 79.3
  IN1 w0.114: v1(168.48,94.27) 168.07,94.68 164.19,94.68 160.46,90.95 160.46,90.45 158.54,88.53 157.73,88.53 154.43,85.23 137.38,85.23 136.43,86.18 136.22,86.18 136.11,86.06 136.11,85.91 135.99,85.8 135.76,85.8 135.65,85.91 135.65,86.06 135.53,86.18 135.31,86.18 135.19,86.06 135.19,85.91 135.08,85.8 134.85,85.8 134.73,85.91 134.73,86.06 134.62,86.18 134.39,86.18 134.28,86.06 134.28,85.91 134.16,85.8 133.93,85.8 133.82,85.91 133.82,86.06 133.71,86.18 120.43,86.18 119.94,85.68 116.55,85.68 114.69,87.55 114.69,90.57 116.57,92.46 116.57,95.17 116.46,95.28 116.23,95.28 116.11,95.17 116.11,94.05 v2(115.54,93.48)
  BOTTOM w0.076: v2(115.54,93.48) 116.06,94 116.06,95.97 115.92,96.11 UC1.AN71
  BOTTOM w0.114: JDIMM1.18 169.07,95.45 168.48,94.86 v1(168.48,94.27)
DDR_A_D8: length 68.7
  IN1 w0.114: v2(117.96,94.31) 117.96,93.79 119.04,92.72 120.15,92.72 122.7,90.17 122.7,89.26 124.49,87.46 136.96,87.46 137.61,86.81 140.01,86.81 140.66,87.46 144.34,87.46 145.29,86.51 145.8,86.51 145.91,86.63 145.91,86.9 146.03,87.02 146.26,87.02 146.37,86.9 146.37,86.63 146.49,86.51 146.71,86.51 146.83,86.63 146.83,86.9 146.94,87.02 147.17,87.02 147.29,86.9 147.29,86.63 147.4,86.51 150.62,86.51 151.03,86.93 151.19,86.93 151.5,86.62 151.67,86.62 151.83,86.78 151.83,86.94 151.52,87.25 151.52,87.41 151.68,87.58 151.84,87.58 152.15,87.27 152.31,87.27 152.47,87.43 152.47,87.59 152.16,87.9 152.16,88.06 152.33,88.22 152.49,88.22 152.91,87.8 153.07,87.8 153.22,87.95 153.22,88.13 152.81,88.55 152.81,88.71 153.92,89.81 157.79,89.81 159.18,91.21 159.18,91.48 164.56,96.87 165.45,96.87 165.73,96.59 v1(165.73,96.09)
  BOTTOM w0.076: UC1.AR70 116.95,96.94 116.68,96.67 116.68,96.28 116.72,96.24 116.72,94.87 117.28,94.31 v2(117.96,94.31)
  BOTTOM w0.114: JDIMM1.21 164.51,96.35 164.72,96.55 165.27,96.55 v1(165.73,96.09)
DDR_A_D9: length 70
  IN1 w0.114: v1(167.01,96.07) 167.01,96.43 167.14,96.55 167.85,96.55 168.01,96.71 168.01,96.92 167.8,97.13 165.96,97.13 165.63,97.45 164.68,97.45 158.85,91.62 158.85,91.34 157.65,90.14 153.78,90.14 150.48,86.84 148.44,86.84 147.49,87.79 140.52,87.79 139.87,87.14 137.75,87.14 137.1,87.79 124.63,87.79 123.03,89.4 123.03,90.3 120.33,93 119.29,93 v2(118.4,93.89)
  BOTTOM w0.076: v2(118.4,93.89) 117.33,93.89 116.56,94.66 116.56,96.17 116.52,96.21 116.52,97.08 116.75,97.32 116.75,97.86 UC1.AR68
  BOTTOM w0.114: JDIMM1.23 165.87,96.95 166.75,96.07 v1(167.01,96.07)
DDR_A_D10: length 67.1
  IN1 w0.114: v2(121.01,94.22) 121.01,94.83 121.18,94.99 121.42,94.99 124.95,91.46 126.88,91.46 128.77,89.57 136.39,89.57 136.5,89.68 136.5,89.81 136.62,89.93 136.85,89.93 136.96,89.81 136.96,89.68 137.08,89.57 137.3,89.57 137.42,89.68 137.42,89.81 137.53,89.93 137.76,89.93 137.88,89.81 137.88,89.68 137.99,89.57 138.22,89.57 138.33,89.68 138.33,89.81 138.45,89.93 138.68,89.93 138.79,89.81 138.79,89.68 138.9,89.57 139.13,89.57 139.25,89.68 139.25,89.81 139.36,89.93 139.59,89.93 139.7,89.81 139.7,89.68 139.82,89.57 140.05,89.57 140.16,89.68 140.16,89.81 140.28,89.93 140.5,89.93 140.62,89.81 140.62,89.68 140.73,89.57 140.96,89.57 141.08,89.68 141.08,89.81 141.19,89.93 141.42,89.93 141.53,89.81 141.53,89.68 141.65,89.57 141.88,89.57 141.99,89.68 141.99,89.81 142.1,89.93 142.33,89.93 142.45,89.81 142.45,89.68 142.56,89.57 142.79,89.57 142.9,89.68 142.9,89.81 143.02,89.93 143.25,89.93 143.36,89.81 143.36,89.68 143.48,89.57 143.71,89.57 143.82,89.68 143.82,89.81 143.93,89.93 144.16,89.93 144.28,89.81 144.28,89.68 144.39,89.57 144.62,89.57 144.73,89.68 144.73,89.81 144.85,89.93 145.08,89.93 145.19,89.81 145.19,89.68 145.31,89.57 145.53,89.57 145.65,89.68 145.65,89.81 145.76,89.93 145.99,89.93 146.11,89.81 146.11,89.68 146.22,89.57 146.45,89.57 146.56,89.68 146.56,89.81 146.68,89.93 146.91,89.93 147.02,89.81 147.02,89.68 147.13,89.57 147.36,89.57 147.48,89.68 147.48,89.81 147.59,89.93 147.82,89.93 147.93,89.81 147.93,89.68 148.05,89.57 148.28,89.57 148.39,89.68 148.39,89.81 148.51,89.93 148.73,89.93 148.85,89.81 148.85,89.68 148.96,89.57 149.19,89.57 149.31,89.68 149.31,89.81 149.42,89.93 149.65,89.93 149.76,89.81 149.76,89.68 149.88,89.57 150.01,89.57 150.31,89.87 150.31,90.03 150.28,90.05 150.28,90.22 150.45,90.38 150.61,90.38 150.63,90.35 150.79,90.35 150.96,90.51 150.96,90.68 150.93,90.7 150.93,90.86 151.09,91.02 151.25,91.02 151.28,91 151.44,91 151.6,91.16 151.6,91.32 151.58,91.35 151.58,91.51 151.74,91.67 151.9,91.67 151.93,91.65 152.09,91.65 152.25,91.81 152.25,91.97 152.22,91.99 152.22,92.16 152.79,92.73 153.09,92.73 153.51,92.32 156.06,92.32 156.8,93.06 157.78,93.06 164.59,99.87 165.58,99.87 165.74,99.71 v1(165.74,99.37)
  BOTTOM w0.076: UC1.AU71 118.38,96.33 118.38,95.33 118.78,94.92 119.46,94.92 120.16,94.22 v2(121.01,94.22)
  BOTTOM w0.114: JDIMM1.33 165.16,99.95 v1(165.74,99.37)
DDR_A_D11: length 69
  IN1 w0.114: v1(167.21,99.36) 166.76,98.91 164.1,98.91 157.17,91.99 152.89,91.99 152.44,91.53 152.44,91.37 152.58,91.23 152.58,91.07 152.42,90.91 152.26,90.91 152.12,91.05 151.96,91.05 150.9,89.99 150.9,89.83 151.03,89.7 151.03,89.54 150.87,89.38 150.71,89.38 150.58,89.51 150.42,89.51 150.15,89.24 128.63,89.24 126.77,91.1 126.28,91.1 126.17,90.99 126.17,90.46 126.03,90.32 125.82,90.32 125.71,90.43 125.71,90.99 125.59,91.1 125.37,91.1 125.25,90.99 125.25,90.48 125.11,90.34 124.91,90.34 124.79,90.46 124.79,90.97 122,93.76 v2(121.42,93.76)
  BOTTOM w0.076: UC1.AU68 117.52,98.39 117.32,98.18 117.32,97.94 117.34,97.92 117.34,97.33 117.4,97.17 117.4,97.03 117.33,96.81 117.33,96.69 117.37,96.61 117.38,96.58 117.38,96.21 117.22,96.05 117.22,95.81 117.81,95.22 117.81,95.09 118.85,94.05 118.85,93.76 119.54,93.07 120.73,93.07 v2(121.42,93.76)
  BOTTOM w0.114: v1(167.21,99.36) 166.03,100.55 JDIMM1.35
DDR_A_D12: length 67.3
  IN1 w0.114: v2(117.11,95.06) 117.11,94.07 118.85,92.32 119.61,92.32 122.04,89.89 122.04,88.99 124.22,86.8 136.68,86.8 137.64,85.85 142.73,85.85 142.84,85.97 142.84,86.32 142.96,86.43 143.18,86.43 143.3,86.32 143.3,85.97 143.41,85.85 143.64,85.85 143.76,85.97 143.76,86.19 143.87,86.3 144.05,86.3 144.21,86.14 144.21,85.97 144.33,85.85 152.11,85.85 153.11,86.85 155.17,86.85 157.47,89.15 158.28,89.15 159.84,90.71 159.84,91.21 163.93,95.3 168.94,95.3 v1(169.72,96.08)
  BOTTOM w0.076: UC1.AR71 116.89,96.38 116.89,95.62 117.11,95.4 v2(117.11,95.06)
  BOTTOM w0.114: v1(169.72,96.08) 170.29,96.65 JDIMM1.22
DDR_A_D13: length 68.8
  IN1 w0.114: v2(117.58,94.72) 117.58,93.87 118.94,92.52 119.88,92.52 122.37,90.03 122.37,89.12 124.36,87.13 136.82,87.13 137.47,86.48 140.14,86.48 140.8,87.13 141.08,87.13 141.2,87.02 141.2,86.8 141.31,86.69 141.54,86.69 141.66,86.8 141.66,87.02 141.77,87.13 142,87.13 142.11,87.02 142.11,86.8 142.23,86.69 142.46,86.69 142.57,86.8 142.57,87.02 142.68,87.13 144.2,87.13 145.15,86.18 151.98,86.18 152.97,87.18 155.03,87.18 157.33,89.48 158.15,89.48 159.51,90.84 159.51,91.35 163.79,95.63 168.02,95.63 v1(168.45,96.06)
  BOTTOM w0.076: v2(117.58,94.72) 117.65,94.79 117.65,95.15 117.05,95.75 117.05,96.12 117.21,96.28 117.21,96.54 117.16,96.66 117.16,96.8 117.22,97.03 117.22,97.17 117.15,97.38 117.15,97.64 UC1.AR69
  BOTTOM w0.114: JDIMM1.24 169.64,97.25 v1(168.45,96.06)
DDR_A_D14: length 67.4
  IN1 w0.114: v1(169.67,99.65) 169.13,100.2 168.57,100.2 168.45,100.08 168.45,99.8 168.34,99.69 168.11,99.69 168,99.8 168,100.08 167.88,100.2 167.59,100.2 167.48,100.08 167.48,99.96 167.37,99.84 167.14,99.84 167.02,99.96 167.02,100.08 166.91,100.2 164.45,100.2 157.64,93.39 156.67,93.39 155.92,92.65 153.65,92.65 153.23,93.06 152.66,93.06 149.9,90.3 136.1,90.3 135.99,90.19 135.99,90.07 135.88,89.95 135.65,89.95 135.53,90.07 135.53,90.19 135.42,90.3 135.19,90.3 135.08,90.19 135.08,90.07 134.96,89.95 134.73,89.95 134.62,90.07 134.62,90.19 134.5,90.3 134.28,90.3 134.16,90.19 134.16,90.07 134.05,89.95 133.82,89.95 133.7,90.07 133.7,90.19 133.59,90.3 133.36,90.3 133.25,90.19 133.25,90.07 133.13,89.95 132.9,89.95 132.79,90.07 132.79,90.19 132.68,90.3 132.45,90.3 132.33,90.19 132.33,90.07 132.22,89.95 131.99,89.95 131.88,90.07 131.88,90.19 131.76,90.3 131.53,90.3 131.42,90.19 131.42,90.07 131.3,89.95 131.08,89.95 130.96,90.07 130.96,90.19 130.85,90.3 130.62,90.3 130.5,90.19 130.5,90.07 130.39,89.95 130.16,89.95 130.05,90.07 130.05,90.19 129.93,90.3 129.7,90.3 129.59,90.19 129.59,90.07 129.48,89.95 129.25,89.95 129.13,90.07 129.13,90.19 129.02,90.3 128.5,90.3 127.01,91.79 125.09,91.79 121.48,95.4 121.05,95.4 120.56,94.9 v2(120.56,94.67)
  BOTTOM w0.076: v2(120.56,94.67) 119.95,94.67 119.51,95.11 118.84,95.11 118.55,95.4 118.55,96.81 UC1.AU70
  BOTTOM w0.114: v1(169.67,99.65) 169.67,99.75 170.17,100.25 JDIMM1.34
DDR_A_D15: length 67.8
  IN1 w0.114: v1(169.65,101.43) 170.17,101.95 170.55,101.95 170.83,101.67 170.83,100.81 170.55,100.53 164.31,100.53 157.51,93.72 156.37,93.72 156.37,93.72 152.85,93.72 149.76,90.63 128.64,90.63 127.15,92.12 125.23,92.12 122.31,95.03 122.31,96.52 121.81,97.02 121.13,97.02 v2(119.69,95.59)
  BOTTOM w0.076: UC1.AU69 118.27,97.53 118.66,97.15 118.66,96.97 118.73,96.89 118.73,95.45 118.9,95.29 119.39,95.29 v2(119.69,95.59)
  BOTTOM w0.114: JDIMM1.36 171.43,100.85 170.62,100.85 170.23,100.85 v1(169.65,101.43)
DDR_A_D16: length 61.1
  IN1 w0.114: v2(125.4,94.99) 125.53,94.86 125.53,93.78 125.91,93.4 127.68,93.4 129.17,91.91 149.16,91.91 149.38,92.14 149.38,92.3 149.21,92.47 149.21,92.63 149.37,92.79 149.53,92.79 149.7,92.62 149.86,92.62 152.88,95.64 157.61,95.64 163.78,101.81 166.5,101.81 167.03,102.35 v1(167.03,102.95)
  BOTTOM w0.076: 125.32,95.07 124.84,95.55 123.8,95.55 123.17,96.19 123.17,99.28 122.36,100.09 121.52,100.09 UC1.BB65
  BOTTOM w0.089: 125.32,95.07 v2(125.4,94.99)
  BOTTOM w0.114: JDIMM1.39 165.83,101.75 v1(167.03,102.95)
DDR_A_D17: length 63.4
  IN1 w0.114: v2(127.94,94.02) 127.94,93.62 129.31,92.24 148.35,92.24 149.52,93.41 149.68,93.41 149.85,93.24 150.01,93.24 150.18,93.4 150.18,93.56 150,93.73 150,93.9 150.16,94.06 150.33,94.06 150.5,93.88 150.66,93.88 150.82,94.05 150.82,94.21 150.65,94.38 150.65,94.54 150.81,94.7 150.97,94.7 151.15,94.53 151.31,94.53 151.47,94.69 151.47,94.85 151.3,95.03 151.3,95.19 151.46,95.35 151.62,95.35 151.79,95.18 151.95,95.18 152.12,95.34 152.12,95.5 151.94,95.67 151.94,95.84 152.08,95.97 157.47,95.97 163.64,102.14 165.89,102.14 166,102.25 166,102.68 v1(165.74,102.95)
  BOTTOM w0.076: v2(127.94,94.02) 127.94,94.38 125.93,96.39 124.03,96.39 123.76,96.65 123.76,98.33 123.71,98.39 123.71,99.71 122.15,101.27 121.82,101.27 121.64,101.09 121.28,101.09 121.16,101.13 121.04,101.13 120.83,101.07 120.68,101.07 120.52,101.13 120.34,101.13 120.18,101.05 119.67,101.05 119.47,100.85 UC1.AW65
  BOTTOM w0.114: v1(165.74,102.95) 165.13,102.35 JDIMM1.41
DDR_A_D18: length 63.8
  IN1 w0.114: v2(127.51,96.84) 127.37,96.84 127.01,96.49 127.01,96.31 127.23,96.09 128.6,96.09 130.28,94.41 147.55,94.41 151.83,98.7 157.13,98.7 158.06,99.63 158.06,99.95 162.35,104.24 162.99,104.24 163.18,104.43 163.18,104.6 163.05,104.73 163.05,104.89 163.21,105.05 163.37,105.05 163.51,104.92 163.67,104.92 163.83,105.08 163.83,105.24 163.69,105.38 163.69,105.54 163.85,105.7 164.02,105.7 164.15,105.57 164.31,105.57 164.75,106 166.8,106 166.98,106.18 v1(166.98,106.58)
  BOTTOM w0.076: v2(127.51,96.84) 126.73,97.62 125.48,97.62 124.37,98.73 124.37,99.99 122.41,101.95 120.76,101.95 120.54,101.73 119.99,101.73 119.68,101.42 UC1.AW63
  BOTTOM w0.114: v1(166.98,106.58) 166.98,105.57 166.76,105.35 JDIMM1.51
DDR_A_D19: length 62.7
  IN1 w0.114: v1(165.66,106.53) 165.21,106.99 164.63,106.99 157.52,99.88 152.54,99.88 147.41,94.74 130.43,94.74 127.78,97.39 123.45,97.39 123.28,97.22 123.28,95.63 123.43,95.47 124.06,95.47 124.17,95.58 v2(124.17,96.84)
  BOTTOM w0.076: UC1.AY63 120.22,101.32 120.47,101.32 120.69,101.24 120.82,101.24 121.05,101.31 121.19,101.31 121.31,101.25 121.57,101.25 121.75,101.43 122.22,101.43 123.87,99.78 123.87,98.46 124.17,98.16 v2(124.17,96.84)
  BOTTOM w0.114: JDIMM1.53 165.08,105.95 v1(165.66,106.53)
DDR_A_D20: length 62.2
  IN1 w0.114: v1(168.31,103.16) 166.63,101.48 163.92,101.48 157.75,95.31 153.02,95.31 149.29,91.58 129.03,91.58 127.55,93.07 125.73,93.07 125.2,93.61 125.2,94.57 v2(124.77,94.99)
  BOTTOM w0.076: v2(124.77,94.99) 124.38,95.39 123.69,95.39 123,96.07 123,99.17 122.24,99.93 121.31,99.93 121.06,100.05 121.06,100.05 121.06,100.05 120.91,100.19 UC1.BA65
  BOTTOM w0.114: v1(168.31,103.16) 169.41,102.05 JDIMM1.40
DDR_A_D21: length 62.7
  IN1 w0.114: v1(169.68,103.09) 167.74,101.15 164.05,101.15 157.25,94.34 156.12,94.34 156.11,94.34 152.52,94.34 149.43,91.25 128.9,91.25 127.41,92.74 125.59,92.74 124.17,94.16 v2(124.17,94.99)
  BOTTOM w0.076: UC1.AY65 120.32,100.19 120.59,99.93 120.87,99.93 121,99.87 121.04,99.87 121.11,99.84 121.27,99.76 122.15,99.76 122.84,99.08 122.84,95.98 123.62,95.19 123.98,95.19 v2(124.17,94.99)
  BOTTOM w0.114: v1(169.68,103.09) 170.12,102.65 JDIMM1.42
DDR_A_D22: length 62.3
  IN1 w0.114: v1(168.3,106.23) 167.73,105.66 164.87,105.66 163.13,103.91 162.49,103.91 158.39,99.81 158.39,99.5 157.26,98.37 151.97,98.37 147.68,94.08 130.12,94.08 128.45,95.76 125.55,95.76 125.43,95.87 125.43,96.15 v2(126.13,96.84)
  BOTTOM w0.076: UC1.BA63 120.98,101.52 121.24,101.79 122.34,101.79 124.2,99.92 124.2,98.62 125.42,97.4 125.57,97.4 v2(126.13,96.84)
  BOTTOM w0.114: v1(168.3,106.23) 169.48,105.05 JDIMM1.50
DDR_A_D23: length 61.5
  IN1 w0.114: v2(125.47,96.84) 124.9,96.27 124.9,95.82 125.29,95.43 128.25,95.43 129.92,93.75 147.82,93.75 152.11,98.04 157.4,98.04 158.72,99.36 158.72,99.67 162.63,103.58 163.27,103.58 165.01,105.33 168.78,105.33 v1(169.64,106.18)
  BOTTOM w0.076: v2(125.47,96.84) 124.82,97.49 124.82,97.74 124.04,98.53 124.04,99.85 122.29,101.6 121.49,101.6 UC1.BB63
  BOTTOM w0.114: v1(169.64,106.18) 170.17,105.65 JDIMM1.52
DDR_A_D24: length 61.7
  IN1 w0.076: 129,97.24 127.94,98.3 126.73,98.3 v2(126.06,98.97)
  IN1 w0.114: 129,97.24 129.28,97.24 130.68,95.83 146.59,95.83 150.32,99.56 150.48,99.56 150.56,99.49 150.72,99.49 150.88,99.65 150.88,99.81 150.8,99.89 150.8,100.05 150.96,100.21 151.13,100.21 151.2,100.13 151.36,100.13 151.53,100.29 151.53,100.46 151.45,100.53 151.45,100.69 151.61,100.86 151.77,100.86 151.85,100.78 152.01,100.78 152.17,100.94 152.17,101.1 152.1,101.18 152.1,101.34 152.34,101.59 157.8,101.59 158.33,102.12 158.33,102.28 158.33,102.29 158.33,102.45 158.49,102.61 158.66,102.61 158.66,102.61 158.82,102.61 158.98,102.77 158.98,102.93 158.98,102.93 158.98,103.09 159.14,103.26 159.3,103.26 159.3,103.25 159.47,103.25 159.63,103.41 159.63,103.58 159.63,103.58 159.63,103.74 159.79,103.9 159.95,103.9 159.95,103.9 160.11,103.9 160.27,104.06 160.27,104.22 160.27,104.23 160.27,104.39 160.43,104.55 160.6,104.55 160.6,104.55 160.76,104.55 160.92,104.71 160.92,104.87 160.92,104.87 160.92,105.03 161.08,105.2 161.24,105.2 161.24,105.19 161.41,105.19 161.57,105.35 161.57,105.52 161.57,105.52 161.57,105.68 161.73,105.84 161.89,105.84 161.89,105.84 162.05,105.84 162.21,106 162.21,106.16 162.21,106.17 162.21,106.33 162.37,106.49 162.54,106.49 162.54,106.49 162.7,106.49 162.86,106.65 162.86,106.81 162.86,106.81 162.86,106.97 163.02,107.14 163.18,107.14 163.18,107.13 163.35,107.13 163.51,107.29 163.51,107.46 163.51,107.46 163.51,107.62 163.67,107.78 163.83,107.78 163.83,107.78 163.99,107.78 164.15,107.94 164.15,108.1 164.15,108.11 164.15,108.27 164.31,108.43 164.48,108.43 164.48,108.43 164.64,108.43 164.76,108.55 166.68,108.55 166.87,108.37 v1(166.87,108.06)
  BOTTOM w0.076: UC1.BA61 120.99,102.55 121.25,102.28 122.54,102.28 124.82,100 124.82,99.56 125.02,99.36 125.67,99.36 v2(126.06,98.97)
  BOTTOM w0.114: v1(166.87,108.06) 165.96,107.15 JDIMM1.57
DDR_A_D25: length 63.1
  IN1 w0.114: v2(124.76,98.97) 124.34,98.97 124.09,98.72 124.09,98.15 124.37,97.87 127.86,97.87 128.84,96.88 129.17,96.88 130.59,95.47 147.25,95.47 147.6,95.82 147.6,95.98 147.48,96.1 147.48,96.26 147.64,96.42 147.8,96.42 147.92,96.3 148.09,96.3 148.25,96.46 148.25,96.62 148.13,96.74 148.13,96.91 148.29,97.07 148.45,97.07 148.57,96.95 148.73,96.95 148.89,97.11 148.89,97.27 148.77,97.39 148.77,97.55 148.94,97.71 149.1,97.71 149.22,97.59 149.38,97.59 149.54,97.76 149.54,97.92 149.42,98.04 149.42,98.2 149.58,98.36 149.74,98.36 149.86,98.24 150.03,98.24 150.19,98.4 150.19,98.56 150.07,98.68 150.07,98.85 150.23,99.01 150.39,99.01 150.51,98.89 150.67,98.89 152.45,100.66 152.78,100.66 152.95,100.5 153.24,100.5 153.4,100.66 153.7,100.66 153.86,100.5 154.16,100.5 154.32,100.66 154.61,100.66 154.78,100.5 155.07,100.5 155.23,100.66 155.53,100.66 155.69,100.5 155.98,100.5 156.15,100.66 156.44,100.66 156.6,100.5 156.9,100.5 157.06,100.66 157.43,100.66 164.37,107.61 165.64,107.61 165.76,107.72 165.76,107.89 v1(165.56,108.08)
  BOTTOM w0.076: UC1.AW61 119.66,102.65 119.98,102.33 120.53,102.33 120.74,102.12 122.47,102.12 124.63,99.96 124.63,99.1 v2(124.76,98.97)
  BOTTOM w0.114: JDIMM1.59 164.48,107.75 164.7,107.52 165.58,107.52 165.7,107.64 165.7,107.94 v1(165.56,108.08)
DDR_A_D26: length 61.6
  IN1 w0.076: v2(127.82,100.9) 127.82,100.79 129.01,99.59 129.33,99.59
  IN1 w0.114: v1(167.14,111.16) 167.14,111.45 166.95,111.65 164.04,111.65 162.48,110.09 161.77,110.09 159.57,107.89 159.57,107.18 157.78,105.39 152.19,105.39 148.11,101.31 147.95,101.31 147.78,101.49 147.62,101.49 147.45,101.32 147.45,101.16 147.63,100.99 147.63,100.83 147.47,100.66 147.31,100.66 147.13,100.84 146.97,100.84 146.81,100.68 146.81,100.52 146.98,100.34 146.98,100.18 146.82,100.02 146.66,100.02 146.48,100.19 146.32,100.19 146.16,100.03 146.16,99.87 146.34,99.69 146.34,99.53 146.17,99.37 146.01,99.37 145.84,99.55 145.68,99.55 145.51,99.38 145.51,99.22 145.69,99.05 145.69,98.89 145.11,98.3 131.68,98.3 130.39,99.59 129.33,99.59
  BOTTOM w0.076: UC1.BB59 121.52,103.98 122.23,103.98 122.47,103.73 123.02,103.73 124.94,101.82 126.9,101.82 v2(127.82,100.9)
  BOTTOM w0.114: v1(167.14,111.16) 167.14,110.59 166.7,110.15 JDIMM1.67
DDR_A_D27: length 64.2
  IN1 w0.076: v2(126.52,100.9) 126.52,100.89 127.25,100.17 128.11,100.17 129.02,99.25 129.33,99.25
  IN1 w0.114: 129.33,99.25 130.27,99.25 131.54,97.97 145.25,97.97 147.62,100.35 147.78,100.35 147.83,100.29 148,100.29 148.16,100.45 148.16,100.61 148.1,100.67 148.1,100.83 148.26,100.99 148.43,100.99 148.48,100.94 148.64,100.94 148.8,101.1 148.8,101.26 148.75,101.32 148.75,101.48 148.91,101.64 149.07,101.64 149.13,101.58 149.29,101.58 149.45,101.75 149.45,101.91 149.4,101.96 149.4,102.12 149.56,102.29 149.72,102.29 149.77,102.23 149.94,102.23 150.1,102.39 150.1,102.55 150.04,102.61 150.04,102.77 150.2,102.93 150.37,102.93 150.42,102.88 150.58,102.88 150.74,103.04 150.74,103.2 150.69,103.26 150.69,103.42 150.85,103.58 151.01,103.58 151.07,103.52 151.23,103.52 151.39,103.69 151.39,103.85 151.34,103.9 151.34,104.06 151.67,104.4 151.83,104.4 151.91,104.31 152.07,104.31 152.24,104.47 152.24,104.63 152.15,104.72 152.15,104.88 152.33,105.06 152.69,105.06 152.81,104.94 152.81,104.84 152.92,104.72 153.15,104.72 153.27,104.84 153.27,104.94 153.38,105.06 156.24,105.06 156.35,104.94 156.35,104.82 156.46,104.7 156.69,104.7 156.81,104.82 156.81,104.94 156.92,105.06 157.15,105.06 157.26,104.94 157.26,104.82 157.38,104.7 157.56,104.7 159.9,107.04 159.9,107.75 160.19,108.04 160.35,108.04 160.53,107.86 160.69,107.86 160.85,108.03 160.85,108.19 160.68,108.36 160.68,108.53 160.84,108.69 161,108.69 161.18,108.51 161.34,108.51 161.5,108.67 161.5,108.83 161.32,109.01 161.32,109.17 161.91,109.76 162.62,109.76 163.61,110.75 164,110.75 164.11,110.87 164.11,111.19 164.22,111.3 164.45,111.3 164.57,111.19 164.57,110.87 164.68,110.75 165.53,110.75 165.77,110.99 v1(165.77,111.19)
  BOTTOM w0.076: v2(126.52,100.9) 126.13,100.51 125.02,100.51 122.75,102.78 121.84,102.78 121.64,102.98 121.28,102.98 121.28,102.98 121.19,102.94 120.99,102.94 120.91,102.98 120.9,102.98 120.9,102.98 120.89,102.99 120.66,102.99 120.54,102.94 120.29,102.94 120.18,103.02 119.67,103.02 119.47,103.22 UC1.AW59
  BOTTOM w0.114: JDIMM1.69 163.55,110.75 164.6,110.75 164.72,110.62 165.55,110.62 165.77,110.85 v1(165.77,111.19)
DDR_A_D28: length 61.4
  IN1 w0.076: v2(126.74,98.97) 127.14,98.56 128.1,98.56 129.14,97.53
  IN1 w0.114: v1(168.15,108) 168.04,108 167.12,108.92 164.29,108.92 157.82,102.46 157.82,102.08 157.66,101.92 157.28,101.92 157.16,102.03 157.16,102.41 157.05,102.53 156.82,102.53 156.7,102.41 156.7,102.03 156.59,101.92 156.36,101.92 156.25,102.03 156.25,102.41 156.13,102.53 155.9,102.53 155.79,102.41 155.79,102.03 155.68,101.92 152.2,101.92 146.49,96.2 130.78,96.2 129.46,97.53 129.14,97.53
  BOTTOM w0.076: v2(126.74,98.97) 126.17,99.54 125.28,99.54 124.99,99.83 124.99,100.07 122.61,102.45 121.52,102.45 UC1.BB61
  BOTTOM w0.114: JDIMM1.56 169.26,106.85 168.15,107.96 v1(168.15,108)
DDR_A_D29: length 62.6
  IN1 w0.076: 129.21,97.85 v2(128.1,98.97)
  IN1 w0.114: v1(169.47,108.05) 168.98,108.54 167.96,108.54 167.24,109.26 164.16,109.26 157.76,102.86 155.46,102.86 155.35,102.75 155.35,102.49 155.23,102.38 155,102.38 154.89,102.49 154.89,102.75 154.78,102.86 154.55,102.86 154.43,102.75 154.43,102.49 154.32,102.38 154.09,102.38 153.98,102.49 153.98,102.75 153.86,102.86 153.63,102.86 153.52,102.75 153.52,102.49 153.4,102.38 153.18,102.38 153.06,102.49 153.06,102.75 152.95,102.86 152.68,102.86 146.35,96.53 130.92,96.53 129.6,97.85 129.21,97.85
  BOTTOM w0.076: v2(128.1,98.97) 127.35,99.72 125.38,99.72 125.15,99.95 125.15,100.14 122.68,102.61 121.77,102.61 121.57,102.81 121.31,102.81 121.22,102.78 121.21,102.78 120.96,102.78 120.87,102.81 120.67,102.81 120.58,102.78 120.58,102.78 120.48,102.75 120.22,102.75 UC1.AY61
  BOTTOM w0.114: v1(169.47,108.05) 169.47,108.03 170.05,107.45 JDIMM1.58
DDR_A_D30: length 62.8
  IN1 w0.076: 129.33,99.92 128.99,99.92 128.83,100.09 128.83,100.54 v2(128.47,100.9)
  IN1 w0.114: v1(168.3,111.7) 168.02,111.98 163.9,111.98 162.34,110.42 161.64,110.42 159.24,108.02 159.24,107.32 157.64,105.72 152.06,105.72 150.1,103.76 149.94,103.76 149.75,103.95 149.59,103.95 149.43,103.78 149.43,103.62 149.61,103.44 149.61,103.28 149.45,103.11 149.29,103.11 149.1,103.3 148.94,103.3 148.78,103.14 148.78,102.98 148.97,102.79 148.97,102.63 148.8,102.47 148.64,102.47 148.46,102.65 148.29,102.65 148.13,102.49 148.13,102.33 148.32,102.14 148.32,101.98 148.16,101.82 148,101.82 147.81,102.01 147.65,102.01 144.27,98.64 131.82,98.64 130.53,99.92 129.33,99.92
  BOTTOM w0.076: UC1.BA59 121.17,104.08 121.32,104.14 122.29,104.14 122.54,103.9 123.11,103.9 124.99,102.01 127.36,102.01 v2(128.47,100.9)
  BOTTOM w0.114: v1(168.3,111.7) 168.3,111.14 168.54,110.9 169.96,110.9 170.41,110.45 JDIMM1.68
