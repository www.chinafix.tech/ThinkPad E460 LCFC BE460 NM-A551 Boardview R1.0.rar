# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D31: length 64
  IN1 w0.114: v2(129.76,100.9) 129.46,100.6 129.46,100.44 129.57,100.32 130.6,100.32 131.95,98.97 144.14,98.97 149.65,104.48 149.81,104.48 150,104.29 150.16,104.29 150.32,104.45 150.32,104.62 150.14,104.8 150.14,104.96 150.3,105.13 150.46,105.13 150.65,104.94 150.81,104.94 150.97,105.1 150.97,105.26 150.78,105.45 150.78,105.61 150.94,105.77 151.11,105.77 151.29,105.59 151.45,105.59 151.62,105.75 151.62,105.91 151.43,106.1 151.43,106.26 151.8,106.63 154.63,106.63 155.2,106.05 157.51,106.05 158.91,107.46 158.91,108.16 161.5,110.75 162.2,110.75 163.76,112.31 169.3,112.31 169.6,112.01 v1(169.6,111.68)
  BOTTOM w0.076: UC1.AY59 120.32,103.87 120.59,104.14 120.78,104.14 121.21,104.27 121.28,104.31 122.36,104.31 122.6,104.06 123.19,104.06 125.05,102.21 128.45,102.21 129.71,100.95
  BOTTOM w0.089: 129.71,100.95 v2(129.76,100.9)
  BOTTOM w0.114: v1(169.6,111.68) 169.6,111.67 170.21,111.05 JDIMM1.70
DDR_A_D32: length 63.2
  IN1 w0.076: 132.83,116.88 132.68,116.88 132.17,116.37 130.75,116.37 130.01,115.63 v2(129.82,115.63)
  IN1 w0.114: v1(161.19,131.8) 161.31,131.68 161.74,131.68 161.87,131.55 161.87,131.34 161.74,131.21 151.31,131.21 150.18,130.09 150.18,129.92 145.11,124.84 145.11,124.47 137.52,116.88 132.83,116.88
  BOTTOM w0.076: 127.83,114.54 123.48,114.54 123.32,114.7 122.73,114.7 122.58,114.54 121.73,114.54 121.67,114.49 121.27,114.49 121.14,114.55 121.12,114.55 120.87,114.65 120.59,114.65 120.32,114.92 UC1.AY39
  BOTTOM w0.114: JDIMM1.129 161.52,131.15 161.38,131.01 161.38,130.45 161.54,130.3 161.92,130.3 162.1,130.12 162.1,129.86 161.99,129.74 161.85,129.74 161.74,129.63 161.74,129.25 162.02,128.97 162.02,128.24 161.79,128.01 160.6,128.01 160.34,128.27 160.34,128.8 160.8,129.26 160.8,130.96 160.69,131.07 160.43,131.07 160.28,131.22 160.28,131.83 160.42,131.97 161.02,131.97 v1(161.19,131.8) ; v2(129.82,115.63) 129.14,114.94 128.6,114.94 128.2,114.54 127.83,114.54
DDR_A_D33: length 60.5
  IN1 w0.076: 133.42,115.89 130.95,115.89 130.54,115.48 130.54,115.37 130.12,114.96 124.68,114.96 v2(124.01,115.63)
  IN1 w0.114: v1(167.42,131.25) 167.27,131.25 166.47,130.46 164.17,130.46 163.92,130.22 151.72,130.22 151.17,129.67 151.17,129.51 146.1,124.43 146.1,124.06 137.92,115.89 133.42,115.89
  BOTTOM w0.076: v2(124.01,115.63) 123.62,116.01 121.85,116.01 121.65,115.81 121.28,115.81 121.16,115.86 121.04,115.86 120.83,115.79 120.68,115.79 120.52,115.85 120.34,115.85 120.3,115.83 119.73,115.83 119.47,115.57 UC1.AW39
  BOTTOM w0.114: JDIMM1.131 166.92,131.75 v1(167.42,131.25)
DDR_A_D34: length 62.8
  IN1 w0.076: v2(124.66,115.63) 124.66,116.83 124.85,117.02 127.62,117.02 127.91,116.73 130.33,116.73 130.63,117.04 130.8,117.04
  IN1 w0.114: v1(161.05,133.43) 161.05,133.45 160.94,133.56 158.21,133.56 157.68,133.03 151.09,133.03 148.71,130.65 148.71,130.48 138.12,119.89 137.55,119.89 135.98,118.33 132.09,118.33 130.8,117.04
  BOTTOM w0.076: v2(124.66,115.63) 124.11,116.18 121.78,116.18 121.58,115.98 121.31,115.98 121.19,116.03 121.05,116.03 120.82,115.97 120.69,115.97 120.47,116.04 120.22,116.04 UC1.AY37
  BOTTOM w0.114: v1(161.05,133.43) 160.41,133.43 160.3,133.55 160.3,134.01 160.41,134.13 161.19,134.13 161.31,134.24 161.31,134.62 161.19,134.74 160.41,134.74 160.3,134.85 160.3,135.23 160.41,135.35 161.19,135.35 161.31,135.46 161.31,135.84 161.19,135.96 160.5,135.96 160.33,136.13 160.33,137.04 160.5,137.21 161.28,137.21 162.05,136.44 162.05,134.92 162.22,134.75 JDIMM1.141
DDR_A_D35: length 62.7
  IN1 w0.076: v2(127.91,117.41) 128.42,116.89 130.26,116.89 130.67,117.31 130.67,117.38
  IN1 w0.114: 130.67,117.38 131.95,118.66 135.84,118.66 137.41,120.22 137.98,120.22 148.38,130.62 148.38,130.79 150.95,133.36 157.54,133.36 158.07,133.89 162.26,133.89 162.9,133.25 168.05,133.25 168.21,133.41 168.21,133.8 168.04,133.98 v1(166.61,133.98)
  BOTTOM w0.076: v2(127.91,117.41) 127.18,116.67 121.78,116.67 121.78,116.68 120.76,116.68 120.54,116.45 119.99,116.45 119.68,116.14 UC1.AW37
  BOTTOM w0.114: JDIMM1.143 165.24,135.35 v1(166.61,133.98)
DDR_A_D36: length 60.5
  IN1 w0.076: v2(127.91,115.63) 128.42,115.12 130.06,115.12 130.38,115.44 130.38,115.55 130.88,116.05 132.66,116.05 132.83,116.22
  IN1 w0.114: v1(169.35,130.87) 169.62,130.87 170.07,131.32 170.07,131.6 169.94,131.73 167.27,131.73 166.41,130.87 164.11,130.87 163.79,130.55 151.58,130.55 150.84,129.81 150.84,129.64 145.77,124.57 145.77,124.2 137.79,116.22 132.83,116.22
  BOTTOM w0.076: v2(127.91,115.63) 127.16,114.87 123.61,114.87 123.46,115.03 122.59,115.03 122.45,114.88 121.45,114.88 UC1.BB39
  BOTTOM w0.114: v1(169.35,130.87) 169.93,131.45 JDIMM1.130
DDR_A_D37: length 61.1
  IN1 w0.076: 132.83,116.55 132.77,116.55 132.43,116.21 130.82,116.21 130.22,115.62 130.22,115.53 129.97,115.28 128.91,115.28 v2(128.56,115.63)
  IN1 w0.114: 132.83,116.55 137.66,116.55 145.44,124.34 145.44,124.7 150.51,129.78 150.51,129.95 151.44,130.88 163.65,130.88 163.97,131.2 166.28,131.2 167.14,132.06 169.66,132.06 169.84,132.23 169.84,132.46 169.66,132.64 v1(169.1,132.64)
  BOTTOM w0.076: UC1.BA39 120.91,114.92 121.06,114.78 121.06,114.77 121.06,114.77 121.31,114.65 121.61,114.65 121.66,114.71 122.51,114.71 122.66,114.86 123.39,114.86 123.54,114.71 127.64,114.71 v2(128.56,115.63)
  BOTTOM w0.114: JDIMM1.132 169.69,132.05 v1(169.1,132.64)
DDR_A_D38: length 61.6
  IN1 w0.076: 130.44,117.61 130.44,117.3 130.19,117.05 129.69,117.05 v2(129.34,117.41)
  IN1 w0.114: v1(169.59,133.85) 168.96,134.47 164.72,134.47 164.42,134.17 164.42,133.79 164.3,133.67 164.07,133.67 163.96,133.79 163.96,134.17 163.84,134.29 163.62,134.29 163.5,134.17 163.5,133.79 163.39,133.67 163.16,133.67 163.04,133.79 163.04,134.17 162.93,134.29 151.41,134.29 148.05,130.92 148.05,130.75 137.85,120.55 137.28,120.55 135.71,118.99 131.81,118.99 130.44,117.61
  BOTTOM w0.076: UC1.BA37 120.98,116.24 121.24,116.51 121.71,116.51 121.71,116.51 128.44,116.51 v2(129.34,117.41)
  BOTTOM w0.114: v1(169.59,133.85) 169.59,133.9 170.13,134.45 JDIMM1.140
DDR_A_D39: length 60.8
  IN1 w0.114: v1(169.72,135.66) 169.72,135.06 169.46,134.8 168.86,134.8 168.75,134.92 168.75,135.22 168.63,135.33 168.41,135.33 168.29,135.22 168.29,134.92 168.18,134.8 167.95,134.8 167.83,134.92 167.83,135.22 167.72,135.33 167.49,135.33 167.38,135.22 167.38,134.92 167.26,134.8 164.58,134.8 164.39,134.62 151.27,134.62 147.72,131.06 147.72,130.89 137.71,120.88 137.14,120.88 135.57,119.32 131.65,119.32 130.05,117.72 v2(130.05,117.41)
  BOTTOM w0.076: v2(130.05,117.41) 128.99,116.34 121.71,116.34 121.61,116.24 UC1.BB37
  BOTTOM w0.114: JDIMM1.142 170.32,135.05 169.72,135.64 v1(169.72,135.66)
DDR_A_D40: length 63.7
  IN1 w0.076: 132.39,120.27 131.98,120.27 129.69,117.97 126.53,117.97 v2(125.96,117.41)
  IN1 w0.114: v1(165.76,135.95) 165.33,136.38 164.35,136.38 164.24,136.27 164.24,136.13 164.12,136.02 163.89,136.02 163.78,136.13 163.78,136.27 163.67,136.38 163.44,136.38 163.32,136.27 163.32,136.13 163.21,136.02 162.98,136.02 162.87,136.13 162.87,136.27 162.75,136.38 162.52,136.38 162.41,136.27 162.41,136.13 162.29,136.02 162.07,136.02 161.95,136.13 161.95,136.27 161.84,136.38 161.61,136.38 161.49,136.27 161.49,136.13 161.38,136.02 161.15,136.02 161.04,136.13 161.04,136.51 160.92,136.62 160.69,136.62 160.58,136.51 160.58,136.13 160.47,136.02 160.24,136.02 160.12,136.13 160.12,136.51 160.01,136.62 159.78,136.62 159.67,136.51 159.67,136.13 159.55,136.02 159.32,136.02 159.21,136.13 159.21,136.51 159.09,136.62 158.87,136.62 158.75,136.51 158.75,136.13 158.64,136.02 158.41,136.02 158.29,136.13 158.29,136.51 158.18,136.62 157.95,136.62 157.84,136.51 157.84,136.13 157.72,136.02 157.49,136.02 157.38,136.13 157.38,136.27 157.27,136.38 156.11,136.38 155.99,136.27 155.99,136.05 155.88,135.94 155.65,135.94 155.54,136.05 155.54,136.27 155.42,136.38 151.69,136.38 144.75,129.44 143.99,129.44 143.33,128.78 143.33,127.85 139.48,124 138.66,124 135.23,120.57 134.3,120.57 134,120.27 132.39,120.27
  BOTTOM w0.076: UC1.AY35 120.22,117.47 120.48,117.47 120.67,117.54 120.87,117.54 120.96,117.5 121.21,117.5 121.22,117.5 121.31,117.54 121.88,117.54 122.09,117.33 123.13,117.33 123.76,117.96 125.4,117.96 v2(125.96,117.41)
  BOTTOM w0.114: JDIMM1.147 165.38,136.55 165.76,136.17 v1(165.76,135.95)
DDR_A_D41: length 64.2
  IN1 w0.076: 132.39,119.94 131.96,119.94 129.82,117.81 127.66,117.81 v2(127.26,117.41)
  IN1 w0.114: 132.39,119.94 134.14,119.94 134.44,120.24 135.39,120.24 138.82,123.67 139.62,123.67 147.03,131.09 147.03,131.26 151.01,135.24 156.94,135.24 157.05,135.35 157.05,135.53 157.16,135.64 157.39,135.64 157.51,135.53 157.51,135.35 157.62,135.24 157.85,135.24 157.96,135.35 157.96,135.53 158.08,135.64 158.31,135.64 158.42,135.53 158.42,135.35 158.54,135.24 158.76,135.24 158.88,135.35 158.88,135.53 158.99,135.64 159.22,135.64 159.34,135.53 159.34,135.35 159.45,135.24 159.68,135.24 159.79,135.35 159.79,135.53 159.91,135.64 160.14,135.64 160.25,135.53 160.25,135.35 160.36,135.24 160.59,135.24 160.71,135.35 160.71,135.53 160.82,135.64 161.05,135.64 161.17,135.53 161.17,135.35 161.28,135.24 161.51,135.24 161.62,135.35 161.62,135.53 161.74,135.64 161.97,135.64 162.08,135.53 162.08,135.35 162.19,135.24 162.42,135.24 162.54,135.35 162.54,135.53 162.65,135.64 162.88,135.64 162.99,135.53 162.99,135.35 163.11,135.24 163.34,135.24 163.45,135.35 163.45,135.53 163.57,135.64 163.79,135.64 163.91,135.53 163.91,135.35 164.02,135.24 164.13,135.24 164.32,135.43 166.56,135.43 v1(167.08,135.95)
  BOTTOM w0.076: v2(127.26,117.41) 126.69,116.84 121.85,116.84 121.85,116.84 120.74,116.84 120.53,117.05 119.98,117.05 119.66,117.37 UC1.AW35
  BOTTOM w0.114: JDIMM1.149 165.88,137.15 v1(167.08,135.95)
DDR_A_D42: length 63.9
  IN1 w0.076: 132.76,122.71 129.64,119.59 127.86,119.59 v2(127.45,119.18)
  IN1 w0.114: 132.76,122.71 132.99,122.71 133.29,123.01 133.98,123.01 137.42,126.45 138.48,126.45 140.89,128.86 140.89,129.84 142.93,131.88 143.74,131.88 147.41,135.54 147.41,135.91 147.97,136.47 148.33,136.47 151.28,139.41 153.07,139.41 153.57,139.91 157.38,139.91 157.88,139.41 158.09,139.41 158.2,139.52 158.2,139.78 158.32,139.9 158.55,139.9 158.66,139.78 158.66,139.52 158.78,139.41 159,139.41 159.12,139.52 159.12,139.78 159.23,139.9 159.46,139.9 159.58,139.78 159.58,139.52 159.69,139.41 159.92,139.41 160.03,139.52 160.03,139.78 160.15,139.9 160.38,139.9 160.49,139.78 160.49,139.52 160.6,139.41 160.83,139.41 160.95,139.52 160.95,139.78 161.06,139.9 161.29,139.9 161.41,139.78 161.41,139.52 161.52,139.41 161.75,139.41 161.86,139.52 161.86,139.78 161.98,139.9 162.21,139.9 162.32,139.78 162.32,139.52 162.43,139.41 162.89,139.41 163.01,139.3 163.01,138.94 163.12,138.83 163.35,138.83 163.47,138.94 163.47,139.3 163.58,139.41 163.81,139.41 163.92,139.3 163.92,138.94 164.04,138.83 164.27,138.83 164.38,138.94 164.38,139.3 164.49,139.41 165.3,139.41 v1(165.71,138.99)
  BOTTOM w0.076: v2(127.45,119.18) 126.94,119.7 123.33,119.7 122.64,119.01 122.3,119.01 122.14,118.85 121.82,118.85 121.76,118.91 121.64,119.03 121.27,119.03 121.04,118.92 120.94,118.87 120.59,118.87 120.32,118.6 UC1.AY33
  BOTTOM w0.114: JDIMM1.157 165.16,139.55 v1(165.71,138.99)
DDR_A_D43: length 63
  IN1 w0.076: v2(128.1,119.18) 129.51,119.18 132.7,122.38
  IN1 w0.114: 132.7,122.38 133.13,122.38 133.43,122.68 134.11,122.68 137.56,126.12 138.62,126.12 141.22,128.72 141.22,129.7 143.06,131.55 143.88,131.55 147.74,135.41 147.74,135.77 148.1,136.14 148.47,136.14 151.41,139.08 153.21,139.08 153.7,139.57 157.26,139.57 157.75,139.08 162.4,139.08 162.99,138.49 166.55,138.49 v1(167,138.94)
  BOTTOM w0.076: v2(128.1,119.18) 126.91,118 126.3,118 126.17,118.13 123.69,118.13 123.06,117.5 122.16,117.5 121.95,117.7 121.28,117.7 121.28,117.7 121.19,117.67 120.99,117.67 120.91,117.7 120.9,117.7 120.9,117.71 120.89,117.71 120.66,117.71 120.54,117.67 120.29,117.67 120.18,117.74 119.67,117.74 119.47,117.95 UC1.AW33
  BOTTOM w0.114: JDIMM1.159 165.3,140.15 166.51,138.94 v1(167,138.94)
DDR_A_D44: length 62
  IN1 w0.076: 132.39,120.6 132.02,120.6 129.6,118.18 126.08,118.18 v2(125.31,117.41)
  IN1 w0.114: 132.39,120.6 133.86,120.6 134.17,120.9 134.98,120.9 138.42,124.33 139.34,124.33 143,127.99 143,128.91 143.86,129.77 144.61,129.77 151.55,136.71 157.2,136.71 157.44,136.95 157.87,136.95 157.99,137.06 157.99,137.16 158.1,137.27 158.33,137.27 158.44,137.16 158.44,137.06 158.56,136.95 158.79,136.95 158.9,137.06 158.9,137.16 159.02,137.27 159.24,137.27 159.36,137.16 159.36,137.06 159.47,136.95 159.7,136.95 159.82,137.06 159.82,137.16 159.93,137.27 160.16,137.27 160.27,137.16 160.27,137.06 160.39,136.95 160.62,136.95 160.73,137.06 160.73,137.16 160.84,137.27 161.07,137.27 161.19,137.16 161.19,136.94 161.41,136.71 168.05,136.71 168.38,136.38 v1(168.38,135.85)
  BOTTOM w0.076: UC1.BB35 121.52,117.17 121.98,117.17 121.99,117.17 123.2,117.17 123.83,117.8 124.92,117.8 v2(125.31,117.41)
  BOTTOM w0.114: v1(168.38,135.85) 168.79,136.25 JDIMM1.146
DDR_A_D45: length 62.6
  IN1 w0.076: v2(124.01,117.41) 124.95,118.35 129.53,118.35 132.11,120.93 132.39,120.93
  IN1 w0.114: 132.39,120.93 133.73,120.93 134.03,121.23 134.85,121.23 138.28,124.66 139.21,124.66 142.67,128.12 142.67,129.05 143.72,130.1 144.48,130.1 151.42,137.04 157.06,137.04 157.65,137.64 161.43,137.64 162.02,137.04 168.19,137.04 168.89,136.35 169.84,136.35 170.11,136.62 170.11,136.96 v1(169.62,137.45)
  BOTTOM w0.076: v2(124.01,117.41) 123.61,117 121.92,117 121.25,117.01 120.99,117.27 UC1.BA35
  BOTTOM w0.114: JDIMM1.148 170.22,136.85 v1(169.62,137.45)
DDR_A_D46: length 62.6
  IN1 w0.076: 132.74,123.4 131.49,122.15 131.49,122.04 129.41,119.95 124.32,119.95 v2(123.55,119.18)
  IN1 w0.114: 132.74,123.4 133.02,123.67 133.7,123.67 137.15,127.11 138.21,127.11 140.23,129.13 140.23,130.11 142.65,132.54 143.47,132.54 146.75,135.82 146.75,136.18 147.69,137.13 148.06,137.13 151,140.07 152.8,140.07 153.19,140.46 153.19,140.96 153.48,141.25 157.42,141.25 158.02,140.65 164.09,140.65 164.67,140.07 165.96,140.07 166.17,139.86 168.64,139.86 v1(169.04,140.27)
  BOTTOM w0.076: v2(123.55,119.18) 123.19,118.83 122.35,118.83 122.21,118.69 121.75,118.69 121.57,118.86 121.31,118.86 121.06,118.75 121.06,118.74 121.06,118.74 120.91,118.6 UC1.BA33
  BOTTOM w0.114: v1(169.04,140.27) 169.46,139.85 JDIMM1.158
DDR_A_D47: length 61.8
  IN1 w0.076: 132.08,122.32 129.54,119.77 124.78,119.77 v2(124.2,119.18)
  IN1 w0.114: 132.08,122.32 132.81,123.04 132.85,123.04 133.15,123.34 133.84,123.34 137.28,126.78 138.35,126.78 140.56,128.99 140.56,129.98 142.79,132.21 143.6,132.21 147.08,135.68 147.08,136.05 147.83,136.8 148.2,136.8 151.14,139.74 152.94,139.74 153.49,140.29 162.28,140.29 162.83,139.74 163.21,139.74 163.32,139.85 163.32,140.18 163.44,140.3 163.66,140.3 163.78,140.18 163.78,139.85 163.89,139.74 165.63,139.74 165.92,139.45 169.48,139.45 v1(170.36,140.34)
  BOTTOM w0.076: v2(124.2,119.18) 123.68,118.66 122.42,118.66 122.28,118.52 121.63,118.52 121.55,118.6 UC1.BB33
  BOTTOM w0.114: v1(170.36,140.34) 170.47,140.45 JDIMM1.160
DDR_A_D48: length 66.4
  IN1 w0.076: v2(129.59,121.09) 129.78,121.09 130.93,122.24 130.93,123.4 131.2,123.67
  IN1 w0.114: 131.2,123.67 132.48,124.95 133.17,124.95 136.61,128.39 137.68,128.39 138.94,129.66 138.94,130.64 142.12,133.82 142.94,133.82 145.46,136.35 145.46,136.71 147.34,138.59 147.34,139 150.88,142.54 161.52,142.54 162.12,141.93 162.43,141.93 162.55,142.05 162.55,142.21 162.66,142.33 162.89,142.33 163,142.21 163,142.05 163.12,141.93 163.35,141.93 163.46,142.05 163.46,142.21 163.57,142.33 163.8,142.33 163.92,142.21 163.92,142.05 164.03,141.93 164.26,141.93 164.38,142.05 164.38,142.21 164.49,142.33 164.72,142.33 164.83,142.21 164.83,142.05 164.95,141.93 167.28,141.93 167.78,141.43 v1(167.78,141.15)
  BOTTOM w0.076: v2(129.59,121.09) 128.45,119.95 123.13,119.95 122.81,119.64 122.7,119.64 122.7,119.64 122.15,119.64 121.81,119.64 121.64,119.47 121.27,119.47 121.25,119.48 120.87,119.63 120.59,119.63 120.32,119.9 UC1.AY31
  BOTTOM w0.114: v1(167.78,141.15) 167.18,140.55 166.28,140.55 165.21,141.61 164.88,141.61 164.62,141.35 JDIMM1.163
DDR_A_D49: length 66.8
  IN1 w0.076: v2(123.75,121.09) 124.64,120.21 129.43,120.21 130.03,120.81 130.04,120.81 131.32,122.09 131.32,122.85
  IN1 w0.114: v1(166.44,141.16) 166.44,140.84 166.29,140.69 164.92,140.69 164.34,141.27 160.19,141.27 160.08,141.39 160.08,141.76 159.96,141.88 159.73,141.88 159.62,141.76 159.62,141.39 159.51,141.27 159.28,141.27 159.16,141.39 159.16,141.76 159.05,141.88 158.82,141.88 158.71,141.76 158.71,141.39 158.59,141.27 158.28,141.27 157.68,141.88 151.93,141.88 151.25,141.2 151.09,141.2 150.87,141.41 150.71,141.41 150.55,141.25 150.55,141.09 150.76,140.87 150.76,140.71 150.6,140.55 150.44,140.55 150.23,140.76 150.06,140.76 149.9,140.6 149.9,140.44 150.12,140.23 150.12,140.07 149.95,139.9 149.79,139.9 149.58,140.12 149.42,140.12 149.26,139.96 149.26,139.79 149.47,139.58 149.47,139.42 147.8,137.75 147.43,137.75 146.12,136.44 146.12,136.07 143.21,133.16 142.39,133.16 139.61,130.37 139.61,129.39 137.95,127.73 136.89,127.73 133.45,124.29 132.76,124.29 131.32,122.85
  BOTTOM w0.076: UC1.AW31 119.47,120.55 119.72,120.81 120.29,120.81 120.34,120.83 120.52,120.83 120.68,120.78 120.83,120.78 121.04,120.84 121.16,120.84 121.24,120.81 121.27,120.79 121.8,120.79 122.09,121.09 123.75,121.09 v2(123.75,121.09)
  BOTTOM w0.114: JDIMM1.165 165.65,141.95 v1(166.44,141.16)
DDR_A_D50: length 65.7
  IN1 w0.076: 130.44,124.93 130.21,124.7 130.21,122.49 129.82,122.11 125.43,122.11 124.42,121.09 v2(124.41,121.09)
  IN1 w0.114: v1(165.64,144.81) 165.64,144.87 165.29,145.21 164.76,145.21 164.24,144.69 163.89,144.69 163.77,144.8 163.77,145.09 163.66,145.21 163.43,145.21 163.32,145.09 163.32,144.8 163.2,144.69 162.97,144.69 162.86,144.8 162.86,145.09 162.75,145.21 162.52,145.21 162.4,145.09 162.4,144.8 162.29,144.69 162.06,144.69 161.95,144.8 161.95,145.09 161.83,145.21 161.6,145.21 161.49,145.09 161.49,144.8 161.37,144.69 161.15,144.69 161.03,144.8 161.03,145.09 160.92,145.21 160.69,145.21 160.57,145.09 160.57,144.8 160.46,144.69 160.23,144.69 160.12,144.8 160.12,145.09 160,145.21 159.77,145.21 159.66,145.09 159.66,144.8 159.55,144.69 158.5,144.69 157.62,145.57 154.76,145.57 154.16,146.17 151.79,146.17 150.83,145.22 150.83,145 145.57,139.73 145.57,139.62 143.12,137.17 142.25,137.17 141.37,136.29 141.37,135.98 139.65,134.26 139.65,133.97 132.44,126.76 131.77,126.76 130.44,125.43 130.44,124.93
  BOTTOM w0.076: v2(124.41,121.09) 124.41,121.09 124.04,121.46 123.11,121.46 122.91,121.25 122.03,121.25 121.73,120.96 121.31,120.96 121.19,121.01 121.05,121.01 120.82,120.95 120.69,120.95 120.47,121.02 120.22,121.02 UC1.AY29
  BOTTOM w0.114: JDIMM1.175 164.46,144.95 164.73,145.22 165.22,145.22 v1(165.64,144.81)
DDR_A_D51: length 66.9
  IN1 w0.076: v2(127.66,122.69) 128.07,122.28 129.77,122.28 130.03,122.54 130.03,124.89 130.18,125.04
  IN1 w0.114: 130.18,125.04 130.18,125.64 131.63,127.09 132.3,127.09 139.32,134.11 139.32,134.4 141.04,136.12 141.04,136.43 142.32,137.71 143.19,137.71 145.24,139.76 145.24,140.09 151.77,146.62 157.29,146.62 158.36,145.54 158.9,145.54 159.02,145.66 159.02,145.96 159.13,146.07 159.36,146.07 159.48,145.96 159.48,145.66 159.59,145.54 159.82,145.54 159.93,145.66 159.93,145.96 160.05,146.07 160.28,146.07 160.39,145.96 160.39,145.66 160.5,145.54 166.67,145.54 166.93,145.28 v1(166.93,144.83)
  BOTTOM w0.076: v2(127.66,122.69) 126.92,121.95 122.9,121.95 122.69,121.75 121.8,121.75 121.71,121.66 120.76,121.66 120.54,121.44 119.99,121.44 119.68,121.13 UC1.AW29
  BOTTOM w0.114: v1(166.93,144.83) 166.21,145.55 JDIMM1.177
DDR_A_D52: length 64.5
  IN1 w0.076: 131.12,123.12 131.12,122.13 129.88,120.89 129.88,120.88 129.46,120.46 128.29,120.46 v2(127.66,121.09)
  IN1 w0.114: v1(169.3,141.65) 169.3,141.47 168.31,140.48 167.23,140.48 166.99,140.72 166.99,141.31 166.69,141.6 161.54,141.6 161.42,141.72 161.42,142.09 161.3,142.21 161.07,142.21 160.96,142.09 160.96,141.72 160.85,141.61 160.62,141.61 160.5,141.72 160.5,142.09 160.39,142.21 151.02,142.21 147.67,138.86 147.67,138.46 145.79,136.58 145.79,136.21 143.07,133.49 142.26,133.49 139.28,130.51 139.28,129.52 137.81,128.06 136.75,128.06 133.31,124.62 132.62,124.62 131.12,123.12
  BOTTOM w0.076: UC1.BB31 121.49,119.97 122.28,119.97 122.63,119.97 122.94,120.28 126.85,120.28 v2(127.66,121.09)
  BOTTOM w0.114: v1(169.3,141.65) JDIMM1.164
DDR_A_D53: length 65.3
  IN1 w0.076: 130.77,123.7 130.77,122.31 129.97,121.51 128.73,121.51 v2(128.31,121.09)
  IN1 w0.114: v1(168.18,142.55) 167.89,142.26 165.33,142.26 164.35,143.24 164.05,143.24 163.94,143.13 163.94,142.82 163.82,142.71 163.59,142.71 163.48,142.82 163.48,143.13 163.36,143.24 163.14,143.24 163.02,143.13 163.02,142.82 162.91,142.71 162.68,142.71 162.56,142.82 162.56,143.13 162.45,143.24 161.62,143.24 161.24,142.87 160.39,142.87 160.01,143.25 159.26,143.25 158.88,142.87 158.28,142.87 157.56,143.59 151.47,143.59 147.01,139.14 147.01,138.73 144.01,135.73 143.57,135.73 141.99,134.15 141.98,134.15 138.94,131.11 138.86,131.11 133.04,125.28 132.35,125.28 130.77,123.7
  BOTTOM w0.076: UC1.BA31 120.91,119.9 121.06,119.76 121.06,119.76 121.06,119.75 121.31,119.63 121.57,119.63 121.74,119.8 122.21,119.8 122.21,119.8 122.63,119.8 122.63,119.8 122.74,119.8 123.05,120.12 127.33,120.12 v2(128.31,121.09)
  BOTTOM w0.114: JDIMM1.166 170.09,142.25 169.53,142.81 168.43,142.81 v1(168.18,142.55)
DDR_A_D54: length 65.4
  IN1 w0.076: v2(129.02,122.69) 129.02,123.23 129.65,123.87 129.65,125.45 129.72,125.52
  IN1 w0.114: 129.72,125.52 129.72,126.13 131.4,127.8 132.08,127.8 138.66,134.38 138.66,134.67 140.38,136.39 140.38,136.7 142.98,139.3 143.52,139.3 151.49,147.28 157.56,147.28 157.93,146.92 162.89,146.92 163.6,146.21 167.29,146.21 v1(169.5,144)
  BOTTOM w0.076: UC1.BA29 120.99,121.22 121.26,121.49 121.8,121.49 121.89,121.58 122.76,121.58 122.97,121.79 128.12,121.79 v2(129.02,122.69)
  BOTTOM w0.114: JDIMM1.174 170.15,144.65 v1(169.5,144)
DDR_A_D55: length 64.6
  IN1 w0.076: 129.95,125.27 129.81,125.14 129.81,123.73 129.68,123.6 v2(129.68,122.69)
  IN1 w0.114: 129.95,125.27 129.95,125.89 131.53,127.47 132.22,127.47 138.99,134.24 138.99,134.54 140.71,136.26 140.71,136.56 142.19,138.04 143.06,138.04 144.86,139.85 144.86,140.18 151.63,146.95 157.42,146.95 157.79,146.58 162.75,146.58 163.46,145.87 166.81,145.87 168.15,144.53 v1(168.23,144.53)
  BOTTOM w0.076: v2(129.68,122.69) 128.61,121.62 123.03,121.62 122.83,121.42 121.96,121.42 121.76,121.22 UC1.BB29
  BOTTOM w0.114: JDIMM1.176 169.93,145.25 169.22,144.53 v1(168.23,144.53)
DDR_A_D56: length 71.2
  IN1 w0.076: 128.92,125.66 129.33,125.24 129.33,124.17 128.51,123.34 126.36,123.34 v2(125.71,122.69)
  IN1 w0.114: 128.92,125.66 128.92,126.67 131,128.76 131.14,128.76 131.55,129.17 131.55,129.48 134.32,132.25 134.32,133.14 135.26,134.08 136.15,134.08 138.81,136.74 138.81,136.9 138.56,137.15 138.56,137.31 138.72,137.47 138.88,137.47 139.13,137.23 139.29,137.23 139.45,137.39 139.45,137.55 139.21,137.79 139.21,137.96 139.37,138.12 139.53,138.12 139.78,137.87 139.94,137.87 140.13,138.07 140.13,138.9 141.06,139.82 141.85,139.82 145.82,143.79 146.52,143.79 151.72,148.98 157.21,148.98 157.55,148.64 161.35,148.64 162.13,147.87 162.71,147.87 162.83,147.98 162.83,148.38 162.94,148.5 163.17,148.5 163.28,148.38 163.28,147.98 163.4,147.87 163.63,147.87 163.74,147.98 163.74,148.38 163.85,148.5 164.08,148.5 164.2,148.38 164.2,147.98 164.31,147.87 164.42,147.87 164.65,148.1 166.01,148.1 166.3,147.81 166.3,147.24 166.72,146.83 167.17,146.83 v1(167.34,147)
  BOTTOM w0.076: UC1.AY27 120.22,122.45 120.48,122.45 120.67,122.52 120.87,122.52 120.96,122.48 121.21,122.48 121.22,122.48 121.31,122.52 121.57,122.52 121.68,122.41 122.41,122.41 123.22,123.22 125.18,123.22 v2(125.71,122.69)
  BOTTOM w0.114: v1(167.34,147) 165.89,147 165.65,146.75 JDIMM1.181
DDR_A_D57: length 72.1
  IN1 w0.076: v2(127.01,122.69) 127.48,123.16 128.66,123.16 129.49,124 129.49,125.56 129.49,125.56
  IN1 w0.114: v1(165.73,147.63) 165.73,147.08 165.48,146.83 164.78,146.83 164.66,146.94 164.66,147.31 164.55,147.42 164.32,147.42 164.21,147.31 164.21,146.94 164.09,146.83 163.86,146.83 163.15,147.54 160.99,147.54 160.88,147.65 160.88,148.14 160.76,148.26 160.54,148.26 160.42,148.14 160.42,147.65 160.31,147.54 160.08,147.54 159.96,147.65 159.96,148.14 159.85,148.26 159.62,148.26 159.51,148.14 159.51,147.65 159.39,147.54 159.16,147.54 159.05,147.65 159.05,148.14 158.94,148.26 158.71,148.26 158.59,148.14 158.59,147.65 158.48,147.54 158.19,147.54 157.82,147.9 151.24,147.9 146.53,143.2 146.37,143.2 146.12,143.46 145.96,143.46 145.79,143.29 145.79,143.13 146.05,142.88 146.05,142.72 145.89,142.56 145.73,142.56 145.47,142.81 145.31,142.81 145.15,142.65 145.15,142.49 145.4,142.23 145.4,142.07 145.24,141.91 145.08,141.91 144.82,142.16 144.66,142.16 144.5,142 144.5,141.84 144.76,141.59 144.76,141.42 144.59,141.26 144.43,141.26 144.18,141.52 144.02,141.52 143.85,141.35 143.85,141.19 144.11,140.94 144.11,140.78 143.95,140.62 143.79,140.62 143.53,140.87 143.37,140.87 143.21,140.71 143.21,140.55 143.46,140.29 143.46,140.13 143.26,139.93 142.58,139.93 136.71,134.06 136.71,133.31 131.82,128.42 131.14,128.42 129.27,126.56 129.27,125.79 129.49,125.56
  BOTTOM w0.076: UC1.AW27 119.66,122.35 119.98,122.03 120.53,122.03 120.74,121.82 121.64,121.82 121.73,121.91 122.62,121.91 122.95,122.24 126.55,122.24 v2(127.01,122.69)
  BOTTOM w0.114: v1(165.73,147.63) 165.73,147.58 165.33,147.17 164.75,147.17 164.58,147.35 JDIMM1.183
DDR_A_D58: length 70.7
  IN1 w0.114: v2(125.85,124.64) 125.85,128.64 129.19,131.98 129.19,136.57 130.25,137.63 135.42,137.63 140.4,142.61 140.76,142.61 151.35,153.2 157.53,153.2 159.03,151.69 162.49,151.69 162.61,151.58 162.61,150.86 162.72,150.75 163.12,150.75 163.23,150.86 163.23,151.58 163.34,151.69 163.74,151.69 163.85,151.58 163.85,150.86 163.97,150.75 164.36,150.75 164.47,150.86 164.47,151.58 164.59,151.69 165.52,151.69 165.89,151.32 v1(165.89,150.95)
  BOTTOM w0.076: UC1.AY25 120.32,123.58 120.59,123.85 120.94,123.85 121.04,123.9 121.3,124.02 122.47,124.02 123.46,125.01 125.65,125.01 125.85,124.8 v2(125.85,124.64)
  BOTTOM w0.114: JDIMM1.191 164.69,149.75 v1(165.89,150.95)
DDR_A_D59: length 71.2
  IN1 w0.076: 126.26,125.16 126.26,124.45 126.49,124.22 128.18,124.22 v2(128.61,124.64)
  IN1 w0.114: 126.26,125.16 126.26,128.58 129.52,131.84 129.52,136.43 129.85,136.75 135.01,136.75 140.54,142.28 140.9,142.28 146.47,147.85 146.63,147.85 147.02,147.47 147.18,147.47 147.46,147.75 147.46,147.91 147.07,148.29 147.07,148.45 147.35,148.73 147.51,148.73 147.9,148.35 148.06,148.35 148.34,148.63 148.34,148.79 147.95,149.17 147.95,149.33 151.49,152.87 157.39,152.87 159.52,150.74 v1(162.02,150.74)
  BOTTOM w0.076: v2(128.61,124.64) 127.35,123.39 123.13,123.39 122.32,122.57 121.75,122.57 121.64,122.69 121.28,122.69 121.28,122.68 121.19,122.65 120.99,122.65 120.91,122.69 120.9,122.69 120.9,122.69 120.89,122.69 120.66,122.69 120.54,122.65 120.29,122.65 120.18,122.72 119.67,122.72 119.47,122.93 UC1.AW25
  BOTTOM w0.114: v1(162.02,150.74) 162.41,150.35 JDIMM1.193
DDR_A_D60: length 69.5
  IN1 w0.076: 128.59,125.51 128.77,125.33 128.89,125.33 129.17,125.05 129.17,124.36 128.39,123.58 125.94,123.58 v2(125.06,122.69)
  IN1 w0.114: v1(168.39,147.59) 167.77,147.59 166.93,148.43 164.62,148.43 164.08,148.97 157.69,148.97 157.35,149.31 156.94,149.31 156.82,149.43 156.82,149.73 156.71,149.84 156.48,149.84 156.36,149.73 156.36,149.43 156.25,149.31 153.53,149.31 153.42,149.43 153.42,149.74 153.3,149.85 153.07,149.85 152.96,149.74 152.96,149.43 152.85,149.31 152.62,149.31 152.5,149.43 152.5,149.74 152.39,149.85 152.16,149.85 152.05,149.74 152.05,149.43 151.93,149.31 151.58,149.31 146.39,144.12 145.68,144.12 141.72,140.15 140.92,140.15 137.93,137.16 137.93,136.39 135.95,134.41 135.12,134.41 133.93,133.22 133.93,132.39 131.65,130.11 130.54,130.11 128.59,128.16 128.59,125.51
  BOTTOM w0.076: v2(125.06,122.69) 124.69,123.06 123.29,123.06 122.47,122.24 121.43,122.24 UC1.BB27
  BOTTOM w0.114: v1(168.39,147.59) 168.39,147.57 169.51,146.45 JDIMM1.180
DDR_A_D61: length 70.2
  IN1 w0.076: 128.26,125.34 128.52,125.07 128.76,125.07 129.01,124.81 129.01,124.49 128.28,123.76 124.28,123.76 123.75,123.23 v2(123.75,122.69)
  IN1 w0.114: 128.26,125.34 128.26,128.29 130.4,130.44 131.51,130.44 133.6,132.53 133.6,133.36 134.98,134.74 135.81,134.74 137.6,136.53 137.6,137.3 140.78,140.48 141.58,140.48 145.55,144.45 146.26,144.45 152.42,150.62 156.51,150.62 157.82,149.3 164.22,149.3 164.76,148.76 165.47,148.76 165.58,148.88 165.58,149.17 165.7,149.28 166.09,149.28 166.21,149.17 166.21,148.88 166.32,148.76 167.07,148.76 167.71,148.11 169.47,148.11 169.72,147.86 v1(169.72,147.65)
  BOTTOM w0.076: UC1.BA27 120.99,122.25 121.25,121.99 121.57,121.99 121.66,122.08 122.54,122.08 123.16,122.69 v2(123.75,122.69)
  BOTTOM w0.114: JDIMM1.182 169.95,147.05 169.72,147.28 v1(169.72,147.65)
DDR_A_D62: length 69.8
  IN1 w0.114: v2(124.06,124.64) 124.06,127.78 128.53,132.25 128.53,137.17 129.66,138.29 135.15,138.29 140.13,143.27 140.49,143.27 151.08,153.86 157.8,153.86 159.28,152.38 168.09,152.38 v1(170.31,150.16)
  BOTTOM w0.076: v2(124.06,124.64) 123.84,124.43 123.13,124.43 122.56,123.86 121.33,123.86 121.07,123.73 120.91,123.58 UC1.BA25
  BOTTOM w0.114: JDIMM1.192 170.42,150.05 v1(170.31,150.16)
DDR_A_D63: length 69.3
  IN1 w0.114: v2(124.66,124.64) 124.66,127.91 128.86,132.11 128.86,136.7 130.12,137.96 135.29,137.96 140.27,142.94 140.63,142.94 151.21,153.53 157.66,153.53 159.15,152.05 165.82,152.05 v1(168.08,149.79)
  BOTTOM w0.076: UC1.BB25 121.64,123.58 121.65,123.59 121.75,123.69 122.71,123.69 123.27,124.25 124.26,124.25 v2(124.66,124.64)
  BOTTOM w0.114: v1(168.08,149.79) 168.09,149.8 168.09,149.9 168.85,150.65 JDIMM1.194
DDR_A_DQS0: length 81.2
  IN1 w0.114: v1(168.71,92.5) 168.95,92.26 168.95,92.05 168.84,91.94 167.83,91.94 167.29,92.48 165.73,92.48 165.47,92.23 164.52,92.23 163.31,91.02 163.31,90.69 163.61,90.39 163.61,90.12 163.43,89.95 163.17,89.95 162.87,90.25 162.54,90.25 162.14,89.85 162.14,89.53 161.91,89.3 161.59,89.3 160.29,87.99 160.29,87.55 156.31,83.58 116.37,83.58 113.04,86.91 113.04,91.05 113.12,91.13 113.12,91.66 113.3,91.84 114.17,91.84 114.65,92.32 114.65,93.14 114.38,93.4 114.15,93.4 v2(113.91,93.65)
  BOTTOM w0.076: UC1.AM69 115.16,97.87 115.12,97.83 115.01,97.83 114.9,97.72 114.82,97.54 114.82,97.27 114.85,97.19 114.85,96.98 114.8,96.87 114.8,96.65 114.85,96.54 114.85,95.97 114.78,95.9 114.78,93.78 114.4,93.4 114.16,93.4 v2(113.91,93.65)
  BOTTOM w0.114: JDIMM1.12 170.6,93.65 170.41,93.46 169.3,93.46 169.05,93.21 169.05,92.84 v1(168.71,92.5)
DDR_A_DQS1: length 68.6
  IN1 w0.114: v2(119.69,93.43) 119.92,93.66 120.51,93.66 120.55,93.66 123.74,90.48 123.74,89.57 124.89,88.42 151.12,88.42 153.46,90.77 157.39,90.77 158.21,91.59 158.21,91.86 164.42,98.07 167.08,98.07 167.64,98.63 168.3,98.63 168.41,98.52 168.41,98.28 168.21,98.08 v1(167.85,98.08)
  BOTTOM w0.076: v2(119.69,93.43) 119.46,93.65 119.4,93.65 119.22,93.66 119.04,93.83 119.04,94.1 118.01,95.13 118.01,96.07 117.84,96.24 117.84,96.57 117.9,96.71 117.9,96.82 117.84,96.95 117.84,96.98 117.84,97.22 117.89,97.33 117.89,97.54 117.85,97.61 117.8,97.66 117.65,97.66 117.61,97.62 UC1.AT70
  BOTTOM w0.114: v1(167.85,98.08) 168.21,98.08 168.38,97.9 168.38,97.74 168.21,97.57 167.37,97.57 166.39,98.55 164.91,98.55 164.71,98.75 JDIMM1.29
DDR_A_DQS2: length 62.3
  IN1 w0.076: 128.82,93.94 128.82,93.96 128.8,93.98 128.8,94.01 127.99,94.83 126.65,94.83 126.34,94.52 126.34,94.23 126.16,94.05 v2(126.09,94.05)
  IN1 w0.114: v1(165.79,104.7) 165.97,104.7 166.15,104.53 166.15,104.15 165.91,103.92 165.07,103.92 164.11,102.96 162.89,102.96 159.34,99.42 159.34,99.1 157.29,97.05 152,97.05 148.01,93.06 129.69,93.06 128.82,93.94
  BOTTOM w0.076: v2(126.09,94.05) 126.22,94.05 126.38,94.21 126.38,95 125.4,95.98 123.8,95.98 123.35,96.42 123.35,97.99 123.35,99.43 122.49,100.3 121.73,100.3 121.57,100.46 121.31,100.46 121.2,100.41 120.98,100.41 120.87,100.46 120.66,100.46 120.56,100.41 120.32,100.41 120.11,100.51 120.07,100.55 120.07,100.55 120.02,100.6 120.02,100.72 119.98,100.76 UC1.AY64
  BOTTOM w0.114: JDIMM1.47 164.71,104.15 164.9,103.96 165.73,103.96 166.14,104.36 166.14,104.54 165.98,104.7 v1(165.79,104.7)
DDR_A_DQS3: length 63.1
  IN1 w0.114: v2(125.22,100.9) 125.31,100.9 126.65,99.56 128.03,99.56 129.16,98.43 129.92,98.43 131.2,97.15 146.09,97.15 152.82,103.88 157.9,103.88 163.92,109.9 167.53,109.9 168.14,109.3 168.76,109.3 169.17,109.7 169.17,109.98 v1(169.47,110.28)
  BOTTOM w0.076: v2(125.22,100.9) 125.31,100.9 125.42,101 125.42,101.32 125.34,101.4 124.72,101.4 122.83,103.29 122.51,103.29 122.45,103.29 122.13,103.6 121.83,103.6 121.67,103.44 121.3,103.44 121.14,103.5 121.04,103.5 120.91,103.44 120.63,103.44 120.54,103.48 120.34,103.48 120.2,103.42 120.09,103.31 120.09,103.25 120.13,103.21 120.23,103.21 UC1.BA60
  BOTTOM w0.114: JDIMM1.64 170.6,109.25 170.41,109.06 169.49,109.06 169.25,109.3 169.25,110.06 v1(169.47,110.28)
DDR_A_DQS4: length 61.6
  IN1 w0.076: v2(126.61,115.63) 126.42,115.82 126.42,116 126.68,116.27 130.42,116.27 130.75,116.59 131.05,116.59 131.06,116.58 131.08,116.58
  IN1 w0.114: v1(166.57,132.5) 166.31,132.23 166.31,132.11 166.02,131.82 164.58,131.82 164.35,132.05 164.35,132.27 164.24,132.39 163.84,132.39 163.73,132.27 163.73,132.05 163.5,131.82 163.04,131.82 162.24,132.62 161.33,132.62 160.53,131.83 159.36,131.83 159.13,132.06 159.13,132.57 159.02,132.69 158.63,132.69 158.51,132.57 158.51,132.06 158.28,131.83 151.05,131.83 149.57,130.35 149.57,130.18 144.49,125.1 144.49,124.75 137.24,117.51 132.44,117.51 131.51,116.58 131.08,116.58
  BOTTOM w0.076: v2(126.61,115.63) 126.41,115.42 126.41,115.26 126.22,115.07 123.67,115.07 123.51,115.23 122.5,115.23 122.32,115.05 121.83,115.05 121.7,115.18 121.31,115.18 121.2,115.13 121.17,115.13 120.98,115.13 120.87,115.18 120.66,115.18 120.53,115.12 120.37,115.12 120.19,115.19 120.05,115.28 120,115.32 119.97,115.34 119.94,115.36 UC1.AY38
  BOTTOM w0.114: JDIMM1.137 164.71,133.55 164.9,133.36 165.97,133.36 166.38,132.94 166.38,132.69 v1(166.57,132.5)
DDR_A_DQS5: length 63.3
  IN1 w0.076: v2(126.15,119.18) 125.9,118.94 125.9,118.84 125.97,118.77 129.43,118.77 132.4,121.74 132.47,121.74 132.48,121.76 132.5,121.76
  IN1 w0.114: 132.5,121.76 133.4,121.76 133.69,122.06 134.45,122.06 137.89,125.5 138.88,125.5 141.84,128.46 141.84,129.44 143.32,130.92 144.14,130.92 151.67,138.46 153.78,138.46 154.06,138.74 155.01,138.74 155.3,138.46 162.14,138.46 162.73,137.86 167.04,137.86 167.61,138.43 168.36,138.43 168.51,138.58 v1(168.51,138.77)
  BOTTOM w0.076: UC1.BA34 120.44,117.93 120.23,117.93 120.17,118 120.17,118.08 120.19,118.13 120.27,118.18 120.38,118.22 120.51,118.22 120.63,118.17 120.91,118.17 121.04,118.22 121.16,118.22 121.27,118.17 122.39,118.17 122.53,118.3 125.58,118.3 125.97,118.69 125.97,119.01 v2(126.15,119.18)
  BOTTOM w0.114: v1(168.51,138.77) 168.51,138.67 168.73,138.46 170.41,138.46 170.6,138.65 JDIMM1.154
DDR_A_DQS6: length 65.8
  IN1 w0.076: 130.59,124.42 130.59,124.4 130.58,124.39 130.58,122.4 129.87,121.69 128.86,121.69 128.86,121.68 126.6,121.68 126.36,121.44 v2(126.36,121.09)
  IN1 w0.114: 130.59,124.42 132.09,125.92 132.8,125.92 138.57,131.69 138.65,131.69 140.73,133.78 140.73,134.18 142.32,135.77 142.73,135.77 143.31,136.35 143.46,136.35 146.39,139.28 146.39,139.39 151.75,144.75 157.28,144.75 158.16,143.87 164.6,143.87 165.59,142.89 167.08,142.89 167.35,143.15 167.35,143.32 v1(167.57,143.54)
  BOTTOM w0.076: v2(126.36,121.09) 126.16,120.89 126.16,120.74 125.92,120.5 122.86,120.5 122.49,120.13 122.35,120.13 121.95,120.14 121.92,120.17 121.31,120.17 121.2,120.11 120.98,120.11 120.87,120.17 120.66,120.17 120.57,120.12 120.32,120.12 120.19,120.17 120.05,120.26 119.93,120.35 UC1.AY30
  BOTTOM w0.114: JDIMM1.171 164.62,143.75 164.76,143.61 165.04,143.61 165.66,144.23 167.11,144.23 167.37,143.96 167.37,143.74 v1(167.57,143.54)
DDR_A_DQS7: length 70.8
  IN1 w0.114: v2(127.31,124.64) 127.08,124.87 127.08,128.18 130.1,131.2 131.39,131.2 132.98,132.79 132.98,133.86 134.43,135.31 134.73,135.31 140.63,141.21 141.43,141.21 146.44,146.22 147.1,146.22 150.64,149.76 150.64,150.86 151.52,151.74 156.73,151.74 158.55,149.92 164.24,149.92 166.78,149.92 167.96,148.75 169.49,148.75 169.72,148.98 169.72,149.26 169.92,149.46 v1(170.09,149.46)
  BOTTOM w0.076: UC1.BA26 120.44,122.91 120.23,122.91 120.17,122.98 120.17,123.06 120.19,123.1 120.27,123.16 120.37,123.2 120.52,123.2 120.63,123.15 120.91,123.15 121.04,123.2 121.14,123.2 121.28,123.15 121.31,123.15 121.67,123.15 121.89,123.36 122.85,123.36 123.05,123.56 126.69,123.56 127.09,123.96 127.09,124.42 v2(127.31,124.64)
  BOTTOM w0.114: JDIMM1.188 170.6,148.85 170.41,148.66 169.95,148.66 169.81,148.8 169.81,149.27 169.99,149.46 v1(170.09,149.46)
DDR_A_DQS#0: length 81.2
  IN1 w0.114: v2(113.91,93) 114.11,93.2 114.3,93.2 114.45,93.05 114.45,92.4 114.09,92.04 113.22,92.04 112.93,91.75 112.93,91.22 112.84,91.13 112.84,86.83 116.29,83.38 156.39,83.38 160.48,87.47 160.48,87.91 161.67,89.1 161.99,89.1 162.34,89.45 162.34,89.77 162.62,90.05 162.79,90.05 163.08,89.75 163.52,89.75 163.8,90.04 163.8,90.48 163.51,90.77 163.51,90.93 164.6,92.03 165.56,92.03 165.81,92.29 167.2,92.29 167.75,91.74 168.92,91.74 169.15,91.97 169.15,92.18 v1(169.47,92.5)
  BOTTOM w0.076: UC1.AM70 115.26,97.58 115.17,97.66 115.08,97.66 115.04,97.62 114.98,97.5 114.98,97.3 114.99,97.29 115.02,97.22 115.02,96.95 114.96,96.82 114.96,96.71 115.02,96.57 115.02,96.49 115.02,95.9 114.94,95.83 114.94,93.71 114.46,93.23 114.14,93.23 v2(113.91,93)
  BOTTOM w0.114: JDIMM1.10 170.6,93.05 170.41,93.24 169.39,93.24 169.26,93.12 169.26,92.71 v1(169.47,92.5)
DDR_A_DQS#1: length 68.6
  IN1 w0.114: v2(119.69,94.08) 119.91,93.86 120.51,93.86 120.63,93.86 123.93,90.56 123.93,89.65 124.97,88.61 151.03,88.61 153.38,90.96 157.31,90.96 158.01,91.67 158.01,91.95 164.34,98.27 167,98.27 167.56,98.83 168.38,98.83 168.61,98.6 168.61,98.3 v1(168.84,98.08)
  BOTTOM w0.076: UC1.AT69 117.61,97.89 117.67,97.83 117.87,97.83 117.99,97.71 118.05,97.57 118.05,97.29 118.01,97.19 118.01,96.98 118.06,96.87 118.06,96.65 118.01,96.54 118.01,96.31 118.17,96.14 118.17,95.2 119.21,94.17 119.21,93.9 119.29,93.82 119.43,93.82 v2(119.69,94.08)
  BOTTOM w0.114: JDIMM1.27 164.71,98.15 164.89,98.33 166.3,98.33 167.28,97.35 168.3,97.35 168.59,97.65 168.59,97.83 v1(168.84,98.08)
DDR_A_DQS#2: length 62.3
  IN1 w0.076: 128.62,93.94 128.62,93.96 127.92,94.66 126.72,94.66 126.51,94.45 126.51,94.26 v5(126.72,94.05)
  IN1 w0.114: 128.62,93.94 128.62,93.86 129.61,92.87 148.09,92.87 152.08,96.85 157.38,96.85 159.54,99.02 159.54,99.33 162.97,102.76 164.19,102.76 165.15,103.72 165.99,103.72 166.34,104.07 166.34,104.5 v1(166.55,104.7)
  BOTTOM w0.076: UC1.BA64 120.29,100.86 120.19,100.76 120.19,100.67 120.2,100.65 120.36,100.58 120.52,100.58 120.63,100.63 120.91,100.63 121.04,100.57 121.16,100.57 121.27,100.63 121.64,100.63 121.8,100.46 122.56,100.46 123.52,99.5 123.52,96.49 123.87,96.14 125.47,96.14 126.55,95.07 126.55,94.22 v5(126.72,94.05)
  BOTTOM w0.114: v1(166.55,104.7) 166.35,104.51 166.35,104.27 165.82,103.74 164.9,103.74 164.71,103.55 JDIMM1.45
DDR_A_DQS#3: length 63
  IN1 w0.114: v1(168.71,110.28) 168.86,110.28 168.97,110.16 168.97,109.79 168.68,109.5 168.22,109.5 167.62,110.1 163.84,110.1 157.82,104.08 152.74,104.08 146.01,97.35 131.29,97.35 130.01,98.63 129.24,98.63 128.11,99.76 126.73,99.76 125.87,100.62 v2(125.87,100.9)
  BOTTOM w0.076: UC1.AY60 119.86,103.31 119.98,103.42 120.11,103.55 120.3,103.65 120.58,103.65 120.66,103.61 120.87,103.61 120.98,103.66 121,103.66 121.18,103.66 121.33,103.6 121.6,103.6 121.76,103.77 122.2,103.77 122.51,103.45 122.9,103.45 124.78,101.56 125.41,101.56 125.58,101.39 125.58,101.07 125.75,100.9 v2(125.87,100.9)
  BOTTOM w0.114: JDIMM1.62 170.6,108.65 170.41,108.84 169.4,108.84 169.03,109.21 169.03,110.16 168.92,110.28 v1(168.71,110.28)
DDR_A_DQS#4: length 61.6
  IN1 w0.076: v2(125.96,115.63) 126.11,115.63 126.25,115.77 126.25,116.07 126.61,116.43 130.35,116.43 130.68,116.76 131.05,116.76 131.06,116.77 131.08,116.77
  IN1 w0.114: 131.08,116.77 131.43,116.77 132.36,117.7 137.16,117.7 144.29,124.83 144.29,125.18 149.37,130.26 149.37,130.43 150.97,132.03 158.2,132.03 158.31,132.14 158.31,132.66 158.54,132.89 159.1,132.89 159.33,132.66 159.33,132.14 159.45,132.03 160.45,132.03 161.24,132.82 162.32,132.82 163.12,132.02 163.41,132.02 163.53,132.13 163.53,132.36 163.76,132.59 164.32,132.59 164.55,132.36 164.55,132.13 164.66,132.02 165.94,132.02 166.11,132.2 166.11,132.36 165.98,132.5 v1(165.81,132.5)
  BOTTOM w0.076: v2(125.96,115.63) 126.1,115.63 126.24,115.48 126.24,115.33 126.15,115.23 123.74,115.23 123.58,115.4 122.43,115.4 122.25,115.22 121.9,115.22 121.77,115.35 121.27,115.35 121.16,115.3 121.15,115.3 121.04,115.3 120.91,115.35 120.77,115.35 120.63,115.35 120.49,115.29 120.4,115.29 120.27,115.34 120.19,115.39 120.11,115.45 120.11,115.52 120.16,115.66 120.27,115.66 UC1.BA38
  BOTTOM w0.114: v1(165.81,132.5) 166,132.5 166.17,132.66 166.17,132.85 165.88,133.14 164.9,133.14 164.71,132.95 JDIMM1.135
DDR_A_DQS#5: length 63.3
  IN1 w0.076: v2(125.5,119.18) 125.74,118.94 125.74,118.77 125.9,118.61 129.5,118.61 132.45,121.56 132.5,121.56
  IN1 w0.114: 132.5,121.56 133.48,121.56 133.78,121.86 134.54,121.86 137.98,125.3 138.96,125.3 142.04,128.38 142.04,129.36 143.4,130.73 144.22,130.73 151.75,138.26 153.86,138.26 154.15,138.55 154.93,138.55 155.22,138.26 162.06,138.26 162.65,137.67 167.12,137.67 167.69,138.23 168.33,138.23 v1(168.54,138.03)
  BOTTOM w0.076: v2(125.5,119.18) 125.61,119.18 125.81,118.98 125.81,118.76 125.51,118.46 122.46,118.46 122.33,118.33 121.31,118.33 121.2,118.39 120.98,118.39 120.87,118.33 120.66,118.33 120.55,118.38 120.34,118.38 120.19,118.32 120.1,118.27 120.05,118.24 120.05,118.24 120,118.11 120,118.05 119.98,118.03 UC1.AY34
  BOTTOM w0.114: v1(168.54,138.03) 168.75,138.24 170.41,138.24 170.6,138.05 JDIMM1.152
DDR_A_DQS#6: length 65.8
  IN1 w0.076: 130.39,124.42 130.39,124.4 130.41,124.39 130.41,122.47 129.8,121.85 128.79,121.85 128.79,121.85 126.53,121.85 126.19,121.51 126.12,121.51 125.71,121.1 v2(125.71,121.09)
  IN1 w0.114: v1(166.91,143.54) 167.03,143.54 167.15,143.43 167.15,143.23 167,143.08 165.67,143.08 164.69,144.07 158.24,144.07 157.36,144.95 151.67,144.95 146.19,139.48 146.19,139.36 143.38,136.55 143.23,136.55 142.65,135.97 142.24,135.97 140.53,134.26 140.53,133.86 138.57,131.89 138.49,131.89 132.71,126.12 132.01,126.12 130.39,124.51 130.39,124.42
  BOTTOM w0.076: UC1.BA30 120.26,120.61 120.12,120.6 120.09,120.44 120.15,120.4 120.19,120.37 120.27,120.32 120.35,120.29 120.53,120.29 120.63,120.33 120.91,120.33 121.04,120.28 121.16,120.28 121.27,120.33 121.99,120.33 122.02,120.3 122.42,120.3 122.42,120.3 122.65,120.53 122.79,120.67 125.85,120.67 125.99,120.81 125.99,120.94 125.84,121.09 v2(125.71,121.09)
  BOTTOM w0.114: v1(166.91,143.54) 167.16,143.79 167.16,143.87 167.02,144.01 165.75,144.01 165.13,143.39 164.76,143.39 164.52,143.15 JDIMM1.169
DDR_A_DQS#7: length 70.8
  IN1 w0.114: v2(126.66,124.64) 126.88,124.87 126.88,128.26 130.02,131.4 131.31,131.4 132.78,132.87 132.78,133.94 134.35,135.51 134.65,135.51 140.55,141.41 141.35,141.41 146.36,146.42 147.02,146.42 150.44,149.84 150.44,150.94 151.44,151.94 156.81,151.94 158.63,150.12 164.33,150.12 166.87,150.12 168.04,148.95 169.41,148.95 169.53,149.06 169.53,149.26 v1(169.33,149.46)
  BOTTOM w0.076: v2(126.66,124.64) 126.92,124.38 126.92,124.03 126.62,123.73 122.99,123.73 122.78,123.53 121.82,123.53 121.61,123.31 121.31,123.31 121.2,123.37 120.98,123.37 120.87,123.31 120.66,123.31 120.55,123.36 120.34,123.36 120.19,123.3 120.1,123.25 120.05,123.22 120,123.09 120,123.04 119.98,123.02 UC1.AY26
  BOTTOM w0.114: JDIMM1.186 170.6,148.25 170.41,148.44 169.86,148.44 169.59,148.71 169.59,149.2 v1(169.33,149.46)
DDR_A_MA0: length 60
  IN1 w0.076: v2(125.47,106.88) 125.47,107.38 125.79,107.69 130.91,107.69 131.01,107.59 131.54,107.59
  IN1 w0.165: v1(170.25,121.7) 170,121.7 169.09,120.8 166.69,120.8 166.05,121.44 159.81,121.44 157.56,119.19 151.9,119.19 139.91,107.2 131.93,107.2 131.54,107.59
  BOTTOM w0.076: v2(125.47,106.88) 125.1,107.25 125.02,107.25 124.52,107.76 123.92,107.76 123.52,108.16 122.81,108.16 122.23,108.74 121.75,108.74 121.57,108.56 121.31,108.56 121.23,108.59 121.22,108.6 121.19,108.62 121.05,108.62 120.82,108.55 120.69,108.55 120.47,108.63 120.27,108.83 UC1.AY50
  BOTTOM w0.178: JDIMM1.98 170.4,121.85 v1(170.25,121.7)
DDR_A_MA1: length 60.1
  IN1 w0.076: v2(126.13,106.88) 126.74,107.49 130.67,107.49
  IN1 w0.165: v1(168.26,120.23) 168.13,120.35 166.51,120.35 165.87,120.99 160,120.99 156.82,117.82 151.46,117.82 140.4,106.76 131.74,106.76 131.31,107.19 130.97,107.19 130.67,107.49
  BOTTOM w0.076: UC1.BB50 121.49,108.9 122.3,108.9 122.81,108.4 123.52,108.4 123.98,107.94 124.57,107.94 125,107.51 125.21,107.51
  BOTTOM w0.102: 125.21,107.51 125.6,107.51 126.13,106.98 v2(126.13,106.88)
  BOTTOM w0.178: JDIMM1.97 167.43,121.55 168.26,120.72 v1(168.26,120.23)
DDR_A_MA2: length 61.7
  IN1 w0.076: 131.53,104.96 130.43,106.07 124.88,106.07 124.34,106.6 v2(124.34,107.36)
  IN1 w0.165: v1(169.52,120.4) 169.52,120.04 168.79,119.3 166.71,119.3 166.46,119.05 164.84,119.05 164.37,118.57 160.1,118.57 159.66,118.14 159.66,117.39 157.73,115.46 151.76,115.46 141.26,104.96 131.53,104.96
  BOTTOM w0.076: UC1.AY51 120.02,108.44 120.52,108.44 120.68,108.38 120.83,108.38 121.04,108.44 121.16,108.44 121.28,108.4 121.64,108.4 121.82,108.57 122.17,108.57 122.84,107.9 123.54,107.9 124.09,107.36 v2(124.34,107.36)
  BOTTOM w0.178: v1(169.52,120.4) 169.51,120.42 169.51,120.67 170.09,121.25 JDIMM1.96
DDR_A_MA3: length 59.5
  IN1 w0.076: v2(127.43,106.88) 127.43,107 127.71,107.29 130.47,107.29 131.46,106.3
  IN1 w0.165: 131.46,106.3 140.57,106.3 151.65,117.37 157.01,117.37 160.18,120.55 165.69,120.55 166.42,119.81 v1(167.02,119.81)
  BOTTOM w0.076: UC1.BA50 120.91,108.83 121.18,109.1 121.57,109.1 121.6,109.07 122.37,109.07 122.72,108.72 123.44,108.72 124.04,108.12 124.68,108.12 125.08,107.72 125.21,107.72
  BOTTOM w0.102: 125.21,107.72 127.09,107.72 127.43,107.39 v2(127.43,106.88)
  BOTTOM w0.178: JDIMM1.95 167.1,120.95 167.47,120.57 167.47,120.27 v1(167.02,119.81)
DDR_A_MA4: length 60
  IN1 w0.076: 132.2,102.74 130.54,104.4 127.89,104.4 127.32,104.97 126.87,104.97 126.18,105.66 v2(126.13,105.66)
  IN1 w0.165: v1(169.62,118.85) 169.62,118.67 167.29,116.34 162.46,116.34 160.64,114.52 159.94,114.52 157.6,112.19 151.63,112.19 142.18,102.74 132.2,102.74
  BOTTOM w0.076: UC1.BB52 121.51,107.41 123.27,107.41 124.54,106.14 124.97,106.14 125.04,106.06 125.12,106.06
  BOTTOM w0.102: v2(126.13,105.66) 125.72,106.06 125.12,106.06
  BOTTOM w0.178: JDIMM1.92 170.16,120.05 169.62,119.51 v1(169.62,118.85)
DDR_A_MA5: length 60.9
  IN1 w0.076: 131.38,105.41 130.54,106.24 127.89,106.24 127.77,106.37 127.77,106.69 127.96,106.88 v2(128.08,106.88)
  IN1 w0.165: v1(161.08,119.15) 160.96,119.03 159.92,119.03 158.91,118.02 158.91,117.79 159.03,117.67 159.03,117.38 157.54,115.9 154.7,115.9 154.29,116.31 154.08,116.31 153.67,115.9 151.57,115.9 141.08,105.41 131.38,105.41
  BOTTOM w0.076: 125.18,106.47 124.67,106.47 123.41,107.74 121.84,107.74 121.64,107.94 121.28,107.94 121.28,107.93 121.19,107.9 120.99,107.9 120.91,107.94 120.9,107.94 120.9,107.94 120.89,107.94 120.66,107.94 UC1.BA51
  BOTTOM w0.102: v2(128.08,106.88) 127.67,106.47 125.18,106.47
  BOTTOM w0.178: v1(161.08,119.15) 161.08,123.91 161.3,124.14 161.88,124.14 162.08,123.94 162.08,120.03 162.36,119.75 JDIMM1.91
DDR_A_MA6: length 60.9
  IN1 w0.076: 131.99,102.3 131.01,103.27 131.01,103.7 130.53,104.18 127.64,104.18 127.1,104.71 126.36,104.71 125.47,105.6 v2(125.47,105.66)
  IN1 w0.165: v1(170.28,118.85) 170.28,118.71 167.47,115.9 162.65,115.9 160.83,114.08 160.12,114.08 157.16,111.12 151.47,111.12 142.65,102.3 131.99,102.3
  BOTTOM w0.076: UC1.BA52 120.99,107.5 121.25,107.24 123.21,107.24 124.47,105.97 124.9,105.97 125.01,105.86 125.27,105.86 v2(125.47,105.66)
  BOTTOM w0.178: JDIMM1.90 170.44,119.45 170.28,119.29 v1(170.28,118.85)
DDR_A_MA7: length 62.1
  IN1 w0.076: 132.04,103.18 130.67,104.56 128.53,104.56 v2(127.43,105.66)
  IN1 w0.165: 132.04,103.18 142,103.18 151.98,113.16 153.86,113.16 154.39,112.63 157.42,112.63 161.57,116.78 167.1,116.78 168.35,118.03 v1(168.35,118.82)
  BOTTOM w0.076: v2(127.43,105.66) 127.03,105.26 125.29,105.26 124.75,105.81 124.4,105.81 123.14,107.07 120.74,107.07 120.53,107.28 119.98,107.28 119.66,107.6 UC1.AW52
  BOTTOM w0.178: v1(168.35,118.82) 168.91,118.25 169.81,118.25 170.39,118.25 JDIMM1.86
DDR_A_MA8: length 60.2
  IN1 w0.076: v2(129.38,106.88) 130.39,106.88 131.41,105.85
  IN1 w0.165: v1(165.73,119.65) 165.73,119.88 165.5,120.1 164.5,120.1 164.34,119.94 164.34,119.19 164.17,119.03 163.84,119.03 163.68,119.19 163.68,119.94 163.51,120.1 163.18,120.1 163.02,119.94 163.02,119.19 162.85,119.03 162.52,119.03 162.36,119.19 162.36,119.94 162.19,120.1 161.05,120.1 160.5,119.55 159.81,119.55 158.12,117.86 158.12,117.63 158.24,117.5 158.24,117.22 157.52,116.51 157.11,116.51 156.69,116.93 151.83,116.93 140.75,105.85 131.41,105.85
  BOTTOM w0.076: UC1.AY52 120.22,107.7 120.48,107.7 120.67,107.77 120.87,107.77 120.96,107.73 121.21,107.73 121.22,107.73 121.31,107.77 121.57,107.77 121.77,107.57 123.34,107.57 124.61,106.3 125.04,106.3 125.07,106.27 125.23,106.27
  BOTTOM w0.102: 125.23,106.27 128.77,106.27 v2(129.38,106.88)
  BOTTOM w0.178: v1(165.73,119.65) 165.73,119.4 165.48,119.15 JDIMM1.89
DDR_A_MA9: length 59.2
  IN1 w0.076: v5(130.03,105.66) 129.74,105.38 129.74,105.23 129.94,105.04 131.06,105.04 131.58,104.52
  IN1 w0.165: v1(165.74,118.52) 165.74,118.28 165.57,118.12 161.02,118.12 157.81,114.91 155.51,114.91 155.09,114.5 153.07,114.5 152.91,114.66 152.91,114.81 152.74,114.98 152.41,114.98 152.25,114.81 152.25,114.66 152.08,114.5 151.43,114.5 141.45,104.52 131.58,104.52
  BOTTOM w0.076: UC1.BB54 121.52,106.58 122.93,106.58 124.19,105.31 124.4,105.31 125.06,104.65 129.82,104.65 130.26,105.09 130.26,105.43 v5(130.03,105.66)
  BOTTOM w0.178: v1(165.74,118.52) 166.06,118.52 166.3,118.28 166.3,117 166.06,116.76 165.64,116.76 164.45,117.95 JDIMM1.85
