# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 113.9,110.16 113.9,113.92 113.98,113.99 114.7,113.99 114.75,114.04 114.75,114.6 114.7,114.65 113.07,114.65 112.9,114.47 112.9,113.08 112.91,113.08 113.14,112.85 113.14,111.92 112.76,111.54 104.5,111.54 104.38,111.41 104.38,109.38 104.5,109.25 112.46,109.25 112.53,109.19 112.54,109.19 112.59,109.14 112.59,106.68 113.48,106.68 113.48,109.73
GND on TOP: 87.62,120.17 87.37,120.43 87.37,125 87.5,125.13 88.12,125.13 89.01,124.24 93.63,124.24 93.97,124.58 94.58,124.58 94.68,124.48 94.68,124.07 94.84,123.92 96.21,123.92 96.44,124.15 96.44,124.44 96.56,124.57 97.44,124.57 97.9,124.11 98.91,124.11 99.17,124.37 99.17,124.87 99.42,125.13 100.18,125.13 101.33,123.98 101.33,122.46 101.2,122.33 100.74,122.33 100.74,122.33 100.5,122.33 99.95,122.89 93.37,122.89 92.95,122.46 92.95,120.3 92.82,120.17
GND on TOP: 77.18,119.54 78.92,119.54 79.04,119.43 79.04,118.94 78.53,118.44 77.01,118.44 76.82,118.25 76.82,117.76 76.56,117.51 76.56,116.62 76.44,116.49 75.93,116.49 75.42,117 75.42,119.03 75.58,119.2 76.84,119.2
GND on TOP: 198.87,176.5 200.96,176.5 201.36,176.09 201.36,175.69 201.05,175.37 198.94,175.37 198.62,175.69 198.62,176.25
GND on TOP: 60.71,175.24 60.71,173.54 60.15,172.98 60.15,171.63 60.28,171.51 61.73,171.51 61.88,171.66 61.88,172.96 62.01,173.08 62.41,173.08 62.52,173.18 62.52,173.74 62.36,173.9 61.86,173.9 61.65,174.1 61.65,175.27 61.55,175.37 60.84,175.37
GND on TOP: 192.74,66.1 192.58,65.95 192.39,65.95 192.23,66.1 192.23,66.48 192.01,66.71 187.94,66.71 187.81,66.58 187.56,66.58 187.43,66.71 187.43,66.96 188.07,67.6 192.32,67.6 192.74,67.18
GND on TOP: 276.09,55.8 290.06,55.8 290.31,55.55 290.31,52.37 288.05,52.37 285.79,50.11 285.79,49.32 284.42,47.95 284.42,43.23 285.68,41.97 285.68,38.21 286.5,37.38 286.5,36.24 286.12,35.86 285.11,35.86 284.09,36.88 284.09,43.1 283.58,43.61 282.31,43.61 281.93,43.23 281.93,39.67 280.79,38.53 280.79,34.08 281.81,33.07 281.81,31.42 280.41,30.02 276.73,30.02 275.71,29 275.46,29.26 275.46,55.16
GND on TOP: 112.18,121.7 114.41,121.7 114.57,121.53 114.57,120.98 114.55,120.95 113.84,120.95 113.81,120.98 112.49,120.98 112.31,120.8 112.31,119.27 112.26,119.22 112.13,119.22 112.06,119.15 105.94,119.15 105.78,119.3 105.28,119.3 104.87,119.71 104.87,120.72 104.92,120.77 105.02,120.77 105.15,120.9 105.15,121.41 105.2,121.46 105.63,121.46 105.73,121.36 105.73,120.44 105.81,120.37 111.78,120.37 111.86,120.45 111.86,121.37
GND on TOP: 164.84,112.77 169.79,112.77 170.48,112.09 170.48,108.35 170.99,107.84 170.99,90.75 170.53,90.29 165.07,90.29 161.74,93.62 161.74,105.91 164.61,108.78 164.61,112.54
GND on TOP: 93.67,129.87 95.34,129.87 95.42,129.79 95.42,127.68 95.24,127.5 93.77,127.5 93.59,127.68 93.59,129.79
GND on TOP: 149.47,157.91 152.27,157.91 153.28,156.89 153.28,156.51 153.15,156.38 149.47,156.38 149.22,156.64 149.22,157.65
GND on TOP: 162.26,54.29 162.52,54.03 174.89,54.03 175.06,53.85 175.06,52.94 174.87,52.75 174.87,51.94 175.24,51.57 176,51.57 176.26,51.82 176.26,52.05 176.38,52.18 178.34,52.18 178.49,52.03 178.49,51.29 178.26,51.06 174.38,51.06 173.82,50.5 160.64,50.5 160.62,50.51 160.28,50.51 159.65,51.14 144.32,51.14 142.74,52.73 142.74,56.69 141.85,57.58 141.74,57.58 141.74,58.66 143.31,60.23 146.55,60.23 146.97,59.81 152.46,59.81 152.65,60 153.37,60 153.6,59.77 153.6,57.31 153.61,57.3 153.61,56.36 153.91,56.06 159.82,56.06 159.95,56.19 159.95,57.41 160.2,57.66 162.01,57.66 162.26,57.41
GND on TOP: 103.23,89.19 104.76,89.19 104.88,89.06 104.88,83.85 104.76,83.73 103.99,83.73 103.87,83.85 103.87,84.87 103.61,85.12 101.45,85.12 101.2,85.38 101.2,88.93 101.58,89.31 103.11,89.31
GND on TOP: 106.9,107.23 107.49,106.65 110.79,106.65 111.52,105.91 111.52,104.64 111.47,104.59 107.74,104.59 107.36,104.21 107.36,103.09 107.54,102.92 110.1,102.92 110.25,102.76 110.25,101.54 109.67,100.96 106.09,100.96 105.99,101.06 105.99,101.52 105.89,101.62 105.25,101.62 105.2,101.67 105.2,102.33 105.28,102.41 105.76,102.41 105.81,102.46 105.81,103.09 105.86,103.14 105.86,107.54 105.94,107.62 106.75,107.62 106.9,107.46
GND on TOP: 113.33,123.24 113.21,123.12 112.15,123.12 112.12,123.1 111.36,123.1 111.11,123.35 104.38,123.35 104.37,123.35 103.89,123.35 103.76,123.48 103.76,123.96 103.5,124.23 103.5,125.4 103.62,125.52 104.16,125.52 104.23,125.45 104.23,124.89 104.44,124.68 104.44,124.3 104.46,124.28 105.2,124.28 105.22,124.3 105.22,125.22 105.28,125.27 107.18,125.27 107.31,125.14 107.31,124.62 107.55,124.38 109.16,124.38 109.28,124.49 110.81,124.49 110.82,124.5 113.18,124.5 113.33,124.35
GND on TOP: 113.61,128.32 114.75,128.32 114.95,128.52 114.95,129.08 115,129.13 115.64,129.13 115.74,129.03 115.74,128.77 116.32,128.77 116.45,128.9 116.45,130.09 116.35,130.2 114.57,130.2 113.73,131.03 113.51,131.03 113.44,130.97 113.44,129.78 113.33,129.66 112.9,129.66 112.82,129.59 112.82,129.1
GND on TOP: 93.83,118.9 97.64,118.9 97.9,118.65 98.91,118.65 99.68,117.89 99.68,117.13 99.55,117 98.66,117 98.53,117.13 93.07,117.13 92.44,117.76 92.44,118.4 92.56,118.52 93.45,118.52
GND on TOP: 214.95,173.73 219.3,173.73 220.06,172.97 220.06,164.99 219.7,164.64 219.7,152.19 219.19,151.68 208.78,151.68 208.4,152.07 208.4,156.51 214.62,162.73 214.62,173.4
GND on TOP: 107.65,81.59 107.8,81.44 107.8,75.34 107.55,75.09 105.65,75.09 105.47,75.26 105.47,81.43 105.63,81.59
GND on TOP: 217.04,136.06 219.7,136.06 219.83,135.94 219.83,135.3 219.7,135.17 218.81,135.17 218.56,134.92 218.56,134.29 218.43,134.16 218.31,134.16 218.18,134.29 218.18,135.05 218.05,135.17 217.04,135.17 216.91,135.3 216.91,135.94
GND on BOTTOM: 278.88,42.46 285.11,42.46 286,41.58 286,36.11 285.74,35.86 285.23,35.86 284.98,35.61 282.31,35.61 281.81,36.11 279.65,36.11 279.39,36.37 279.39,40.18 278.5,41.07 278.5,42.08
GND on BOTTOM: 62.73,71.67 64,71.67 64.13,71.55 65.78,71.55 65.91,71.42 65.91,71.04 65.78,70.91 62.73,70.91 62.6,71.04 62.6,71.55
GND on BOTTOM: 177.26,158.09 181.2,158.09 181.96,157.32 181.96,143.18 181.6,142.82 179.37,142.82 177.18,145 177.18,152.04 177.13,152.09 177.13,157.96
GND on BOTTOM: 253.09,94.39 255.76,94.39 256.27,93.89 256.27,91.98 255.25,90.96 255.25,90.46 255,90.2 253.09,90.2 252.84,90.46 252.84,94.14
GND on BOTTOM: 207.76,145.08 228.85,145.08 229.1,144.83 229.1,143.94 228.85,143.68 207.76,143.68 207.38,144.06 207.38,144.7
GND on BOTTOM: 281.2,108.73 280.54,109.39 275.96,109.39 274.19,111.17 274.19,114.47 279.52,119.81 280.41,119.81 280.79,119.43 285.49,119.43 286.12,120.06 286.38,120.06 286.38,112.44 285.96,112.03 285.96,108.93 285.76,108.73
GND on BOTTOM: 133.98,126.41 142.13,126.41 146.96,131.24 146.96,150.54 147.67,151.25 151,151.25 151.38,150.87 151.38,130.83 150.87,130.32 149.24,130.32 148.33,129.41 148.33,112.57 148.76,112.14 150.84,112.14 151.3,111.68 151.3,91.59 152.49,90.39 152.49,88.62 150.92,87.04 148.35,87.04 147.72,87.68 147.72,91 145.48,93.24 137.84,93.24 136.9,94.18 136.9,112.95 132.96,116.89 132.96,125.4
GND on BOTTOM: 284.44,32.37 284.56,32.24 284.56,31.05 284.39,30.87 280.53,30.87 280.38,31.02 280.38,32.25 280.5,32.37
GND on BOTTOM: 260.6,135.56 256.15,140 256.15,148.89 259.33,152.07 259.33,156.64 258.95,157.02 256.91,157.02 256.28,157.65 256.28,160.19 255.52,160.96 250.56,160.96 250.18,160.57 248.15,160.57 247.64,161.08 242.82,161.08 229.23,147.49 221.1,147.49 220.46,148.13 220.46,168.75 220.9,169.18 220.9,173.91 220.44,174.37 218.15,174.37 218.12,174.33 214.51,174.33 211.93,176.91 211.93,177.03 212.21,177.31 235.37,177.31 240.35,172.33 240.35,169.57 242.66,167.25 249.29,167.25 251.55,164.99 272.05,164.99 272.94,164.1 272.94,154.48 272.15,153.69 272.15,136.83 270.88,135.56 ; 2 cut-outs
GND on BOTTOM: 217.67,168.32 219.58,168.32 219.83,168.07 219.83,167.43 219.58,167.18 217.67,167.18 217.54,167.31 217.54,168.19
GND on BOTTOM: 145.53,90.44 145.53,86.28 145.03,85.77 138.3,85.77 137.91,86.15 137.91,88.31 137.9,88.32 137.9,90.76 138.19,91.05 144.93,91.05
GND on BOTTOM: 47.62,62.28 50.54,62.28 51.05,61.77 51.05,56.31 55.11,52.24 55.11,49.2 54.73,48.81 53.08,48.81 52.44,49.45 50.54,49.45 50.41,49.32 50.41,47.67 50.28,47.54 49.65,47.54 49.52,47.67 49.52,49.32 49.4,49.45 45.2,49.45 43.81,48.05 42.66,48.05 42.27,48.45 42.27,56.93
GND on BOTTOM: 204.84,107.49 208.53,107.49 208.91,107.11 208.91,102.15 211.32,99.74 211.32,91.23 210.43,90.34 209.03,90.34 197.87,79.18 197.87,76.39 197.68,76.2 193.54,76.2 192.27,77.47 177.95,77.47 177.69,77.72 177.69,78.23 177.97,78.51 182.47,78.51 193.16,89.2 193.16,95.8
GND on BOTTOM: 87.99,117.51 91.42,117.51 91.55,117.38 91.55,116.62 91.42,116.49 90.79,116.49 90.66,116.62 90.66,116.75 89.52,116.75 89.39,116.62 89.39,115.73 89.14,115.48 88.37,115.48 88.25,115.35 88.25,114.21 88.37,114.08 89.39,114.08 89.52,114.21 89.52,115.09 89.64,115.22 90.41,115.22 90.53,115.09 90.53,114.71 90.79,114.46 91.42,114.46 91.55,114.33 91.55,113.7 91.29,113.44 88.12,113.44 87.74,113.82 87.74,117.25
GND on BOTTOM: 114.51,124.06 114.78,124.33 115.46,124.33 115.49,124.35 115.49,125.37 114.83,126.03 114.83,127.2 115.54,127.91 115.54,131.57 115.82,131.85 115.82,132.35 115.28,132.89 115.16,132.89 114.17,131.9 110.18,131.9 108.76,130.48 107.59,130.48 107.05,129.94 107.05,127 106.62,126.56 105.56,126.56 104.77,125.78 104.77,124.63 105.34,124.06
GND on BOTTOM: 74.07,159.75 73.72,160.09 73.72,162.56 72.79,163.5 69.21,163.5 68.06,164.64 68.06,166.8 66.29,168.58 65.65,168.58 64.76,169.46 64.76,170.86 64.25,171.37 64.25,172 64.13,172.13 63.87,172.13 63.37,172.64 63.37,173.15 65.27,173.15 66.16,172.26 71.24,172.26 71.72,171.78 71.72,169.25 73.64,167.32 73.64,165.11 73.66,165.1 73.66,164.84 75.7,162.8 76.81,162.8 79.05,160.55 79.05,160.05 78.74,159.75
GND on BOTTOM: 1.9,164.26 8.63,164.26 9.01,163.88 9.01,130.6 8.37,129.97 5.96,129.97 5.33,130.6 2.41,130.6 1.64,131.36 1.64,164
GND on BOTTOM: 62.19,116.19 63.17,117.17 64.34,117.17 65.91,115.6 67.42,115.6 68.05,116.24 68.94,116.24 70.34,114.84 70.34,114.46 70.21,114.33 69.7,114.33 69.07,114.97 68.69,114.97 67.55,113.82 64.77,113.82 63.3,112.36 62.87,112.36 60.18,115.04 60.18,115.22 61.15,116.19
GND on BOTTOM: 217.67,101.39 229.99,101.39 230.5,100.88 230.5,94.41 226.43,90.34 216.02,90.34 215.51,90.85 215.51,99.23
GND on BOTTOM: 244.33,89.19 248.65,89.19 248.77,89.06 248.77,85 248.65,84.87 244.33,84.87 244.2,85 244.2,89.06
GND on BOTTOM: 208.55,117.39 206.11,117.39 204.23,119.27 204.23,121.46 203.93,121.76 202.43,121.76 202.02,121.36 202.02,117.55 201.87,117.39 200.91,117.39 198.75,115.24 195.57,115.24 194.81,116 194.81,118.92 193.29,120.44 193.29,128.32 195.95,130.98 200.53,130.98 204.08,127.43 209.14,127.43 209.26,127.3 209.26,118.11
GND on BOTTOM: 170.17,90.22 169.92,90.47 169.92,107.36 172.97,107.36 172.97,110.79 169.92,110.79 169.92,112.95 171.19,114.22 172.33,114.22 172.71,114.6 172.71,129.46 172.08,130.09 170.17,130.09 169.92,130.35 169.92,151.56 170.43,152.07 174.36,152.07 175.13,151.3 175.13,95.04 173.47,93.39 173.47,90.72 172.97,90.22 ; 1 cut-out
GND on BOTTOM: 254.25,81.2 254.12,81.07 250.94,81.07 250.56,80.69 247.13,80.69 246.63,81.2 245.36,81.2 245.23,81.33 245.23,82.34 245.36,82.47 253.99,82.47 254.25,82.22
GND on BOTTOM: 61.7,175.29 61.7,171.74 61.45,171.48 60.31,171.48 60.18,171.61 60.18,172.88 60.19,172.89 60.19,173.15 59.94,173.4 59.94,173.66 60.19,173.91 60.57,173.91 60.81,174.15 60.81,174.91 60.69,175.04 60.69,175.29 60.81,175.42 61.58,175.42
GND on BOTTOM: 188.97,147.75 200.02,147.75 203.19,144.57 203.19,142.03 201.67,140.51 199,140.51 197.6,139.11 190.49,139.11 188.46,141.14 188.46,147.24
GND on BOTTOM: 140.06,156.62 145.14,156.62 145.4,156.37 145.4,153.19 145.14,152.94 142.73,152.94 141.97,152.18 140.19,152.18 139.81,152.56 139.81,156.37
GND on BOTTOM: 152.52,67.61 163.57,67.61 166.87,64.31 189.73,64.31 191.13,62.91 191.13,55.8 190.75,55.42 185.54,55.42 185.29,55.67 185.29,59.1 184.4,59.99 183.51,59.99 182.75,60.75 180.08,60.75 178.94,59.61 176.52,59.61 173.35,56.43 173.35,50.85 172.97,50.47 160.27,50.47 159.76,50.97 159,50.97 158.74,50.72 144.52,50.72 142.74,52.5 142.74,56.69 141.34,58.09 137.15,58.09 136.77,57.7 136.77,55.67 136.39,55.29 136.39,47.26 100.68,47.26 100.45,47.49 100.45,50.47 99.69,51.23 99.69,66.47 100.2,66.98 102.1,66.98 105.66,63.42 148.33,63.42
GND on BOTTOM: 176.14,113.97 192.27,113.97 193.03,113.2 193.03,105.84 183.38,96.19 176.78,96.19 176.14,96.82 176.14,112.7 175.76,113.08 175.76,113.58
GND on BOTTOM: 71.86,119.67 74.56,119.67 75.94,118.28 75.94,114.85 75.17,114.08 73.51,114.08 73.26,114.33 73.26,117.84 72.8,118.29 71.76,118.29 71.61,118.45 71.61,119.41
GND on BOTTOM: 115.54,126.49 116.02,126.49 116.15,126.61 116.15,127.2 116.27,127.33 116.78,127.33 117.11,127 117.11,126.61 117.29,126.44 118.61,126.44 118.64,126.41 118.64,125.42 118.53,125.32 115.72,125.32 115.49,125.55 115.49,126.44
GND on BOTTOM: 177.26,91.03 182.26,91.03 182.57,90.72 182.57,87.8 180.99,86.23 175.18,86.23 174.9,86.51 174.9,86.89 177.13,89.12 177.13,90.9
GND on IN1: 276.73,9.32 276.22,9.83 276.22,13.13 276.6,13.51 277.23,13.51 277.61,13.13 279.65,13.13 282.31,15.79 282.31,17.95 282.06,18.21 278.5,18.21 278,18.72 278,24.68 276.22,26.46 276.22,32.3 276.47,32.56 281.42,32.56 285.87,28.11 287.39,28.11 287.71,27.92 287.63,27.56 287.27,26.97 287.32,26.28 287.4,26.3 287.47,26.25 287.84,25.84 288.37,25.69 297.34,25.69 298.04,24.99 298.04,19.01 297.34,18.31 288.37,18.31 287.6,17.95 287.37,17.14 287.37,17.08 287.32,17.04 287.32,16.86 287.45,16.64 287.63,16.44 287.69,16.04 287.3,15.91 287.28,15.9 286.07,15.9 285.87,15.69 285.87,13.38 281.81,9.32
GND on IN1: 66.29,110.92 70.22,110.92 73.14,113.84 73.27,113.84 74.03,113.08 74.03,110.41 74.8,109.65 74.8,106.35 77.46,103.68 77.46,100.63 75.94,99.11 72.26,99.11 70.99,97.84 61.84,97.84 60.44,99.23 60.44,102.03 62.98,104.57 62.98,106.98 62.86,107.11 62.86,107.49
GND on IN1: 212.34,125.78 231.01,125.78 236.97,131.75 262.76,131.75 264.66,129.84 268.72,129.84 270.38,128.19 270.38,114.35 270.88,113.84 272.53,113.84 274.31,115.62 277.87,115.62 278.12,115.36 278.12,113.33 276.73,111.93 276.73,110.54 277.61,109.65 277.61,107.49 272.28,102.15 260.22,102.15 258.69,103.68 229.86,103.68 226.69,106.85 222.24,106.85 217.67,111.43 217.67,114.6 216.02,116.25 205.99,116.25 204.59,117.65 204.59,117.9 204.21,117.9 203.19,118.92 199.64,118.92 198.62,117.9 198.62,115.49 198.37,115.24 178.05,115.24 176.14,117.14 176.14,121.59 178.55,124 178.55,129.59 179.7,130.73 180.97,130.73 183.63,128.06 192.65,128.06 197.85,122.87 197.85,122 198.49,121.36 201.39,121.36 205.33,125.29 211.85,125.29
GND on IN1: 72.76,97.96 77.21,97.96 77.84,97.33 77.84,95.55 80.38,93.01 80.38,85.52 86.99,78.91 86.99,75.61 87.75,74.85 91.05,74.85 93.97,71.93 99.43,71.93 111.37,59.99 124.07,59.99 127.5,56.56 132.96,56.56 134.36,57.96 136.26,57.96 136.77,57.45 136.77,55.67 136.39,55.29 136.39,48.31 136.14,48.05 67.68,48.05 66.16,46.53 58.79,46.53 56.51,48.81 47.24,48.81 46.73,48.31 29.96,48.31 29.46,48.81 29.46,52.5 30.22,53.26 32.63,53.26 32.76,53.39 47.49,60.63 50.92,63.93 58.16,66.09 62.98,66.09 63.75,66.85 63.75,69.01 60.19,72.56 60.19,79.8 60.95,80.56 60.95,83.49 66.79,89.33 66.79,95.17 67.81,96.19 70.99,96.19
GND on IN1: 197.86,77.9 233.8,77.9 234.31,77.39 234.31,74.34 234.05,74.09 222.5,74.09 219.96,71.55 197.48,71.55 196.08,70.15 196.08,53.39 195.83,53.13 193.03,53.13 192.52,52.62 192.52,50.34 192.14,49.96 189.35,49.96 189.1,50.21 189.1,52.62 187.95,53.77 187.95,55.16 187.83,55.29 185.54,55.29 185.29,55.55 185.29,60.12 185.54,60.37 192.78,60.37 193.41,61.01 193.41,63.29 192.02,64.69 186.94,64.69 186.68,64.94 186.68,66.72
GND on IN1: 59.3,144.95 59.94,144.95 60.32,144.57 61.84,144.57 65.91,140.51 65.91,136.44 69.72,132.63 69.72,130.6 68.57,129.46 49.14,129.46 48.63,129.97 48.63,133.02 51.3,135.68 51.3,142.03 51.81,142.54 57.65,142.54 59.05,143.94 59.05,144.7
GND on IN1: 219.96,176.32 243.07,176.32 249.55,169.85 249.55,163.75 249.17,163.37 243.32,163.37 231.64,151.68 202.94,151.68 196.08,158.54 196.08,170.23 198.11,172.26 199.76,172.26 202.56,175.05 218.69,175.05
GND on IN1: 186.17,176.45 192.65,176.45 194.18,174.93 194.18,160.45 193.54,159.81 189.98,159.81 187.06,162.73 187.06,167.05 185.67,168.45 185.67,170.23 186.56,171.12 186.56,175.18 185.92,175.81 185.92,176.2
GND on IN1: 2.28,164.13 11.04,164.13 11.42,163.75 11.42,161.34 8.88,158.8 8.88,130.86 8.5,130.48 2.28,130.48 1.77,130.98 1.77,163.62
GND on IN2: 172.33,176.2 243.71,176.2 249.17,170.73 249.17,166.29 251.07,164.38 271.39,164.38 272.03,163.75 272.03,136.32 273.41,134.93 281.31,134.93 282.95,133.29 282.95,112.19 282.19,111.43 282.19,97.71 278.25,93.77 263.39,93.77 262.63,94.53 262.63,100.63 263.01,101.01 272.28,101.01 272.41,100.88 273.42,100.88 276.09,103.55 276.09,108.63 279.39,111.93 279.39,122.98 263.26,139.11 256.91,139.11 249.29,146.73 246.25,146.73 245.36,145.84 245.36,133.27 267.9,110.73 273.61,110.73 274.44,109.9 274.44,103.93 272.79,102.28 263.64,102.28 261.36,104.57 232.53,104.57 229.61,107.49 229.61,116.25 228.21,117.65 226.05,117.65 225.9,117.8 225.9,143.02 227.2,144.32 227.2,171.75 226.31,172.64 216.78,172.64 216.27,172.13 216.27,154.1 215.38,153.21 200.27,153.21 194.68,158.8 191.13,158.8 186.81,163.11 160.52,163.11 159.89,163.75 158.74,163.75 158.23,164.26 158.23,174.8 159.25,175.81 164.46,175.81 164.84,175.43 171.57,175.43
GND on IN2: 110.85,95.16 110.87,95.18 110.87,95.63 113.27,98.02 113.27,103.16 114.17,104.06 117.11,104.06 117.62,104.57 117.62,111.98 122.29,116.66 122.29,118.54 122.55,118.79 122.55,119.81 122.04,120.32 122.04,121.59 123.18,122.73 123.18,124.63 122.17,125.65 115.69,125.65 115.56,125.78 115.56,126.41 116.82,127.67 116.83,127.66 118.56,127.66 118.94,127.27 120.49,127.27 121.73,128.52 121.73,128.8 121.71,128.82 121.71,135.1 122.04,135.43 126.49,135.43 129.62,138.56 134.58,138.56 147.43,151.42 147.43,151.92 149.45,153.94 155.49,153.94 155.52,153.97 158.95,153.97 160.17,152.75 170.48,152.75 170.48,152.76 174.85,152.76 182.66,144.94 182.66,138.9 171.7,127.94 171.7,113.58 171.71,113.58 171.71,101.52 172.08,101.15 172.08,101.14 183.51,101.14 186.43,98.22 186.43,93.01 160.77,67.36 125.6,67.36 120.01,72.94 112.39,72.94 110.85,74.48
GND on IN2: 50.54,163.62 59.43,163.62 62.16,160.89 62.16,157.08 63.87,155.37 65.91,155.37 75.81,145.46 75.81,137.33 73.53,135.05 71.49,135.05 69.72,133.27 69.72,119.93 68.45,118.66 56.38,118.66 54.86,117.14 54.86,114.73 54.6,114.47 54.6,112.95 55.11,112.44 76.57,112.44 77.72,111.3 77.72,102.03 75.3,99.61 60.62,99.61 59.81,100.43 59.81,105.58 37.71,127.68 13.96,127.68 11.04,130.6 2.53,130.6 1.77,131.36 1.77,163.5 2.66,164.38 15.87,164.38 21.33,169.85 25.9,169.85 27.42,171.37 41.17,171.37 41.39,171.14 43.66,171.14 49.95,164.84 49.95,164.21
GND on IN2: 276.73,9.11 276.22,9.62 276.22,16.48 278.05,18.31 278.05,24.81 276.17,26.69 276.17,39.47 280.43,43.73 280.43,50.95 280.79,51.3 288.79,51.3 289.62,52.14 289.98,52.28 290.22,51.98 290.22,51.24 290.19,51.11 290.11,51 289.84,49.8 290.85,49.11 298.84,49.11 299.46,48.49 299.46,41.06 298.84,40.44 288.37,40.44 287.31,39.7 287.63,38.44 287.7,38.06 287.34,37.89 286.66,37.89 285.92,37.16 285.92,28.42 286.23,28.11 287.37,28.11 287.71,27.93 287.63,27.56 287.24,26.74 287.56,25.9 287.75,25.9 288.04,25.75 288.37,25.69 297.34,25.69 298.04,24.99 298.04,19.01 297.34,18.31 288.37,18.31 287.52,17.84 287.46,16.87 287.47,16.84 287.47,16.81 287.47,16.61 287.54,16.52 287.63,16.44 287.71,16.07 287.37,15.89 286.58,15.89 285.92,15.23 285.92,11.6 283.43,9.11
GND on IN2: 120.36,136.06 120.36,129.21 119.5,128.34 114.72,128.34 114.45,128.62 114.45,129.36 116.17,131.08 116.17,135 117.39,136.22 120.21,136.22
GND on IN2: 279.9,55.55 278.76,56.69 278.76,70.28 273.55,75.48 273.55,76.75 274.19,77.39 276.6,77.39 283.71,70.28 283.71,68.88 284.5,68.09 296.77,68.09 297.63,68.96 297.63,69.33 297.58,69.33 297.57,69.34 297.57,69.97 298.27,69.97 298.27,65.89 290.85,65.89 289.84,65.2 290.11,64.01 290.19,63.9 290.22,63.77 290.22,63.02 290.07,62.75 289.76,62.74 289.73,62.71 289.2,62.71 288.92,62.43 288.92,61.36 288.59,61.03 287.52,61.03 286.63,60.14 286.63,55.93 286.25,55.55
GND on IN2: 58.79,46.53 57.27,48.05 29.84,48.05 29.33,48.56 29.33,52.37 30.22,53.26 32.63,53.26 47.36,60.5 50.92,64.05 52.19,64.94 55.49,64.94 58.16,67.61 60.44,67.61 60.83,67.23 60.83,65.32 58.16,62.66 58.16,56.82 63.75,51.23 71.37,51.23 72,50.59 74.92,50.59 76.19,51.86 64.51,51.86 60.57,55.8 60.57,59.48 61.84,60.75 61.84,65.83 62.48,66.47 65.14,66.47 66.03,67.36 66.03,69.77 65.78,70.02 62.86,70.02 60.19,72.69 60.19,79.68 60.95,80.44 60.95,83.36 61.33,83.74 61.33,85.14 62.48,86.28 64.38,86.28 64.89,85.77 64.89,82.85 67.43,80.31 75.43,80.31 76.57,79.17 76.57,64.69 75.94,64.05 75.94,59.1 77.21,57.83 83.69,57.83 83.94,57.58 83.94,56.94 111.5,56.94 111.75,56.69 115.94,56.69 116.07,56.82 136.52,56.82 136.77,56.56 136.77,55.67 136.39,55.29 136.39,48.31 136.14,48.05 67.68,48.05 66.16,46.53
GND on VCC: 286.25,63.04 285.74,63.55 285.74,68.12 285.87,68.25 296.81,68.25 297.55,68.99 297.55,69.97 298.27,69.97 298.27,69.86 298.27,65.93 298.27,65.89 298.21,65.88 290.85,65.88 290.73,65.88 290.62,65.86 289.8,65.09 290.11,64.01 290.18,63.91 290.21,63.79 290.22,63.78 290.22,63.04
GND on VCC: 57.7,45.01 57.35,45.15 56.77,46.57 55.7,47.01 29.7,47.01 28.65,47.45 28.21,48.5 28.21,52.74 28.54,53.68 29.38,54.2 41.16,58.79 50.66,67.11 50.97,67.29 51.31,67.22 51.96,66.81 52.17,66.69 52.39,66.58 56.92,68.12 55.7,72.75 55.1,73.13 54.89,73.41 54.92,73.76 55.14,74.22 55.14,74.22 57.24,79.67 58.43,85.38 82.91,85.38 82.92,72.75 82.92,67.51 83.83,66.59 86.12,66.59 86.5,66.21 112.73,66.21 113.15,65.79 113.15,58.47 113.14,47.01 68.7,47.01 67.63,46.57 67.05,45.15 66.7,45.01 ; 1 cut-out
GND on VCC: 113.48,78.02 113.01,78.5 113.01,82.05 109.71,85.35 109.71,93.02 112,95.3 112,101.4 113.27,102.67 113.27,103.56 113.81,104.11 118.81,104.11 119.14,103.78 120.69,103.78 121.91,102.56 122.9,102.56 124.22,101.24 129.76,101.24 130.07,100.93 130.07,100.76 130.09,100.73 130.09,100.55 130.7,99.94 140.2,99.94 152.19,111.93 154.28,111.93 154.53,112.19 170.42,112.19 170.8,111.81 170.8,89.29 168.41,86.9 165.1,86.9 158.75,80.55 127.13,80.55 124.6,78.02
GND on VCC: 276.61,8.01 275.56,8.45 275.12,9.5 275.12,17.5 275.26,17.85 275.61,17.99 275.9,17.99 276.61,18.29 276.91,19 276.91,24 276.61,24.71 275.9,25.01 275.61,25.01 275.26,25.15 275.12,25.5 275.12,25.94 276.48,25.94 278.9,23.53 280.67,23.53 280.91,23.29 280.92,13.87 280.15,13.11 280.15,8.01
GND on VCC: 297.55,87.93 297.55,88.92 296.77,89.71 288.01,89.71 284.32,93.39 280.43,93.39 279.77,92.73 279.77,91.85 278.4,90.47 277.1,90.47 277.11,121.18 276.32,121.97 267.98,121.97 267.73,121.71 265.02,121.71 264.77,121.97 260.34,121.97 260.34,122.45 259.81,122.98 258.8,122.98 248.83,132.93 228.45,153.3 228.45,177.49 245.7,177.49 246.75,177.05 247.19,176 247.19,175 247.63,173.93 248.7,173.49 250.2,173.49 250.55,173.35 250.69,173 250.69,167 251.13,165.93 252.2,165.49 271.68,165.49 272.74,165.05 273.17,164 273.17,137.5 273.62,136.43 274.68,135.99 293.18,135.99 294.24,135.55 294.67,134.5 294.67,133.3 295.74,130.04 298.54,128.04 298.54,126.16 286.04,126.16 286.04,123.9 286.22,123.32 286.71,122.95 286.84,122.84 286.84,112.02 286.76,111.96 286.24,111.59 286.04,110.99 286.04,96.24 298.04,96.24 298.04,94.45 297.9,94.1 297.55,93.96 295.7,93.96 293.84,92.1 295.7,90.24 297.55,90.24 297.9,90.1 298.04,89.75 298.04,87.93
GND on VCC: outline of 86 points within 113.15,112.62 171.32,152.19
GND on VCC: 52.79,166.4 52.32,166.88 52.32,170.88 54.09,172.66 54.09,173.76 52.7,175.16 52.7,177.49 65.02,177.49 65.02,170.84 64.64,170.46 64.64,169.44 61.61,166.42 60.83,166.42
GND on VCC: 286.73,18.07 285.99,18.81 285.99,25.71 286.73,26.45 287.39,26.45 287.75,25.9 288.37,25.69 297.34,25.69 298.04,24.99 298.04,19.01 297.34,18.31 288.37,18.31 288.02,18.25 287.71,18.07
GND on VCC: 30.82,170.21 30.33,170.7 30.33,176.39 39.1,176.39 39.1,170.7 38.61,170.21
GND on VCC: 285.41,0.51 284.36,0.95 283.92,2 283.92,5.11 286.09,5.11 286.85,5.87 287.86,5.87 287.86,5.57 287.4,4.44 288.37,3.69 297.84,3.69 298.54,2.99 298.54,2 298.1,0.95 297.05,0.51
GND on IN3: 126.48,175.56 164.61,175.56 165.09,175.08 165.09,169.72 164.46,169.08 153.66,169.08 153.15,169.59 150.23,169.59 145.53,164.89 139.06,164.89 137.91,163.75 126.87,163.75 125.85,164.77 125.85,174.93
GND on IN3: 69.59,112.31 78.63,112.31 84.57,106.37 84.57,102.15 81.02,98.6 74.67,98.6 74.29,98.98 74.29,102.15 72.89,103.55 64.76,103.55 64.38,103.93 64.38,107.11
GND on IN3: 161.28,149.65 165.22,149.65 166.74,148.13 170.93,148.13 171.19,147.87 171.19,129.46 170.68,128.95 161.66,128.95 160.65,129.97 160.65,149.02
GND on IN3: 160.39,98.6 167.76,98.6 168.01,98.85 170.68,98.85 171.19,98.34 171.19,90.6 167.89,87.3 165.98,87.3 163.82,85.14 161.16,85.14 159.89,86.41 159.89,98.09
GND on IN3: 191.25,83.49 216.4,83.49 217.29,82.6 217.29,81.45 216.65,80.82 196.08,80.82 189.6,74.34 189.6,73.71 182.87,66.98 180.71,66.98 178.43,69.26 178.43,70.66
GND on IN3: 204.97,108.89 209.67,108.89 221.61,96.95 224.4,96.95 225.42,95.93 226.69,95.93 230.5,92.12 236.47,92.12 237.1,91.49 237.1,89.2 236.47,88.57 189.22,88.57 188.59,89.2 188.59,91.36 199.76,102.54 199.76,103.68
GND on IN3: 67.81,91.61 69.84,91.61 70.22,91.23 70.22,86.53 70.86,85.9 76.19,85.9 76.7,85.39 76.7,75.36 76.32,74.98 74.16,74.98 72,72.82 66.29,72.82 66.03,72.56 66.03,67.74 63.49,65.2 60.44,65.2 60.06,65.58 60.06,65.83 60.57,66.34 60.57,72.31 60.19,72.69 60.19,79.68 60.95,80.44 60.95,83.49 61.08,83.61 62.1,83.61 62.22,83.49 62.22,74.21 62.48,73.96 63.24,73.96 63.37,73.83 63.37,72.31 63.49,72.18 64.38,72.18 64.64,72.44 64.64,73.2 65.27,73.83 65.27,87.8 67.18,89.71 67.18,90.98
GND on IN3: 85.34,97.71 86.48,97.71 87.75,96.44 87.75,84.12 87.24,83.61 84.57,83.61 83.3,82.34 83.3,81.2 89.4,75.1 89.4,73.96 89.02,73.58 83.81,73.58 78.48,68.25 76.83,68.25 76.19,68.88 76.19,71.17 77.97,72.94 77.97,84.37 80.76,87.17 80.76,93.14
GND on IN3: 284.75,12.64 286.12,14.02 286.12,17.19 285.74,17.57 285.74,26.21 284.73,27.22 282.69,27.22 282.19,26.72 282.19,22.4 278.88,19.1 278.88,17.19 277.61,15.92 277.61,13.89 278,13.51 278,11.86 277.59,11.45 276.45,11.45 276.42,11.43 275.79,12.06 275.79,12.09 275.68,11.98 275.68,9.16 276.52,8.33 284.04,8.33 284.75,9.04
GND on IN3: 197.1,175.18 202.05,175.18 202.94,176.07 223.64,176.07 223.77,176.2 243.58,176.2 248.4,171.37 248.4,166.8 250.82,164.38 271.14,164.38 271.77,163.75 271.77,140 269.99,138.22 258.95,138.22 258.44,138.73 258.44,145.46 264.79,151.81 264.79,154.99 263.52,156.26 256.02,156.26 255.96,156.32 246.69,156.32 233.04,142.67 226.81,142.67 218.18,151.3 209.67,151.3 204.34,156.64 198.11,156.64 195.06,159.69 195.06,173.15
GND on IN3: 266.69,99.61 264.28,102.03 257.17,102.03 256.91,101.77 251.71,101.77 250.31,100.38 248.28,100.38 244.47,104.19 223,104.19 217.04,110.16 217.04,112.7 218.05,113.71 219.7,113.71 222.24,116.25 222.24,118.16 228.59,124.51 228.59,129.59 243.83,144.83 254.12,144.83 256.79,142.16 256.79,137.08 260.6,133.27 264.28,133.27 278.76,118.79 278.76,110.79 280.41,109.14 280.41,102.92 277.11,99.61 ; 1 cut-out
GND on IN3: 208.58,128.82 215.89,128.82 217.42,130.35 220.46,130.35 220.97,129.84 220.97,129.21 204.34,112.57 202.18,112.57 201.67,113.08 201.67,116.89 203.17,118.38 203.17,123.41
GND on IN3: 279.77,43.35 282.19,43.35 283.58,41.96 283.58,40.31 281.17,37.89 281.17,28.88 280.41,28.11 279.27,28.11 278.5,28.88 278.5,34.34 279.14,34.97 279.14,39.29 279.65,39.8 279.65,43.23
GND on IN3: 2.15,164.38 5.83,164.38 6.72,163.5 6.72,137.33 11.42,132.63 11.42,130.22 10.91,129.71 5.96,129.71 5.07,130.6 2.02,130.6 1.64,130.98 1.64,163.88
GND on IN3: 134.87,69.39 176.27,69.39 180.59,65.07 180.59,61.39 178.81,59.61 176.52,59.61 173.35,56.43 173.35,54.53 173.73,54.15 174.62,54.15 174.74,54.02 174.74,51.48 173.86,50.59 160.14,50.59 159.76,50.97 159,50.97 158.74,50.72 144.52,50.72 142.74,52.5 142.74,57.07 141.09,58.72 137.79,58.72 136.77,57.7 136.77,55.67 136.39,55.29 136.39,48.31 136.14,48.05 67.68,48.05 66.16,46.53 58.79,46.53 57.02,48.31 29.79,48.31 29.51,48.59 29.46,48.59 29.46,52.5 30.22,53.26 32.63,53.26 47.49,60.63 51.05,63.93 53.21,63.93 53.59,63.55 53.59,55.04 54.35,54.28 57.4,54.28 58.16,55.04 59.56,55.04 61.59,57.07 61.59,58.59 62.48,59.48 62.48,59.99 67.94,65.45 78.61,65.45 85.34,72.18 88,72.18 88.51,71.67 88.51,67.86 90.16,66.21 99.05,66.21 100.7,64.56 133.09,64.56 133.98,65.45 133.98,68.5
GND on IN3: 264.79,98.47 281.55,98.47 282.06,97.96 282.06,94.28 281.55,93.77 263.14,93.77 262.12,94.79 262.12,95.8
GNDA on TOP (solid shape): 197.02,48.5 196.62,47.53 195.65,47.14 136.64,47.14 136.64,47.77 195.65,47.77 196.17,47.98 196.38,48.5 196.38,52.8 197.02,52.8
GNDA on GND1 (solid shape): outline of 1481 points within 136.64,47.01 197.14,60.5
GNDA on IN1 (solid shape): 197.02,48.5 196.62,47.53 195.65,47.14 136.64,47.14 136.64,47.77 195.65,47.77 196.17,47.98 196.38,48.5 196.38,52.8 197.02,52.8
GNDA on IN2 (solid shape): 197.02,48.5 196.62,47.53 195.65,47.14 136.64,47.14 136.64,47.77 195.65,47.77 196.17,47.98 196.38,48.5 196.38,52.8 197.02,52.8
GNDA on IN3 (solid shape): 197.02,48.5 196.62,47.53 195.65,47.14 136.65,47.14 136.65,47.77 195.65,47.77 196.17,47.98 196.38,48.5 196.38,52.8 197.02,52.8
GNDA on GND2 (solid shape): outline of 1481 points within 136.64,47.01 197.14,60.5
GNDA on BOTTOM, VCC: 136.64,47.01 136.64,55.11 137.03,55.49 137.03,57.52 137.33,57.83 141.16,57.83 142.49,56.51 142.49,52.32 144.34,50.47 158.92,50.47 159.18,50.72 159.58,50.72 160.09,50.21 174.04,50.21 174.67,50.85 178.48,50.85 178.81,51.17 178.81,52.3 178.48,52.62 176.22,52.62 176.01,52.42 176.01,51.91 175.84,51.74 175.43,51.74 175.13,52.04 175.13,52.57 175.38,52.83 175.38,54.07 175.05,54.4 173.91,54.4 173.6,54.71 173.6,56.25 173.78,56.43 174.16,56.43 177.08,59.36 179.24,59.36 180.39,60.5 182.57,60.5 183.33,59.74 184.22,59.74 185.03,58.92 185.03,55.37 185.36,55.04 187.65,55.04 187.7,54.98 187.7,53.71 188.84,52.57 188.84,50.03 189.17,49.7 192.32,49.7 192.77,50.14 192.77,52.43 193.14,52.8 197.14,52.8 197.14,48.5 196.7,47.45 195.65,47.01
VCC0R9GBE on BOTTOM: 257.24,89.24 258.1,88.38 258.1,86.65 257.87,86.41 255.78,86.41 255.21,86.98 255.21,88.14 254.58,88.77 254.58,89.16 254.35,89.38 254.35,89.8 254.47,89.91 255.02,89.91 255.54,90.43 255.54,90.87 256.52,91.85 256.52,94.14 255.89,94.77 252.84,94.77 252.46,94.39 252.46,91.22 252.2,90.96 251.06,90.96 250.55,90.46 250.17,90.46 249.92,90.71 249.92,95.66 250.17,95.92 251.19,95.92 251.7,96.43 258.43,96.43 258.68,96.17 258.68,91.85 258.17,91.35 257.71,91.35 257.24,90.88
VCC0R9GBE_L on BOTTOM: 253.92,89.19 254.25,89.19 254.38,89.06 254.38,88.73 254.95,88.16 254.95,86.46 255.01,86.41 255.01,84.88 254.75,84.63 253.74,84.63 253.4,84.96 253.4,88.19 253.78,88.56 253.78,89.05
VIN_1.00VS on TOP (solid shape): 153.73,175.43 153.73,171.42 153.56,171.25 152.32,171.25 151.75,171.82 151.75,172.93 151.07,173.61 151.07,175.67 151.28,175.88 153.28,175.88
VIN_1.00VS on BOTTOM (solid shape): 153.2,175.53 153.2,173.49 153.22,173.46 153.22,173.41 153.23,173.38 153.72,172.88 153.72,171.45 153.58,171.3 153,171.3 152.76,171.06 150.72,171.06 150.69,171.09 150.69,175.61 150.87,175.79 152.94,175.79
VIN_+1.8VSP on BOTTOM (solid shape): 191.72,172.82 192.99,172.82 193.17,172.64 193.17,169.59 193.79,168.97 193.79,168.96 194.05,168.7 194.05,167.97 193.79,167.97 193.79,168.45 193.72,168.52 193.29,168.52 193.26,168.5 193.26,167.99 193.24,167.97 192.19,167.97 192,168.16 192,170.22 190.44,171.78 190.44,173.01 190.58,173.15 191.38,173.15
+LCDVDD_CON on TOP: 56.88,115.37 57.45,115.94 57.45,116.99 58.17,117.71 61.98,117.71 62.01,117.69 68.89,117.69 68.94,117.63 71.86,117.63 72.24,117.25 72.24,114.71 71.36,113.82 62.54,113.82 62.08,113.37 60.76,113.37 59.15,114.98 58.79,114.98 57.26,113.44 56.3,113.44 55.81,112.95 54.98,112.95 54.63,113.3 54.63,113.86 54.98,114.22 55.55,114.22 56.7,115.37
+LCDVDD_CON on BOTTOM: 73.01,114.33 72.75,114.08 71.48,114.08 69.58,115.98 69.58,116.62 71.05,118.09 72.7,118.09 73.01,117.79
+LCDVDD_CON on BOTTOM: 55.75,114.65 55.75,115.44 56,115.69 57.09,115.69 57.35,115.95 57.35,116.3 57.6,116.56 57.88,116.56 57.92,116.52 58.02,116.52 58.06,116.47 58.06,115.47 55.7,113.1 55.69,113.1 55.52,112.92 55.03,112.92 54.76,113.2 54.76,113.66 55.03,113.94 55.21,113.94 55.75,114.47 55.75,114.65
+LCDVDD_CON on IN1: 56.25,117.78 71.75,117.78 72.26,117.27 72.26,114.35 71.37,113.46 56.25,113.46 55.72,112.92 54.93,112.92 54.7,113.15 54.7,113.94 55.36,114.6 55.36,116.89
+LCDVDD_CON on IN2: 62.45,117.72 71.87,117.72 72.28,117.32 72.28,114.37 71.37,113.46 56.3,113.46 55.72,112.87 54.96,112.87 54.78,113.05 54.78,113.74 55.36,114.32 55.36,116.76 56.38,117.78 62.4,117.78
+LEDVDD on TOP (solid shape): 58.36,111.74 58.36,110.93 58.36,110.92 58.36,110.45 58.03,110.13 57.9,110.13 56.5,111.53 56.5,111.68 57.26,112.44 57.26,112.52 57.3,112.57 57.54,112.57
+LEDVDD on BOTTOM: 59.4,113.24 59.82,113.67 60.26,113.67 60.71,114.13 60.81,114.13 64.09,110.85 64.09,110.37 63.58,109.86 62.44,109.86 61.27,111.03 60.91,111.03 60.89,111.01 59.2,111.01 58.39,110.2 57.47,110.2 56.76,110.91 56.76,112.32 56.86,112.42 56.86,112.59 57.53,113.26 58.95,113.26 58.96,113.24
+PCH_CORE on IN3 (solid shape): outline of 1551 points within 79.34,123.08 108.57,135.45
+PCH_CORE on TOP: 86.61,136.5 86.84,136.27 86.84,135.07 86.71,134.95 82.85,134.95 82.72,135.07 82.72,136.14 83.08,136.5
+PCH_CORE on TOP: 109.34,124.63 109.21,124.51 107.74,124.51 107.59,124.66 107.59,125.55 107.68,125.64 108.31,125.64 108.43,125.52 110.86,125.52 111.14,125.8 111.14,127.38 111.24,127.48 111.7,127.48 112.01,127.17 112.67,127.17 112.79,127.05 112.79,126.51 112.74,126.46 112.24,126.46 112.11,126.34 112.11,124.84 111.91,124.63
+PCH_CORE on BOTTOM: 111.24,127.53 111.6,127.53 112.01,127.12 112.01,126.16 111.88,126.03 111.17,126.03 111.07,126.13 111.07,127.35
+PCH_CORE on VCC: 106.34,123.87 106.04,124.18 106.04,129.13 105.78,129.38 105.78,130.91 105.46,131.24 105.07,131.24 104.77,131.54 104.77,132.05 104.39,132.43 104.39,132.61 104.24,132.76 84.32,132.76 82.7,134.39 82.7,136.09 83.04,136.43 86.19,136.43 86.7,136.94 112.79,136.95 112.9,136.85 112.88,129.85 114.15,128.58 114.15,125.06 114.11,125.01 113.1,125.01 112.77,124.69 112.77,124.05 112.59,123.87
+RTCBATT on TOP: 137.74,145.64 138.24,145.64 139.06,146.45 140.63,146.45 142.79,148.61 142.79,150.95 141.8,151.94 140.99,151.94 140.81,151.76 140.81,150.57 141.57,149.8 141.57,149.37 141.06,148.86 139.92,148.86 137.53,146.48 137.53,145.84
+RTCBATT on IN2: 140.94,151 143.25,151 147.95,155.7 152.98,155.7 153.48,155.19 171.72,155.19 173.53,153.39 179.8,153.39 188.84,144.34 199.41,144.34 202.35,147.29 217.04,147.29 218.48,148.74 218.48,168.58 217.62,169.44 217.62,172.46 217.39,172.69 216.55,172.69 216.35,172.49 216.35,152.57 217.19,151.74 217.19,149.04 216.65,148.51 200.47,148.51 199.08,147.11 189.32,147.11 181.42,155.01 181.4,155.01 180.79,155.62 174.14,155.62 172.79,156.97 147.44,156.97 146.09,155.62 143.45,155.62 140.76,152.93 140.63,152.93 140.63,151.3
+RTCVCC on TOP: 131.82,136.75 133.88,136.75 133.95,136.67 133.95,132.89 133.42,132.35 127.58,132.35 126.61,131.39 124.71,131.39 124.33,131.77 124.33,132.58 124.43,132.69 124.45,132.69 124.99,133.22 131.79,133.22 132.35,133.78 132.35,134.95 131.62,135.68 131.62,136.55
+RTCVCC on BOTTOM: 133.69,145.83 134.21,145.31 134.21,136.93 132.61,135.33 131.56,135.33 131.13,135.76 131.13,137.66 131.87,138.4 131.87,145.21 132.49,145.83
+RTCVCC on IN3: 115.46,126.51 118.59,126.51 120.87,128.8 120.87,129.56 124.07,132.76 125.04,132.76 125.21,132.58 125.21,131.19 119.86,125.83 114.62,125.83 114.39,126.06 114.39,126.84 114.52,126.97 115,126.97
+USB_VCCA on TOP: 282.29,30.63 282.3,30.64 285.83,30.64 286.13,30.34 286.13,28.91 286.14,28.9 286.14,28.67 286.19,28.61 286.19,26.58 285.7,26.09 283.45,26.09 282.66,26.88 282.66,27.16 282.38,27.44 282.12,27.44 281.74,27.82 281.74,30.4 281.97,30.63
+USB_VCCA on TOP: 280.61,11.48 280.87,11.22 280.87,10.84 281.36,10.35 281.36,9.25 281.55,9.06 282.03,9.06 282.05,9.08 282.33,9.08 282.57,9.32 282.57,10.46 282.69,10.59 282.95,10.59 283.08,10.46 283.08,9.32 283.33,9.06 285.23,9.06 286.38,7.92 286.38,6.27 286.25,6.14 285.23,6.14 284.98,6.4 284.98,7.03 283.46,8.56 279.01,8.56 279,8.57 278.72,8.57 278.5,8.78 278.5,11.17 278.81,11.48
+USB_VCCA on BOTTOM: 286.36,7.34 286.37,7.32 286.37,7.29 286.34,6.81 286.59,6.41 286.62,6.3 286.52,6.23 285.17,6.23 285.05,6.36 285.05,6.78 283.28,8.54 282.95,8.54 282.57,8.92 278.9,8.92 278.63,9.19 278.63,12.49 279,12.86 281.77,12.86 281.92,12.71 281.92,11.91 282.6,11.23 283.67,11.23 283.78,11.13 283.78,9.48 284.9,8.36 285.34,8.36
+USB_VCCA on BOTTOM: 279.06,29.31 279.38,29.62 279.38,30.39 279.64,30.64 284.39,30.64 284.76,30.26 285.26,30.26 286.34,29.19 286.44,28.57 286.96,28.23 287.01,28.23 287.01,27.37 286.44,26.8 282.59,26.8 282.58,26.8 282.53,26.8 281.92,26.19 281.92,26.08 281.55,25.71 281.55,23.78 281.3,23.53 280.78,23.53 280.52,23.78 280.52,25.44 280.27,25.69 279.39,25.69 279.06,26.02
+USB_VCCA on VCC: 283.92,5.62 283.14,7.32 281.41,8.01 280.66,8.01 280.66,12.9 281.42,13.66 281.41,39.3 281.9,39.78 287.48,39.78 287.4,39.03 287.86,38.43 287.86,27.57 287.57,27.31 287.39,26.96 286.52,26.96 285.48,25.92 285.48,18.6 286.52,17.56 287.39,17.56 287.44,16.92 287.86,16.43 287.86,6.38 286.64,6.38 285.88,5.62
+VGA_B+ on TOP (solid shape): 110.64,159.99 110.64,159.11 110.57,159.04 108.08,159.04 107.81,159.31 107.81,160.71 107.93,160.83 109.8,160.83
+VGA_B+ on TOP (solid shape): 106,169.83 106,168.46 106.19,168.27 106.19,167.4 106.01,167.22 105,167.22 104.59,167.64 104.59,169.91 104.75,170.08 105.76,170.08
+VGA_B+ on BOTTOM (solid shape): 105.5,174.19 105.5,170.15 105.63,170.01 105.93,170.01 106.2,169.73 106.2,167.79 110.93,163.06 110.93,159.22 110.73,159.02 109.95,159.02 109.55,158.62 106.42,158.62 106.04,159.03 105.66,158.62 103.26,158.62 102.97,158.91 102.97,163.08 103.02,163.13 103.02,163.86 101.6,165.28 101.6,165.62 100.14,167.09 100.14,169.83 99.67,170.3 99.67,174.39 100.08,174.8 104.89,174.8
+VGA_CORE on BOTTOM (solid shape): 85.86,172.44 85.86,170.63 85.32,170.08 84.13,170.08 83.99,169.94 83.99,169.55 84.09,169.44 85.3,169.44 85.86,168.88 85.86,166.81 88.57,164.11 88.57,162.73 87.81,161.97 86.48,161.97 86.29,161.78 86.29,161.23 86.48,161.04 87.4,161.04 88.57,159.87 88.57,158.03 88.43,157.88 85.06,157.88 84.7,158.24 80.72,158.24 79.57,159.39 79.57,160.47 76.86,163.18 75.77,163.18 74.11,164.84 74.11,167.32 72.02,169.41 72.02,172.64 72.51,173.12 85.18,173.12
+VGA_CORE on TOP: 73.1,172.71 81.2,172.71 82.42,171.49 82.42,164.18 80.91,162.67 75.11,162.67 74.39,163.39 70.05,163.39 69.26,162.61 67.68,162.61 65.78,160.7 65.78,159.18 66.16,158.8 67.81,158.8 70.35,156.26 70.35,153.46 67.68,153.46 67.05,152.83 64.38,152.83 62.6,154.61 61.84,154.61 61.71,154.48 61.71,152.45 61.33,152.07 59.3,152.07 58.92,151.68 58.92,149.78 58.16,149.02 58.16,146.99 58.03,146.86 56.63,146.86 55.87,147.62 52.06,147.62 51.43,146.99 50.54,146.99 50.28,147.24 50.28,150.8 49.14,151.94 49.14,153.59 49.65,154.1 50.92,154.1 51.17,154.35 51.17,155.62 51.81,156.26 53.21,156.26 54.09,157.15 55.11,157.15 56.13,158.16 56.13,159.05 63.87,166.8 65.65,166.8 66.16,167.31 71.67,167.31 72.56,168.19 72.56,172.17
+VGA_CORE on IN1: 50.83,146.54 50.45,146.92 50.45,149.41 50.72,149.68 50.72,149.77 51.26,149.77 51.49,149.99 51.49,150.5 51.14,150.86 51.14,151.14 50.82,151.45 50.82,154.4 51.52,155.1 53.09,155.1 53.09,156.39 53.63,156.93 53.8,156.93 53.83,156.9 54.16,156.9 56.04,158.78 59.01,158.78 60.92,156.88 60.92,154.64 60.71,154.44 59.7,154.44 59.27,154.01 59.27,152.81 59.03,152.57 55.39,152.57 54.92,152.1 54.92,148.44 54.08,147.61 52.79,147.61 51.8,146.62 51.8,146.54
+VGA_CORE on VCC: 65.68,145.97 65.67,145.97 61.18,145.97 60.42,146.73 59.15,146.73 59.03,146.86 58.18,146.86 58.05,146.73 56.84,146.73 56.62,146.95 56.62,147.58 56.22,147.99 53.48,148 53.35,147.87 52.72,147.87 52.32,147.47 52.32,147.09 52.08,146.86 51.26,146.86 51.25,146.87 51.16,146.86 51.07,146.86 51.07,149.55 50.79,149.83 50.79,154.99 50.79,155 51.04,155.25 51.04,157.45 51.81,158.22 51.81,162.5 52.32,163.01 52.32,165.29 52.92,165.9 60.83,165.91 61.82,165.91 65.14,169.23 65.14,170.25 65.52,170.63 65.52,177.49 71.75,177.49 72.1,177.35 72.24,177 72.24,176 72.68,174.93 73.75,174.49 82.79,174.49 82.79,158.54 80.74,158.54 80,159.28 80,159.54 79.35,160.19 76.98,160.19 75.94,159.16 75.94,155.64 76.45,155.14 76.45,154.46 76.07,154.08 76.07,152.21 76.7,151.58 76.7,148.87 74.68,146.84 66.55,146.84
+VGA_CORE on IN3: outline of 114 points within 50.76,146.46 83.05,172.13
ADAPTER_ID_ON on TOP (solid shape): 275.35,106.94 275.35,106.87 275.82,106.4 275.82,105.52 275.44,105.14 273.65,105.14 273.64,105.15 273.64,106.5 273.81,106.68 274.39,106.68 274.47,106.75 274.47,106.98 274.67,107.18 275.1,107.18
ADP_ID on TOP: 278.88,108.06 279.42,108.06 279.61,107.87 279.61,106.44 279.47,106.29 278.75,106.29 278.46,106 278.46,105.99 278.34,105.87 277.28,105.87 277.21,105.94 277.21,106.67 277.65,107.11 277.65,109.68 277.74,109.77 278.5,109.77 278.63,109.65 278.63,108.32
APDIN on TOP (solid shape): 286.02,107.72 286.02,106.3 285.98,106.26 282.21,106.26 281.87,106.61 281.87,107.43 282.31,107.87 285.86,107.87
APDIN on TOP (solid shape): 286.03,102.95 286.03,100.79 285.96,100.73 282.12,100.73 281.68,101.16 281.68,102.45 282.28,103.04 285.94,103.04
APDIN on BOTTOM (solid shape): outline of 83 points within 280.09,100.58 286,108.06
B+ on TOP (solid shape): 156.83,175.48 156.83,173.39 156.64,173.2 154.5,173.2 154.23,173.47 154.23,175.53 154.35,175.66 156.65,175.66
B+ on TOP (solid shape): 214.31,173.24 214.31,171.97 213.59,171.26 210.83,171.26 210.44,171.64 210.44,173.29 210.93,173.78 213.77,173.78
B+ on TOP (solid shape): 231.94,121.34 231.94,120.16 231.65,119.87 229.39,119.87 229.13,120.13 229.13,121.3 229.52,121.69 231.58,121.69
B+ on TOP (solid shape): 197.03,175.62 197.03,172.02 196.71,171.69 195.15,171.69 194.66,172.18 194.66,175.61 195.04,175.99 196.66,175.99
B+ on TOP (solid shape): 175.76,167.81 175.76,167.18 175.76,166.04 175.35,165.63 174.71,165.63 174.64,165.71 174.64,166.9 174.64,166.9 174.64,167.45 175.13,167.94 175.63,167.94
B+ on TOP (solid shape): 78.12,72.32 79.37,72.32 79.63,72.06 79.63,69.65 78.68,68.7 77.51,68.7 77.28,68.93 77.28,69.29 77.66,69.67 77.66,70.48 76.83,71.31 76.83,72 77.16,72.33 78.11,72.33
B+ on TOP (solid shape): 113.15,162.04 113.15,161.75 112.95,161.54 112.95,158.47 112.39,157.91 111.5,157.91 111.37,158.03 111.37,158.79 111.2,158.97 111.2,161.08 111.19,161.09 111.19,162.03 111.49,162.33 112.87,162.33
B+ on BOTTOM (solid shape): 113.02,162.11 113.02,158.54 112.39,157.91 111.5,157.91 111.37,158.03 111.37,158.8 111.37,158.8 111.23,158.94 111.23,162.13 111.34,162.24 112.9,162.24
B+ on BOTTOM (solid shape): 77.6,96.18 77.6,91.87 77.21,91.48 74.48,91.48 73.53,92.43 73.53,94 75.26,95.73 75.26,96.12 75.39,96.26 77.16,96.26 77.21,96.31 77.46,96.31
B+ on BOTTOM (solid shape): 175.74,168.99 175.74,165.66 175.24,165.15 174.39,165.15 173.44,166.1 173.44,167.14 173.73,167.44 173.98,167.44 173.98,168.78 173.96,168.8 173.43,168.8 173.43,169.34 173.59,169.51 175.23,169.51
B+ on BOTTOM (solid shape): 67.3,113.33 67.3,111.81 67.27,111.81 67.05,111.59 65.16,111.59 64.52,110.95 64.43,110.95 63.35,112.03 63.35,112.17 63.42,112.24 63.44,112.23 64.16,112.95 64.14,112.96 64.75,113.57 67.06,113.57
B+ on BOTTOM (solid shape): 214.42,173.41 214.42,171.34 214.25,171.18 213.57,171.18 213.43,171.32 213.43,171.74 213.4,171.76 211.97,171.76 211.95,171.74 211.95,171.18 211.63,171.18 211.4,171.4 210.79,171.4 210.67,171.52 210.67,173.21 211.05,173.59 214.25,173.59
B+ on BOTTOM (solid shape): 156.78,175.63 156.78,173.31 156.39,172.92 155.32,172.92 155.16,173.08 153.73,173.08 153.35,173.46 153.35,173.51 153.64,173.81 153.89,173.81 153.89,175.16 153.87,175.18 153.34,175.18 153.34,175.72 153.5,175.88 156.53,175.88
B+ on BOTTOM (solid shape): 253.46,101.36 256.75,101.36 256.81,101.3 256.81,100.92 256.8,100.92 256.8,100.88 256.51,100.59 256.51,100.19 256.8,99.89 256.8,97.97 256.68,97.85 254.95,97.85 254.53,97.44 247.31,97.44 246.98,97.77 246.98,100.15 247.49,100.66 250.8,100.66 251.9,101.76 253.06,101.76
B+ on BOTTOM (solid shape): 82.61,71.26 82.72,71.04 82.94,70.93 84.48,69.38 84.48,66.88 84.22,66.62 84.22,65.19 83.89,64.86 77.44,64.86 77.27,65.03 77.27,69.02 77.79,69.54 77.79,70.85 77.36,71.28 76.04,71.28 75.82,71.5 75.82,74.96 75.98,75.12 78.75,75.12
B+ on BOTTOM (solid shape): 196.78,175.87 196.78,175.12 196.46,174.8 196.46,174.42 195.9,174.42 195.9,173.91 195.93,173.88 196.46,173.88 196.46,173.66 196.44,173.63 195.93,173.63 195.9,173.6 195.9,173.1 195.93,173.07 196.46,173.07 196.46,172.61 196.74,172.33 196.74,171.68 196.31,171.25 195.61,171.25 194.67,172.19 194.67,174.75 195.14,175.22 195.14,175.92 195.22,175.99 196.66,175.99
B+ on TOP: 251.45,101.9 254.63,101.9 254.88,101.65 254.88,99.87 254.75,99.74 250.06,99.74 249.93,99.87 249.93,100.38 250.18,100.63 250.82,100.63 251.2,101.01 251.2,101.65
B+ on BOTTOM: 228.4,116.09 227.79,116.7 227.79,121.61 227.81,121.63 227.81,122.14 227.14,122.8 225.37,122.8 223.72,121.15 214.37,121.15 213.2,122.32 213.2,127.05 213.4,127.25 217.06,127.25 218.41,128.6 223.97,128.6 227.86,124.71 229.58,124.71 232.58,121.71 232.58,121.7 232.58,116.72 231.95,116.09
B+ on IN2: 170.65,54.79 170.63,54.81 169.62,54.81 169.62,54.81 161.52,54.81 161.43,54.85 161.42,54.95 160.7,55.96 159.98,54.95 159.97,54.85 159.89,54.81 147.47,54.81 147.44,54.78 146.42,54.78 144.08,57.13 144.04,57.13 142.98,58.19 137.2,58.19 136.15,57.13 112.52,57.13 111.24,58.4 77.27,58.4 76.4,59.28 76.4,63.8 76.95,64.36 76.95,79.93 76.19,80.69 67.56,80.69 65.27,82.98 65.27,89.2 66.79,90.72 66.79,94.92 68.19,96.31 77.21,96.31 77.72,95.8 77.72,94.66 75.43,92.38 70.99,92.38 70.48,91.87 70.48,87.04 71.24,86.28 85.72,86.28 87.5,84.5 87.5,67.61 89.15,65.96 105.09,65.96 111.5,72.37 119.94,72.37 125.34,66.98 160.77,66.98 184.13,90.33 211.44,90.33 211.9,89.87 211.9,81.03 211.88,81.01 211.88,79.22 211.05,78.39 196.07,78.39 194.8,77.12 194.8,76.94 193.66,75.8 190.55,75.8 177.12,62.37 177.12,62.01 173.32,58.2 173.32,55.98 172.39,55.87 172.27,54.94 172.27,54.84 172.19,54.79 ; 1 cut-out
B+ on VCC: 233.56,88.68 201.01,88.69 200.53,89.18 200.53,92.65 201.54,93.67 201.54,108.78 210.81,118.05 210.8,135.01 206.48,139.45 206.48,154.19 205.06,155.61 192.62,155.61 189.7,158.53 148.59,158.53 147.38,157.31 146.57,156.51 132.98,156.51 132.22,155.75 131.92,155.75 131.16,156.51 126.08,156.51 125.57,157.02 122.45,157.02 121.3,155.88 110.59,155.88 107.8,158.66 107.81,159.06 107.82,159.07 107.82,159.92 107.81,159.93 107.82,162.73 107.82,163.39 108.3,163.88 114.31,163.88 114.95,163.24 137.89,163.24 138.55,163.9 138.55,177.49 227.95,177.49 227.95,153.09 248.39,132.64 248.54,132.49 258.59,122.47 259.6,122.47 259.83,122.24 259.83,121.08 259.83,120.97 259.83,119.66 259.45,119.28 259.45,104.16 256.15,100.86 256.15,100.48 253.63,97.96 253,97.96 252.34,97.31 252.34,96.67 250.71,95.04 245.12,95.04 244.74,94.66 244.32,94.66 243.94,95.04 240.11,95.04 240.1,95.05 240.01,95.04 239.92,95.04 239.91,95.03 239.89,95.03 239.83,94.96 239.77,94.89 239.77,94.89 ; 7 cut-outs
B+ on IN3: 64.38,113.33 65.4,113.33 65.91,112.82 67.3,112.82 67.56,112.57 67.56,110.79 67.18,110.41 65.65,110.41 63.75,108.5 63.75,105.33 62.35,103.93 62.35,101.27 65.52,98.09 77.21,98.09 77.72,97.58 77.72,95.04 77.08,94.41 62.98,94.41 58.92,98.47 58.92,99.11 58.41,99.61 58.29,100 58.29,107.23
B+_1.35V on TOP (solid shape): 170.35,169.4 170.44,169.39 171.06,169.39 171.18,169.39 171.29,169.41 171.94,169.41 172.08,169.27 172.08,166.9 171.8,166.62 169.35,166.62 169.22,166.74 169.22,169.17 169.48,169.42 170.25,169.42
B+_1.35V on BOTTOM (solid shape): 169.99,169.66 169.99,169.65 170.08,169.54 170.19,169.46 170.2,169.45 170.24,169.4 170.38,169.39 170.44,169.39 171.13,169.39 171.18,169.39 171.24,169.4 173.15,169.4 173.26,169.3 173.26,166.74 173.12,166.6 169.74,166.6 169.02,167.31 168.53,167.31 168.5,167.34 167.63,167.34 167.37,167.61 167.37,169.98 167.51,170.12 169.53,170.12
B+_1.35V on IN3 (solid shape): 172.63,169.07 172.63,168.04 172.47,167.89 170.25,167.89 169.96,168.17 169.96,168.92 170.5,169.46 172.24,169.46
BATT+ on BOTTOM (solid shape): 260.11,111.84 260.11,109.96 259.75,109.61 259.75,109.04 258.87,108.16 258.87,104.34 257.41,102.89 253.35,102.89 252.76,102.3 250.57,102.3 250.38,102.49 250.38,102.76 250.84,103.22 250.84,103.58 250.38,104.04 250.38,110.72 250.77,111.11 255.36,111.11 256.28,112.03 259.91,112.03
BATT_TEMP on BOTTOM (solid shape): 218.3,114.08 218.3,113.31 218.25,113.27 217.24,113.27 216.98,113.52 216.98,113.97 217.14,114.12 218.26,114.12
BQ24780_BATDRV on TOP: 248.66,103.04 249.04,103.04 249.67,102.41 250.31,102.41 250.56,102.15 250.56,101.65 249.67,100.76 248.66,100.76 248.53,100.88 248.53,102.92
BST_1.00VS on TOP (solid shape): 147.24,171.8 147.24,169.76 147.12,169.64 145.8,169.64 145.69,169.75 145.69,171.72 145.84,171.88 147.16,171.88
BST_1.00VS on BOTTOM (solid shape): 147.38,170.48 148.23,170.48 148.28,170.43 148.28,170.27 148.26,170.26 147.48,170.26 147.22,170 147.22,169.76 147.11,169.64 146.87,169.64 146.75,169.76 146.75,170.63 146.88,170.77 147.09,170.77
BST_CHG on BOTTOM (solid shape): 223.7,111.8 224.69,111.8 224.81,111.68 224.81,110.93 224.66,110.77 224.01,110.77 223.78,111 223.78,111.14 223.36,111.56 221.07,111.56 221.06,111.58 221.06,111.75 221.09,111.78 221.82,111.78 221.84,111.8 222.75,111.8 222.75,111.81 222.9,111.96 223.54,111.96
CHG on BOTTOM (solid shape): 244.95,113.76 244.95,112.02 245.94,111.03 249.68,111.03 250.07,110.65 250.07,104.91 250.06,104.91 250.06,104.75 248.96,103.65 248.96,103.3 249.55,102.71 249.55,102.3 249.18,101.92 249.18,101.06 249,100.89 245.98,100.89 245.87,101 245.86,101 245.6,101.27 244.57,101.27 244.2,101.63 243.19,101.63 242.55,102.27 239.57,102.27 236.54,105.29 236.54,113.12 237.73,114.3 244.41,114.3
CHG on TOP: 246.88,103.04 248.15,103.04 248.28,102.92 248.28,100.88 248.15,100.76 246.75,100.76 246.25,101.27 246.25,102.41
DH_1.35V on TOP (solid shape): 177.84,171.12 178.13,171.12 178.44,170.81 178.45,170.81 178.48,170.79 179.42,170.79 179.5,170.71 179.5,170.55 178.68,170.55 178.67,170.54 177.62,170.54 177.07,171.09 177.07,171.32 177.26,171.51 177.45,171.51
