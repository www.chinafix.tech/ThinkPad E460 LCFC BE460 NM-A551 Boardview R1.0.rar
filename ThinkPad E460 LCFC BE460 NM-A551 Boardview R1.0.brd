# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Nets (continued)
B_EQ0: R55.1 R9465.2 U6.2(B_EQ0_NC)
B_EQ1: R57.1 U6.4(B_EQ1_I2C_ADDR1)
BATLOW#: RPC18.7(R7) UC1.AU13(GPD0/BATLOW#)
BATT+: PC10.2 PC119.2 PC120.2 PC123.1 PC124.2 PL3.2 PL4.2 PR117.2 PR128.1
BATT_TEMP: CE16.1 PR17.2 PU101.15(BATPRES#) UE1.68(ADC2/GPI2)
BB_DE0: R40.1 R9464.2 U5.3(B_DE0_I2C_ADDR0)
BB_DE1: R42.1 U5.6(B_DE1_NC)
BB_EQ0: R41.1 R9463.2 U5.2(B_EQ0_NC)
BB_EQ1: R43.1 U5.4(B_EQ1_I2C_ADDR1)
BBB_DE0: R251.1 R9460.2 U16.3(B_DE0_I2C_ADDR0)
BBB_DE1: R252.1 U16.6(B_DE1_NC)
BBB_EQ0: R247.1 R9459.2 U16.2(B_EQ0_NC)
BBB_EQ1: R248.1 U16.4(B_EQ1_I2C_ADDR1)
BEEP#: CA22.1 DA1.2 UE1.32(PWM6/SSCK/GPA6)
BKOFF#: JLCD.11 R26.1 UE1.119(CRX0/GPC0)
BOARD_ID: RE3.1 RE7.2 UE1.69(ADC3/GPI3)
BQ24780_BATDRV: PC108.2 PQ104.4(G) PR103.1 PU101.18(BATDRV)
BQ24780_VDD: PC116.1 PU101.24(REGN)
BST_1.00VS: PR707.1 PU701.5(BST)
BST_CHG: PR116.1 PU101.25(BTST)
BT_ON: R150.2 R239.1 RPC10.1(R1) UC1.AP5(GPP_B21/GSPI1_MISO)
BT_ON_R: JWLBT.54(RESERVED/W_DISABLE#2) R90.1 R239.2
BYPASS_PAD: JCP.1 R61.2 R66.2 R108.2
C_COVER_LOGO: JLOGO.1 R84.2
CFG0: RC105.2 RC201.2 TP36.1 UC1.E68(CFG[0])
CFG1: TP38.1 UC1.B67(CFG[1])
CFG2: TP40.1 UC1.D65(CFG[2])
CFG3: TP41.1 UC1.D67(CFG[3])
CFG4: RC104.2 RC144.2 TP42.1 UC1.E70(CFG[4])
CFG5: TP44.1 UC1.C68(CFG[5])
CFG6: TP46.1 UC1.D68(CFG[6])
CFG7: TP47.1 UC1.C67(CFG[7])
CFG8: TP48.1 UC1.F71(CFG[8])
CFG9: TP50.1 UC1.G69(CFG[9])
CFG10: TP52.1 UC1.F70(CFG[10])
CFG11: TP53.1 UC1.G68(CFG[11])
CFG12: TP55.1 UC1.H70(CFG[12])
CFG13: TP56.1 UC1.G71(CFG[13])
CFG14: TP57.1 UC1.H69(CFG[14])
CFG15: TP58.1 UC1.G70(CFG[15])
CFG16: TP61.1 UC1.E63(CFG[16])
CFG17: TP63.1 UC1.F63(CFG[17])
CFG18: TP62.1 UC1.E66(CFG[18])
CFG19: TP65.1 UC1.F66(CFG[19])
CFG_RCOMP: RC152.1 UC1.E60(CFG_RCOMP)
CHG: PC108.1 PC122.1 PC124.1 PL102.2 PQ104.1(S1) PQ104.2(S2) PQ104.3(S3) PR103.2 PR117.1 PR125.1 PU101.17(BATSRC)
CL_CLK_WLAN: JWLBT.42(RESERVED3) UC1.G3(CL_CLK)
CL_DATA_WLAN: JWLBT.40(RESERVED2) R150.1 UC1.G2(CL_DATA)
CL_RST_WLAN#: JWLBT.38(RESERVED1) R151.1 UC1.G1(CL_RST#)
CLK_PCI_EC: CC537.1 RC24.2 UE1.13(LPCCLK/GPM4)
CLK_PCIE_CR: JCR.8 UC1.E38(CLKOUT_PCIE_P5)
CLK_PCIE_CR#: JCR.7 UC1.E40(CLKOUT_PCIE_N5)
CLK_PCIE_LAN: UC1.C40(CLKOUT_PCIE_P3) UL1.44(PE_CLKP)
CLK_PCIE_LAN#: UC1.D40(CLKOUT_PCIE_N3) UL1.45(PE_CLKN)
CLK_PCIE_VGA: UC1.A40(CLKOUT_PCIE_P4) UV3.AK30(PCIE_REFCLKP)
CLK_PCIE_VGA#: UC1.B40(CLKOUT_PCIE_N4) UV3.AK32(PCIE_REFCLKN)
CLK_PCIE_WLAN: JWLBT.47(REFCLKP0) UC1.C41(CLKOUT_PCIE_P2)
CLK_PCIE_WLAN#: JWLBT.49(REFCLKN0) UC1.D41(CLKOUT_PCIE_N2)
CLK_REQ_GPU#: QV7.3(S) RV51.2 RV52.2 RV53.2 RV112.1
CLKOUT_ITPXDP_N: T52.1 UC1.F43(CLKOUT_ITPXDP_N)
CLKOUT_ITPXDP_P: T53.1 UC1.E43(CLKOUT_ITPXDP_P)
CLKREQ_PCIE2_WLAN#: JWLBT.53(CLKREQ0#) RPC200.8(R8) UC1.AT8(GPP_B7/SRCCLKREQ2#)
CLKREQ_PCIE3_LAN#: RPC200.7(R7) UC1.AT10(GPP_B8/SRCCLKREQ3#) UL1.48(CLK_REQ_N)
CLKREQ_PCIE4_VGA#: CV141.1 QV7.1(D) RC165.2 RC166.2 RV51.1 UC1.AU8(GPP_B9/SRCCLKREQ4#)
CLKREQ_PCIE5_CR#: JCR.11 RPC200.5(R5) UC1.AU7(GPP_B10/SRCCLKREQ5#)
CLKRUN#: RC52.1 UC1.AW11(GPP_A8/CLKRUN#)
CONFIGER1: JLINK.19(CONFIG1) R105.1
CP_BYPASS: R108.1 RC406.2 RE51.2 RPC10.2(R2)
CP_BYPASS_EC: RE51.1 UE1.67(ADC1/GPI1)
CP_BYPASS_R: RC406.1 UC1.AB2(GPP_C9/UART0_TXD)
CP_CLK: C44.1 JCP.4 RE5.1 UE1.89(PS2CLK2/GPF4)
CP_DATA: C45.1 JCP.3 RE6.1 UE1.90(PS2DAT2/GPF5)
CP_RESET#: JCP.5 R67.2 RC405.1 RE50.2
CP_RESET#_EC: RE50.1 UE1.35(RTS1#/GPE5)
CP_RESET#_R: RC405.2 UC1.P3(GPP_D10)
CPU_EDP_AUX: C18.1 UC1.F45(EDP_AUXP)
CPU_EDP_AUX#: C17.1 UC1.E45(EDP_AUXN)
CPU_EDP_AUX#_CON: C17.2 JLCD.20
CPU_EDP_AUX_CON: C18.2 JLCD.21
CPU_EDP_HPD: JLCD.22 RC159.1 UC1.L10(GPP_E17/EDP_HPD)
CPU_EDP_TX0+: C16.1 UC1.C46(EDP_TXP[0])
CPU_EDP_TX0+_CON: C16.2 JLCD.29
CPU_EDP_TX0-: C15.1 UC1.C47(EDP_TXN[0])
CPU_EDP_TX0-_CON: C15.2 JLCD.28
CPU_EDP_TX1+: C14.1 UC1.C45(EDP_TXP[1])
CPU_EDP_TX1+_CON: C14.2 JLCD.26
CPU_EDP_TX1-: C13.1 UC1.D46(EDP_TXN[1])
CPU_EDP_TX1-_CON: C13.2 JLCD.25
CSB_1B: PC429.2 PC439.2 PR460.2 PRT405.2 PU401.41(CSN_1B)
CSN1: PR423.2 PR456.2
CSN_1A: PC405.2 PC440.2 PR452.2 PRT401.2 PU401.28(CSN_1A)
CSP1: PR422.2 PR426.2 PR455.2
DDR3_DRAMRST#: CD59.1 CD60.1 JDIMM1.30(RESET#) JDIMM2.30(RESET#) RD21.2 UC1.AT13(DRAM_RESET#)
DDR_A_BS0: JDIMM1.109(BA0) UC1.AU52(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
DDR_A_BS1: JDIMM1.108(BA1) UC1.AT48(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
DDR_A_BS2: JDIMM1.79(BA2) UC1.AY55(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
DDR_A_CAS#: JDIMM1.115(CAS#) UC1.AU48(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
DDR_A_D0: JDIMM1.5(DQ0) UC1.AL71(DDR0_DQ[0])
DDR_A_D1: JDIMM1.7(DQ1) UC1.AL68(DDR0_DQ[1])
DDR_A_D2: JDIMM1.15(DQ2) UC1.AN68(DDR0_DQ[2])
DDR_A_D3: JDIMM1.17(DQ3) UC1.AN69(DDR0_DQ[3])
DDR_A_D4: JDIMM1.4(DQ4) UC1.AL70(DDR0_DQ[4])
DDR_A_D5: JDIMM1.6(DQ5) UC1.AL69(DDR0_DQ[5])
DDR_A_D6: JDIMM1.16(DQ6) UC1.AN70(DDR0_DQ[6])
DDR_A_D7: JDIMM1.18(DQ7) UC1.AN71(DDR0_DQ[7])
DDR_A_D8: JDIMM1.21(DQ8) UC1.AR70(DDR0_DQ[8])
DDR_A_D9: JDIMM1.23(DQ9) UC1.AR68(DDR0_DQ[9])
DDR_A_D10: JDIMM1.33(DQ10) UC1.AU71(DDR0_DQ[10])
DDR_A_D11: JDIMM1.35(DQ11) UC1.AU68(DDR0_DQ[11])
DDR_A_D12: JDIMM1.22(DQ12) UC1.AR71(DDR0_DQ[12])
DDR_A_D13: JDIMM1.24(DQ13) UC1.AR69(DDR0_DQ[13])
DDR_A_D14: JDIMM1.34(DQ14) UC1.AU70(DDR0_DQ[14])
DDR_A_D15: JDIMM1.36(DQ15) UC1.AU69(DDR0_DQ[15])
DDR_A_D16: JDIMM1.39(DQ16) UC1.BB65(DDR0_DQ[16]/DDR0_DQ[32])
DDR_A_D17: JDIMM1.41(DQ17) UC1.AW65(DDR0_DQ[17]/DDR0_DQ[33])
DDR_A_D18: JDIMM1.51(DQ18) UC1.AW63(DDR0_DQ[18]/DDR0_DQ[34])
DDR_A_D19: JDIMM1.53(DQ19) UC1.AY63(DDR0_DQ[19]/DDR0_DQ[35])
DDR_A_D20: JDIMM1.40(DQ20) UC1.BA65(DDR0_DQ[20]/DDR0_DQ[36])
DDR_A_D21: JDIMM1.42(DQ21) UC1.AY65(DDR0_DQ[21]/DDR0_DQ[37])
DDR_A_D22: JDIMM1.50(DQ22) UC1.BA63(DDR0_DQ[22]/DDR0_DQ[38])
DDR_A_D23: JDIMM1.52(DQ23) UC1.BB63(DDR0_DQ[23]/DDR0_DQ[39])
DDR_A_D24: JDIMM1.57(DQ24) UC1.BA61(DDR0_DQ[24]/DDR0_DQ[40])
DDR_A_D25: JDIMM1.59(DQ25) UC1.AW61(DDR0_DQ[25]/DDR0_DQ[41])
DDR_A_D26: JDIMM1.67(DQ26) UC1.BB59(DDR0_DQ[26]/DDR0_DQ[42])
DDR_A_D27: JDIMM1.69(DQ27) UC1.AW59(DDR0_DQ[27]/DDR0_DQ[43])
DDR_A_D28: JDIMM1.56(DQ28) UC1.BB61(DDR0_DQ[28]/DDR0_DQ[44])
DDR_A_D29: JDIMM1.58(DQ29) UC1.AY61(DDR0_DQ[29]/DDR0_DQ[45])
DDR_A_D30: JDIMM1.68(DQ30) UC1.BA59(DDR0_DQ[30]/DDR0_DQ[46])
DDR_A_D31: JDIMM1.70(DQ31) UC1.AY59(DDR0_DQ[31]/DDR0_DQ[47])
DDR_A_D32: JDIMM1.129(DQ32) UC1.AY39(DDR0_DQ[32]/DDR1_DQ[0])
DDR_A_D33: JDIMM1.131(DQ33) UC1.AW39(DDR0_DQ[33]/DDR1_DQ[1])
DDR_A_D34: JDIMM1.141(DQ34) UC1.AY37(DDR0_DQ[34]/DDR1_DQ[2])
DDR_A_D35: JDIMM1.143(DQ35) UC1.AW37(DDR0_DQ[35]/DDR1_DQ[3])
DDR_A_D36: JDIMM1.130(DQ36) UC1.BB39(DDR0_DQ[36]/DDR1_DQ[4])
DDR_A_D37: JDIMM1.132(DQ37) UC1.BA39(DDR0_DQ[37]/DDR1_DQ[5])
DDR_A_D38: JDIMM1.140(DQ38) UC1.BA37(DDR0_DQ[38]/DDR1_DQ[6])
DDR_A_D39: JDIMM1.142(DQ39) UC1.BB37(DDR0_DQ[39]/DDR1_DQ[7])
DDR_A_D40: JDIMM1.147(DQ40) UC1.AY35(DDR0_DQ[40]/DDR1_DQ[8])
DDR_A_D41: JDIMM1.149(DQ41) UC1.AW35(DDR0_DQ[41]/DDR1_DQ[9])
DDR_A_D42: JDIMM1.157(DQ42) UC1.AY33(DDR0_DQ[42]/DDR1_DQ[10])
DDR_A_D43: JDIMM1.159(DQ43) UC1.AW33(DDR0_DQ[43]/DDR1_DQ[11])
DDR_A_D44: JDIMM1.146(DQ44) UC1.BB35(DDR0_DQ[44]/DDR1_DQ[12])
DDR_A_D45: JDIMM1.148(DQ45) UC1.BA35(DDR0_DQ[45]/DDR1_DQ[13])
DDR_A_D46: JDIMM1.158(DQ46) UC1.BA33(DDR0_DQ[46]/DDR1_DQ[14])
DDR_A_D47: JDIMM1.160(DQ47) UC1.BB33(DDR0_DQ[47]/DDR1_DQ[15])
DDR_A_D48: JDIMM1.163(DQ48) UC1.AY31(DDR0_DQ[48]/DDR1_DQ[32])
DDR_A_D49: JDIMM1.165(DQ49) UC1.AW31(DDR0_DQ[49]/DDR1_DQ[33])
DDR_A_D50: JDIMM1.175(DQ50) UC1.AY29(DDR0_DQ[50]/DDR1_DQ[34])
DDR_A_D51: JDIMM1.177(DQ51) UC1.AW29(DDR0_DQ[51]/DDR1_DQ[35])
DDR_A_D52: JDIMM1.164(DQ52) UC1.BB31(DDR0_DQ[52]/DDR1_DQ[36])
DDR_A_D53: JDIMM1.166(DQ53) UC1.BA31(DDR0_DQ[53]/DDR1_DQ[37])
DDR_A_D54: JDIMM1.174(DQ54) UC1.BA29(DDR0_DQ[54]/DDR1_DQ[38])
DDR_A_D55: JDIMM1.176(DQ55) UC1.BB29(DDR0_DQ[55]/DDR1_DQ[39])
DDR_A_D56: JDIMM1.181(DQ56) UC1.AY27(DDR0_DQ[56]/DDR1_DQ[40])
DDR_A_D57: JDIMM1.183(DQ57) UC1.AW27(DDR0_DQ[57]/DDR1_DQ[41])
DDR_A_D58: JDIMM1.191(DQ58) UC1.AY25(DDR0_DQ[58]/DDR1_DQ[42])
DDR_A_D59: JDIMM1.193(DQ59) UC1.AW25(DDR0_DQ[59]/DDR1_DQ[43])
DDR_A_D60: JDIMM1.180(DQ60) UC1.BB27(DDR0_DQ[60]/DDR1_DQ[44])
DDR_A_D61: JDIMM1.182(DQ61) UC1.BA27(DDR0_DQ[61]/DDR1_DQ[45])
DDR_A_D62: JDIMM1.192(DQ62) UC1.BA25(DDR0_DQ[62]/DDR1_DQ[46])
DDR_A_D63: JDIMM1.194(DQ63) UC1.BB25(DDR0_DQ[63]/DDR1_DQ[47])
DDR_A_DQS0: JDIMM1.12(DQS0) UC1.AM69(DDR0_DQSP[0])
DDR_A_DQS1: JDIMM1.29(DQS1) UC1.AT70(DDR0_DQSP[1])
DDR_A_DQS2: JDIMM1.47(DQS2) UC1.AY64(DDR0_DQSP[2]/DDR0_DQSP[4])
DDR_A_DQS3: JDIMM1.64(DQS3) UC1.BA60(DDR0_DQSP[3]/DDR0_DQSP[5])
DDR_A_DQS4: JDIMM1.137(DQS4) UC1.AY38(DDR0_DQSP[4]/DDR1_DQSP[0])
DDR_A_DQS5: JDIMM1.154(DQS5) UC1.BA34(DDR0_DQSP[5]/DDR1_DQSP[1])
DDR_A_DQS6: JDIMM1.171(DQS6) UC1.AY30(DDR0_DQSP[6]/DDR1_DQSP[4])
DDR_A_DQS7: JDIMM1.188(DQS7) UC1.BA26(DDR0_DQSP[7]/DDR1_DQSP[5])
DDR_A_DQS#0: JDIMM1.10(DQS#0) UC1.AM70(DDR0_DQSN[0])
DDR_A_DQS#1: JDIMM1.27(DQS#1) UC1.AT69(DDR0_DQSN[1])
DDR_A_DQS#2: JDIMM1.45(DQS#2) UC1.BA64(DDR0_DQSN[2]/DDR0_DQSN[4])
DDR_A_DQS#3: JDIMM1.62(DQS#3) UC1.AY60(DDR0_DQSN[3]/DDR0_DQSN[5])
DDR_A_DQS#4: JDIMM1.135(DQS#4) UC1.BA38(DDR0_DQSN[4]/DDR1_DQSN[0])
DDR_A_DQS#5: JDIMM1.152(DQS#5) UC1.AY34(DDR0_DQSN[5]/DDR1_DQSN[1])
DDR_A_DQS#6: JDIMM1.169(DQS#6) UC1.BA30(DDR0_DQSN[6]/DDR1_DQSN[4])
DDR_A_DQS#7: JDIMM1.186(DQS#7) UC1.AY26(DDR0_DQSN[7]/DDR1_DQSN[5])
DDR_A_MA0: JDIMM1.98(A0) UC1.AY50(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
DDR_A_MA1: JDIMM1.97(A1) UC1.BB50(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
DDR_A_MA2: JDIMM1.96(A2) UC1.AY51(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
DDR_A_MA3: JDIMM1.95(A3) UC1.BA50(DDR0_MA[3])
DDR_A_MA4: JDIMM1.92(A4) UC1.BB52(DDR0_MA[4])
DDR_A_MA5: JDIMM1.91(A5) UC1.BA51(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
DDR_A_MA6: JDIMM1.90(A6) UC1.BA52(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
DDR_A_MA7: JDIMM1.86(A7) UC1.AW52(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
DDR_A_MA8: JDIMM1.89(A8) UC1.AY52(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
DDR_A_MA9: JDIMM1.85(A9) UC1.BB54(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
DDR_A_MA10: JDIMM1.107(A10/AP) UC1.AT50(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
DDR_A_MA11: JDIMM1.84(A11) UC1.BA54(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
DDR_A_MA12: JDIMM1.83(A12/BC#) UC1.AW54(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
DDR_A_MA13: JDIMM1.119(A13) UC1.AU46(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
DDR_A_MA14: JDIMM1.80(A14) UC1.AY54(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
DDR_A_MA15: JDIMM1.78(A15) UC1.BA55(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
DDR_A_RAS#: JDIMM1.110(RAS#) UC1.AU50(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
DDR_A_WE#: JDIMM1.113(WE#) UC1.AT46(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
DDR_B_BS0: JDIMM2.109(BA0) UC1.BB44(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
DDR_B_BS1: JDIMM2.108(BA1) UC1.BA44(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
DDR_B_BS2: JDIMM2.79(BA2) UC1.AP52(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
DDR_B_CAS#: JDIMM2.115(CAS#) UC1.AY43(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
DDR_B_D0: JDIMM2.5(DQ0) UC1.AF70(DDR1_DQ[8]/DDR0_DQ[24])
DDR_B_D1: JDIMM2.7(DQ1) UC1.AF68(DDR1_DQ[9]/DDR0_DQ[25])
DDR_B_D2: JDIMM2.15(DQ2) UC1.AH71(DDR1_DQ[10]/DDR0_DQ[26])
DDR_B_D3: JDIMM2.17(DQ3) UC1.AH68(DDR1_DQ[11]/DDR0_DQ[27])
DDR_B_D4: JDIMM2.4(DQ4) UC1.AF69(DDR1_DQ[13]/DDR0_DQ[29])
DDR_B_D5: JDIMM2.6(DQ5) UC1.AF71(DDR1_DQ[12]/DDR0_DQ[28])
DDR_B_D6: JDIMM2.16(DQ6) UC1.AH69(DDR1_DQ[15]/DDR0_DQ[31])
DDR_B_D7: JDIMM2.18(DQ7) UC1.AH70(DDR1_DQ[14]/DDR0_DQ[30])
DDR_B_D8: JDIMM2.21(DQ8) UC1.AF67(DDR1_DQ[5]/DDR0_DQ[21])
DDR_B_D9: JDIMM2.23(DQ9) UC1.AF64(DDR1_DQ[1]/DDR0_DQ[17])
DDR_B_D10: JDIMM2.33(DQ10) UC1.AK66(DDR1_DQ[7]/DDR0_DQ[23])
DDR_B_D11: JDIMM2.35(DQ11) UC1.AK65(DDR1_DQ[2]/DDR0_DQ[18])
DDR_B_D12: JDIMM2.22(DQ12) UC1.AF66(DDR1_DQ[4]/DDR0_DQ[20])
DDR_B_D13: JDIMM2.24(DQ13) UC1.AF65(DDR1_DQ[0]/DDR0_DQ[16])
DDR_B_D14: JDIMM2.34(DQ14) UC1.AK64(DDR1_DQ[3]/DDR0_DQ[19])
DDR_B_D15: JDIMM2.36(DQ15) UC1.AK67(DDR1_DQ[6]/DDR0_DQ[22])
DDR_B_D16: JDIMM2.57(DQ24) UC1.AT61(DDR1_DQ[24]/DDR0_DQ[56])
DDR_B_D17: JDIMM2.59(DQ25) UC1.AU61(DDR1_DQ[25]/DDR0_DQ[57])
DDR_B_D18: JDIMM2.67(DQ26) UC1.AP60(DDR1_DQ[26]/DDR0_DQ[58])
DDR_B_D19: JDIMM2.69(DQ27) UC1.AN60(DDR1_DQ[27]/DDR0_DQ[59])
DDR_B_D20: JDIMM2.56(DQ28) UC1.AP61(DDR1_DQ[29]/DDR0_DQ[61])
DDR_B_D21: JDIMM2.58(DQ29) UC1.AN61(DDR1_DQ[28]/DDR0_DQ[60])
DDR_B_D22: JDIMM2.68(DQ30) UC1.AT60(DDR1_DQ[30]/DDR0_DQ[62])
DDR_B_D23: JDIMM2.70(DQ31) UC1.AU60(DDR1_DQ[31]/DDR0_DQ[63])
DDR_B_D24: JDIMM2.39(DQ16) UC1.AT66(DDR1_DQ[16]/DDR0_DQ[48])
DDR_B_D25: JDIMM2.41(DQ17) UC1.AU66(DDR1_DQ[17]/DDR0_DQ[49])
DDR_B_D26: JDIMM2.51(DQ18) UC1.AP65(DDR1_DQ[18]/DDR0_DQ[50])
DDR_B_D27: JDIMM2.53(DQ19) UC1.AN65(DDR1_DQ[19]/DDR0_DQ[51])
DDR_B_D28: JDIMM2.40(DQ20) UC1.AP66(DDR1_DQ[21]/DDR0_DQ[53])
DDR_B_D29: JDIMM2.42(DQ21) UC1.AN66(DDR1_DQ[20]/DDR0_DQ[52])
DDR_B_D30: JDIMM2.50(DQ22) UC1.AT65(DDR1_DQ[22]/DDR0_DQ[54])
DDR_B_D31: JDIMM2.52(DQ23) UC1.AU65(DDR1_DQ[23]/DDR0_DQ[55])
DDR_B_D32: JDIMM2.129(DQ32) UC1.AU40(DDR1_DQ[32]/DDR1_DQ[16])
DDR_B_D33: JDIMM2.131(DQ33) UC1.AT40(DDR1_DQ[33]/DDR1_DQ[17])
DDR_B_D34: JDIMM2.141(DQ34) UC1.AT37(DDR1_DQ[34]/DDR1_DQ[18])
DDR_B_D35: JDIMM2.143(DQ35) UC1.AU37(DDR1_DQ[35]/DDR1_DQ[19])
DDR_B_D36: JDIMM2.130(DQ36) UC1.AR40(DDR1_DQ[36]/DDR1_DQ[20])
DDR_B_D37: JDIMM2.132(DQ37) UC1.AP40(DDR1_DQ[37]/DDR1_DQ[21])
DDR_B_D38: JDIMM2.140(DQ38) UC1.AP37(DDR1_DQ[38]/DDR1_DQ[22])
DDR_B_D39: JDIMM2.142(DQ39) UC1.AR37(DDR1_DQ[39]/DDR1_DQ[23])
DDR_B_D40: JDIMM2.147(DQ40) UC1.AT33(DDR1_DQ[40]/DDR1_DQ[24])
DDR_B_D41: JDIMM2.149(DQ41) UC1.AU33(DDR1_DQ[41]/DDR1_DQ[25])
DDR_B_D42: JDIMM2.157(DQ42) UC1.AU30(DDR1_DQ[42]/DDR1_DQ[26])
DDR_B_D43: JDIMM2.159(DQ43) UC1.AT30(DDR1_DQ[43]/DDR1_DQ[27])
DDR_B_D44: JDIMM2.146(DQ44) UC1.AR33(DDR1_DQ[44]/DDR1_DQ[28])
DDR_B_D45: JDIMM2.148(DQ45) UC1.AP33(DDR1_DQ[45]/DDR1_DQ[29])
DDR_B_D46: JDIMM2.158(DQ46) UC1.AR30(DDR1_DQ[46]/DDR1_DQ[30])
DDR_B_D47: JDIMM2.160(DQ47) UC1.AP30(DDR1_DQ[47]/DDR1_DQ[31])
DDR_B_D48: JDIMM2.163(DQ48) UC1.AU27(DDR1_DQ[48])
DDR_B_D49: JDIMM2.165(DQ49) UC1.AT27(DDR1_DQ[49])
DDR_B_D50: JDIMM2.175(DQ50) UC1.AT25(DDR1_DQ[50])
DDR_B_D51: JDIMM2.177(DQ51) UC1.AU25(DDR1_DQ[51])
DDR_B_D52: JDIMM2.164(DQ52) UC1.AP27(DDR1_DQ[52])
DDR_B_D53: JDIMM2.166(DQ53) UC1.AN27(DDR1_DQ[53])
DDR_B_D54: JDIMM2.174(DQ54) UC1.AN25(DDR1_DQ[54])
DDR_B_D55: JDIMM2.176(DQ55) UC1.AP25(DDR1_DQ[55])
DDR_B_D56: JDIMM2.181(DQ56) UC1.AT22(DDR1_DQ[56])
DDR_B_D57: JDIMM2.183(DQ57) UC1.AU22(DDR1_DQ[57])
DDR_B_D58: JDIMM2.191(DQ58) UC1.AU21(DDR1_DQ[58])
DDR_B_D59: JDIMM2.193(DQ59) UC1.AT21(DDR1_DQ[59])
DDR_B_D60: JDIMM2.180(DQ60) UC1.AN22(DDR1_DQ[60])
DDR_B_D61: JDIMM2.182(DQ61) UC1.AP22(DDR1_DQ[61])
DDR_B_D62: JDIMM2.192(DQ62) UC1.AP21(DDR1_DQ[62])
DDR_B_D63: JDIMM2.194(DQ63) UC1.AN21(DDR1_DQ[63])
DDR_B_DQS0: JDIMM2.12(DQS0) UC1.AG70(DDR1_DQSP[1]/DDR0_DQSP[3])
DDR_B_DQS1: JDIMM2.29(DQS1) UC1.AH65(DDR1_DQSP[0]/DDR0_DQSP[2])
DDR_B_DQS2: JDIMM2.64(DQS3) UC1.AR60(DDR1_DQSP[3]/DDR0_DQSP[7])
DDR_B_DQS3: JDIMM2.47(DQS2) UC1.AR65(DDR1_DQSP[2]/DDR0_DQSP[6])
DDR_B_DQS4: JDIMM2.137(DQS4) UC1.AR38(DDR1_DQSP[4]/DDR1_DQSP[2])
DDR_B_DQS5: JDIMM2.154(DQS5) UC1.AR32(DDR1_DQSP[5]/DDR1_DQSP[3])
DDR_B_DQS6: JDIMM2.171(DQS6) UC1.AR27(DDR1_DQSP[6])
DDR_B_DQS7: JDIMM2.188(DQS7) UC1.AR21(DDR1_DQSP[7])
DDR_B_DQS#0: JDIMM2.10(DQS0#) UC1.AG69(DDR1_DQSN[1]/DDR0_DQSN[3])
DDR_B_DQS#1: JDIMM2.27(DQS1#) UC1.AH66(DDR1_DQSN[0]/DDR0_DQSN[2])
DDR_B_DQS#2: JDIMM2.62(DQS3#) UC1.AR61(DDR1_DQSN[3]/DDR0_DQSN[7])
DDR_B_DQS#3: JDIMM2.45(DQS2#) UC1.AR66(DDR1_DQSN[2]/DDR0_DQSN[6])
DDR_B_DQS#4: JDIMM2.135(DQS4#) UC1.AT38(DDR1_DQSN[4]/DDR1_DQSN[2])
DDR_B_DQS#5: JDIMM2.152(DQS5#) UC1.AT32(DDR1_DQSN[5]/DDR1_DQSN[3])
DDR_B_DQS#6: JDIMM2.169(DQS6#) UC1.AR25(DDR1_DQSN[6])
DDR_B_DQS#7: JDIMM2.186(DQS7#) UC1.AR22(DDR1_DQSN[7])
DDR_B_MA0: JDIMM2.98(A0) UC1.BA46(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
DDR_B_MA1: JDIMM2.97(A1) UC1.AY46(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
DDR_B_MA2: JDIMM2.96(A2) UC1.AY47(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
DDR_B_MA3: JDIMM2.95(A3) UC1.BB46(DDR1_MA[3])
DDR_B_MA4: JDIMM2.92(A4) UC1.BA47(DDR1_MA[4])
DDR_B_MA5: JDIMM2.91(A5) UC1.AY48(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
DDR_B_MA6: JDIMM2.90(A6) UC1.BA48(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
DDR_B_MA7: JDIMM2.86(A7) UC1.AP48(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
DDR_B_MA8: JDIMM2.89(A8) UC1.BB48(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
DDR_B_MA9: JDIMM2.85(A9) UC1.AP50(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
DDR_B_MA10: JDIMM2.107(A10/AP) UC1.AW46(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
DDR_B_MA11: JDIMM2.84(A11) UC1.AN48(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
DDR_B_MA12: JDIMM2.83(A12/BC#) UC1.AN50(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
DDR_B_MA13: JDIMM2.119(A13) UC1.BA43(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
DDR_B_MA14: JDIMM2.80(A14) UC1.AN52(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
DDR_B_MA15: JDIMM2.78(A15) UC1.AN53(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
DDR_B_RAS#: JDIMM2.110(RAS#) UC1.AW44(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
DDR_B_WE#: JDIMM2.113(WE#) UC1.AY44(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
DDR_PG_CTRL: QD1.3(EMITTER) RD24.1 UC1.AW67(DDR_VTT_CNTL)
DDRA_CKE0_DIMMA: JDIMM1.73(CKE0) UC1.BA56(DDR0_CKE[0])
DDRA_CKE1_DIMMA: JDIMM1.74(CKE1) UC1.BB56(DDR0_CKE[1])
DDRA_CS0_DIMMA#: JDIMM1.114(S0#) UC1.AU45(DDR0_CS#[0])
DDRA_CS1_DIMMA#: JDIMM1.121(S1#) UC1.AU43(DDR0_CS#[1])
DDRA_ODT0_DIMMA#: JDIMM1.116(ODT0) UC1.AT45(DDR0_ODT[0])
DDRA_ODT1_DIMMA#: JDIMM1.120(ODT1) UC1.AT43(DDR0_ODT[1])
DDRB_CKE0_DIMMB: JDIMM2.73(CKE0) UC1.AN56(DDR1_CKE[0])
DDRB_CKE1_DIMMB: JDIMM2.74(CKE1) UC1.AP55(DDR1_CKE[1])
DDRB_CS0_DIMMB#: JDIMM2.114(S0#) UC1.BB42(DDR1_CS#[0])
DDRB_CS1_DIMMB#: JDIMM2.121(S1#) UC1.AY42(DDR1_CS#[1])
DDRB_ODT0_DIMMB#: JDIMM2.116(ODT0) UC1.BA42(DDR1_ODT[0])
DDRB_ODT1_DIMMB#: JDIMM2.120(ODT1) UC1.AW42(DDR1_ODT[1])
DGPU_HOLD_RST#: RPC26.2(R2) UC1.U9(GPP_C19/I2C1_SCL) UV4.2(IN2)
DGPU_PWREN#: QV8.3(D2) RV134.2 RV135.1 RV139.1 RV142.1
DGPU_PWROK: PR605.1 RC67.2 RC71.1 RC384.1 RC389.2 UV11.3(ON)
DGPU_PWROK_R: RC384.2 RC408.2 UC1.BB11(GPP_A7/PIRQA#)
DH_1.35V: PQ301.4(G) PU301.17(UGATE)
DH_CHG: PQ106.4(G) PU101.26(HIDRV)
DIFFCLK_BIASREF: RC362.1 UC1.E42(XCLK_BIASREF)
DISCRETE_PRESENCE: RC29.2 RC32.2 UC1.AR10(GPP_B5/SRCCLKREQ0#)
DISP_A0N_L_C: CM15.2 CM16.2 D18.2(IN2) D18.8(OUT3) JLINK.5(ML_LANE0_N)
DISP_A0P_L_C: CM13.2 CM14.2 D18.1(IN1) D18.9(OUT4) JLINK.3(ML_LANE0_P)
DISP_A1N_L_C: CM19.2 CM20.2 D18.5(IN4) D18.6(OUT1) JLINK.11(ML_LANE1_N)
DISP_A1P_L_C: CM17.2 CM18.2 D18.4(IN3) D18.7(OUT2) JLINK.9(ML_LANE1_P)
DL_1.35V: PQ302.4(G) PU301.15(LGATE)
DL_CHG: PQ107.4(G) PU101.23(LODRV)
DMIC_CLK: CA40.1 JLCD.15 RA7.1
DMIC_DATA: CA43.1 JLCD.14 UA1.1(DMIC_DAT/GPIO1)
DOCK_AUXN: CM6.1 RM15.1 UC1.G50(DDI1_AUXN)
DOCK_AUXN_CONN: CM7.2 D16.2(IN2) D16.8(OUT3) JLINK.17(AUX_CH_N) R106.2 RM16.2
DOCK_AUXN_R: CM7.1 RM15.2
DOCK_AUXN_RE: CM6.2 UM1.29(AUX_SRCN)
DOCK_AUXP: CM5.1 RM13.1 UC1.F50(DDI1_AUXP)
DOCK_AUXP_CONN: CM8.2 D16.1(IN1) D16.9(OUT4) JLINK.15(AUX_CH_P) R107.2 RM17.2
DOCK_AUXP_R: CM8.1 RM13.2
DOCK_AUXP_RE: CM5.2 UM1.30(AUX_SRCP)
DOCK_CAL: RM18.1 UM1.10(CAD_SNK)
DOCK_CONSUMP: JLINK.21(DOCK_CONSUMP) PR108.2
DOCK_HPD_CONN: D16.5(IN4) D16.6(OUT1) JLINK.23(HOT_PLUG_DET) Q4.1(D) R83.1 UM1.11(HPD_SNK)
DOCK_ID: JLINK.27(DETECT) PC2.1 PC3.1 PQ4.1(S1) PR6.1 PR7.1
DOCK_TX0+: CM1.1 RM2.1 UC1.F55(DDI1_TXP[0])
DOCK_TX0+_R: CM14.1 RM2.2
DOCK_TX0+_RE: CM1.2 UM1.38(IN0P)
DOCK_TX0-: CM2.1 RM5.1 UC1.E55(DDI1_TXN[0])
DOCK_TX0-_R: CM16.1 RM5.2
DOCK_TX0-_RE: CM2.2 UM1.39(IN0N)
DOCK_TX1+: CM3.1 RM8.1 UC1.F58(DDI1_TXP[1])
DOCK_TX1+_R: CM18.1 RM8.2
DOCK_TX1+_RE: CM3.2 UM1.41(IN1P)
DOCK_TX1-: CM4.1 RM11.1 UC1.E58(DDI1_TXN[1])
DOCK_TX1-_R: CM20.1 RM11.2
DOCK_TX1-_RE: CM4.2 UM1.42(IN1N)
DOCKDP_HPD: Q4.3(S) UC1.L9(GPP_E13/DDPB_HPD0) UM1.9(HPD_SRC)
DP1201_OC: RM32.2 RM33.1 UM1.46(OC_0)
DP_DDC_CLK: RC1.2 UC1.L13(GPP_E18/DDPB_CTRLCLK)
DP_DDC_DAT: RC2.2 UC1.L12(GPP_E19/DDPB_CTRLDATA)
DP_RE_AUXN: RM16.1 UM1.27(AUX_SNKN)
DP_RE_AUXP: RM17.1 UM1.28(AUX_SNKP)
DP_RE_DP0N: CM15.1 UM1.22(OUT0N)
DP_RE_DP0P: CM13.1 UM1.23(OUT0P)
DP_RE_DP1N: CM19.1 UM1.19(OUT1N)
DP_RE_DP1P: CM17.1 UM1.20(OUT1P)
DRVON: PU401.35(DRVON) PU402.3(EN) PU403.3(EN) PU404.3(EN)
EC_AGND: CE2.2 CE3.2 LE2.1 UE1.75(AVSS)
EC_DPWROK: RC286.1 RC353.2 UE1.96(GPH3/ID3)
EC_DPWROK_R: CC529.2 RC286.2 RC352.2 UC1.BB20(DSW_PWROK)
EC_FAN_PWM: JFAN.5 RE8.1 UE1.31(PWM5/GPA5)
EC_FAN_SPEED: JFAN.3 RPE3.7(R7) UE1.47(TACH0A/GPD6)
EC_GS_ON#: RG4.1 UE1.106(SSCE1#/GPG0)
EC_MUTE#: DA5.1 RE31.1 RE32.1 UE1.100(SSCE0#/GPG2)
EC_ON: PR206.1 RE39.1 UE1.83(EGCS#/GPE2)
EC_ON2: PD801.1 PR701.1 PR801.1 RE40.1
EC_ON2_R: RE40.2 UE1.28(PWM2/GPA2)
EC_RSMRST#: RC27.2 RC352.1 UC1.AY17(RSMRST#) UE1.93(CLKRUN#/GPH0/ID0)
EC_RX: R90.2 UE1.16(PWUREQ#/BBO/SMCLK2ALT/GPC7)
EC_SCI#: RPC22.2(R2) UC1.M1(GPP_D0/SPI1_CS#) UE1.23(ECSCI#/GPD3)
EC_SMB_CK1: IT1.1 PR15.2 PR121.1 RPE5.8(R8) UE1.115(SMCLK1/GPC1)
EC_SMB_CK3: QC2.1(S1) QV2.6(D1) QV13.6(D1) RM29.1 RPE5.5(R5) U1.10(SMCLK) UE1.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
EC_SMB_DA1: IT2.1 PR14.2 PR120.1 RPE5.7(R7) UE1.116(SMDAT1/GPC2)
EC_SMB_DA3: QC2.4(S2) QV2.3(D2) QV13.3(D2) RM30.1 RPE5.6(R6) U1.9(SMDATA) UE1.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
EC_SMCA: JBATT1.5 PD7.3 PR15.1
EC_SMDA: JBATT1.4 PD7.2 PR14.1
EC_TX: R89.2 UE1.17(LPCPD#/GPE6)
EC_TX_R: JWLBT.64(RESERVED4) R89.1 R91.1 R151.2
EC_WAKE#: RC40.1 RPC26.3(R3) RV140.1 UE1.2(CK32KE/GPJ7)
EC_WAKE#_L: RC40.2 UC1.A6(GPP_E3/CPU_GP0)
EC_WLAN_WAKE#: JWLBT.55(PEWAKE0#) RPE1.5(R5) UE1.19(L80HLAT/BAO/GPE0)
EDP_COMP: RC344.2 UC1.E52(EDP_RCOMP)
EN_1.8VSP: PC803.1 PD801.2 PR801.2 PR802.2 PU801.5(EN)
ENBKL: RC209.1 UC1.R12(EDP_BKLTEN) UE1.81(DAC5/RIG0#/GPJ5)
EXT_MIC_A: RA14.1 UA1.30(PORTD_A_MIC)
EXT_MIC_B: RA15.1 UA1.31(PORTD_B_MIC)
EXT_PWR_GATE#: T61.1 UC1.AM10(GPP_B11/EXT_PWR_GATE#)
F1_LED#: JKB.27 RPC8.3(R3) UC1.AC2(GPP_C13/UART1_TXD/ISH_UART1_TXD)
F4_LED#: JKB.28 RPC8.2(R2) UC1.AD3(GPP_C22/UART2_RTS#)
FAN_ID: JFAN.1 RPE2.6(R6) UE1.70(ADC4/GPI4)
FB_1.35V: PC314.2 PR305.2 PR307.1 PU301.6(FB)
FBA_BA0: UV3.J16(MAA1_6) UV5.M2(BA0) UV6.M2(BA0) UV7.M2(BA0) UV8.M2(BA0)
FBA_BA1: UV3.L15(MAA1_7) UV5.N8(BA1) UV6.N8(BA1) UV7.N8(BA1) UV8.N8(BA1)
FBA_BA2: UV3.G11(MAA1_5) UV5.M3(BA2) UV6.M3(BA2) UV7.M3(BA2) UV8.M3(BA2)
FBA_CASA0#: UV3.G19(CASA0B) UV5.K3(C\A\S\) UV6.K3(C\A\S\)
FBA_CASA1#: UV3.G16(CASA1B) UV7.K3(C\A\S\) UV8.K3(C\A\S\)
FBA_CKEA0: UV3.K20(CKEA0) UV5.K9(CKE) UV6.K9(CKE)
FBA_CKEA1: UV3.J17(CKEA1) UV7.K9(CKE) UV8.K9(CKE)
FBA_CLKA0: RV26.1 UV3.H26(CLKA0) UV5.J7(CK) UV6.J7(CK)
FBA_CLKA0#: RV27.2 UV3.H25(CLKA0B) UV5.K7(C\K\) UV6.K7(C\K\)
FBA_CLKA1: RV38.1 UV3.G9(CLKA1) UV7.J7(CK) UV8.J7(CK)
FBA_CLKA1#: RV39.2 UV3.H9(CLKA1B) UV7.K7(C\K\) UV8.K7(C\K\)
FBA_CSA0#: UV3.H22(CSA0B_0) UV5.L2(C\S\) UV6.L2(C\S\)
FBA_CSA1#: UV3.G13(CSA1B_0) UV7.L2(C\S\) UV8.L2(C\S\)
FBA_D0: UV3.K27(DQA0_0) UV5.F2(DQL2)
FBA_D1: UV3.J29(DQA0_1) UV5.H3(DQL4)
FBA_D2: UV3.H30(DQA0_2) UV5.E3(DQL0)
FBA_D3: UV3.H32(DQA0_3) UV5.G2(DQL6)
FBA_D4: UV3.G29(DQA0_4) UV5.F8(DQL3)
FBA_D5: UV3.F28(DQA0_5) UV5.F7(DQL1)
FBA_D6: UV3.F32(DQA0_6) UV5.H8(DQL5)
FBA_D7: UV3.F30(DQA0_7) UV5.H7(DQL7)
FBA_D8: UV3.C30(DQA0_8) UV6.A7(DQU4)
FBA_D9: UV3.F27(DQA0_9) UV6.D7(DQU0)
FBA_D10: UV3.A28(DQA0_10) UV6.C3(DQU1)
FBA_D11: UV3.C28(DQA0_11) UV6.A3(DQU7)
FBA_D12: UV3.E27(DQA0_12) UV6.C2(DQU3)
FBA_D13: UV3.G26(DQA0_13) UV6.C8(DQU2)
FBA_D14: UV3.D26(DQA0_14) UV6.A2(DQU5)
FBA_D15: UV3.F25(DQA0_15) UV6.B8(DQU6)
FBA_D16: UV3.A25(DQA0_16) UV6.H3(DQL4)
FBA_D17: UV3.C25(DQA0_17) UV6.E3(DQL0)
FBA_D18: UV3.E25(DQA0_18) UV6.H8(DQL5)
FBA_D19: UV3.D24(DQA0_19) UV6.G2(DQL6)
FBA_D20: UV3.E23(DQA0_20) UV6.F7(DQL1)
FBA_D21: UV3.F23(DQA0_21) UV6.F8(DQL3)
FBA_D22: UV3.D22(DQA0_22) UV6.H7(DQL7)
FBA_D23: UV3.F21(DQA0_23) UV6.F2(DQL2)
FBA_D24: UV3.E21(DQA0_24) UV5.A2(DQU5)
FBA_D25: UV3.D20(DQA0_25) UV5.C2(DQU3)
FBA_D26: UV3.F19(DQA0_26) UV5.A3(DQU7)
FBA_D27: UV3.A19(DQA0_27) UV5.C3(DQU1)
FBA_D28: UV3.D18(DQA0_28) UV5.A7(DQU4)
FBA_D29: UV3.F17(DQA0_29) UV5.B8(DQU6)
FBA_D30: UV3.A17(DQA0_30) UV5.C8(DQU2)
FBA_D31: UV3.C17(DQA0_31) UV5.D7(DQU0)
FBA_D32: UV3.E17(DQA1_0) UV7.H8(DQL5)
FBA_D33: UV3.D16(DQA1_1) UV7.H7(DQL7)
FBA_D34: UV3.F15(DQA1_2) UV7.F7(DQL1)
FBA_D35: UV3.A15(DQA1_3) UV7.F8(DQL3)
FBA_D36: UV3.D14(DQA1_4) UV7.E3(DQL0)
FBA_D37: UV3.F13(DQA1_5) UV7.F2(DQL2)
FBA_D38: UV3.A13(DQA1_6) UV7.G2(DQL6)
FBA_D39: UV3.C13(DQA1_7) UV7.H3(DQL4)
FBA_D40: UV3.E11(DQA1_8) UV7.A3(DQU7)
FBA_D41: UV3.A11(DQA1_9) UV7.D7(DQU0)
FBA_D42: UV3.C11(DQA1_10) UV7.C8(DQU2)
FBA_D43: UV3.F11(DQA1_11) UV7.C2(DQU3)
FBA_D44: UV3.A9(DQA1_12) UV7.A7(DQU4)
FBA_D45: UV3.C9(DQA1_13) UV7.B8(DQU6)
FBA_D46: UV3.F9(DQA1_14) UV7.A2(DQU5)
FBA_D47: UV3.D8(DQA1_15) UV7.C3(DQU1)
FBA_D48: UV3.E7(DQA1_16) UV8.C2(DQU3)
FBA_D49: UV3.A7(DQA1_17) UV8.A3(DQU7)
FBA_D50: UV3.C7(DQA1_18) UV8.A2(DQU5)
FBA_D51: UV3.F7(DQA1_19) UV8.C3(DQU1)
FBA_D52: UV3.A5(DQA1_20) UV8.A7(DQU4)
FBA_D53: UV3.E5(DQA1_21) UV8.B8(DQU6)
FBA_D54: UV3.C3(DQA1_22) UV8.C8(DQU2)
FBA_D55: UV3.E1(DQA1_23) UV8.D7(DQU0)
FBA_D56: UV3.G7(DQA1_24) UV8.H3(DQL4)
FBA_D57: UV3.G6(DQA1_25) UV8.G2(DQL6)
FBA_D58: UV3.G1(DQA1_26) UV8.F7(DQL1)
FBA_D59: UV3.G3(DQA1_27) UV8.F8(DQL3)
FBA_D60: UV3.J6(DQA1_28) UV8.E3(DQL0)
FBA_D61: UV3.J1(DQA1_29) UV8.H7(DQL7)
FBA_D62: UV3.J3(DQA1_30) UV8.H8(DQL5)
FBA_D63: UV3.J5(DQA1_31) UV8.F2(DQL2)
FBA_DQM0: UV3.E32(WCKA0_0) UV5.E7(DML)
FBA_DQM1: UV3.E30(WCKA0B_0) UV6.D3(DMU)
FBA_DQM2: UV3.A21(WCKA0_1) UV6.E7(DML)
FBA_DQM3: UV3.C21(WCKA0B_1) UV5.D3(DMU)
FBA_DQM4: UV3.E13(WCKA1_0) UV7.E7(DML)
FBA_DQM5: UV3.D12(WCKA1B_0) UV7.D3(DMU)
FBA_DQM6: UV3.E3(WCKA1_1) UV8.D3(DMU)
FBA_DQM7: UV3.F4(WCKA1B_1) UV8.E7(DML)
FBA_DQS0: UV3.H28(EDCA0_0) UV5.F3(DQSL)
FBA_DQS1: UV3.C27(EDCA0_1) UV6.C7(DQSU)
FBA_DQS2: UV3.A23(EDCA0_2) UV6.F3(DQSL)
FBA_DQS3: UV3.E19(EDCA0_3) UV5.C7(DQSU)
FBA_DQS4: UV3.E15(EDCA1_0) UV7.F3(DQSL)
FBA_DQS5: UV3.D10(EDCA1_1) UV7.C7(DQSU)
FBA_DQS6: UV3.D6(EDCA1_2) UV8.C7(DQSU)
FBA_DQS7: UV3.G5(EDCA1_3) UV8.F3(DQSL)
FBA_DQS#0: UV3.H27(DDBIA0_0) UV5.G3(D\Q\S\L\)
FBA_DQS#1: UV3.A27(DDBIA0_1) UV6.B7(D\Q\S\U\)
FBA_DQS#2: UV3.C23(DDBIA0_2) UV6.G3(D\Q\S\L\)
FBA_DQS#3: UV3.C19(DDBIA0_3) UV5.B7(D\Q\S\U\)
FBA_DQS#4: UV3.C15(DDBIA1_0) UV7.G3(D\Q\S\L\)
FBA_DQS#5: UV3.E9(DDBIA1_1) UV7.B7(D\Q\S\U\)
FBA_DQS#6: UV3.C5(DDBIA1_2) UV8.B7(D\Q\S\U\)
FBA_DQS#7: UV3.H4(DDBIA1_3) UV8.G3(D\Q\S\L\)
FBA_MA0: UV3.K17(MAA0_0) UV5.N3(A0) UV6.N3(A0) UV7.N3(A0) UV8.N3(A0)
FBA_MA1: UV3.J20(MAA0_1) UV5.P7(A1) UV6.P7(A1) UV7.P7(A1) UV8.P7(A1)
FBA_MA2: UV3.H23(MAA0_2) UV5.P3(A2) UV6.P3(A2) UV7.P3(A2) UV8.P3(A2)
FBA_MA3: UV3.G23(MAA0_3) UV5.N2(A3) UV6.N2(A3) UV7.N2(A3) UV8.N2(A3)
FBA_MA4: UV3.G24(MAA0_4) UV5.P8(A4) UV6.P8(A4) UV7.P8(A4) UV8.P8(A4)
FBA_MA5: UV3.H24(MAA0_5) UV5.P2(A5) UV6.P2(A5) UV7.P2(A5) UV8.P2(A5)
FBA_MA6: UV3.J19(MAA0_6) UV5.R8(A6) UV6.R8(A6) UV7.R8(A6) UV8.R8(A6)
FBA_MA7: UV3.K19(MAA0_7) UV5.R2(A7) UV6.R2(A7) UV7.R2(A7) UV8.R2(A7)
FBA_MA8: UV3.J14(MAA1_0) UV5.T8(A8) UV6.T8(A8) UV7.T8(A8) UV8.T8(A8)
FBA_MA9: UV3.K14(MAA1_1) UV5.R3(A9) UV6.R3(A9) UV7.R3(A9) UV8.R3(A9)
FBA_MA10: UV3.J11(MAA1_2) UV5.L7(A10/AP) UV6.L7(A10/AP) UV7.L7(A10/AP) UV8.L7(A10/AP)
FBA_MA11: UV3.J13(MAA1_3) UV5.R7(A11) UV6.R7(A11) UV7.R7(A11) UV8.R7(A11)
FBA_MA12: UV3.H11(MAA1_4) UV5.N7(A12/B\C\) UV6.N7(A12/B\C\) UV7.N7(A12/B\C\) UV8.N7(A12/B\C\)
FBA_MA13: UV3.G20(MAA0_8) UV5.T3(A13) UV6.T3(A13) UV7.T3(A13) UV8.T3(A13)
FBA_MA14: UV3.G14(MAA1_8) UV5.T7(A14) UV6.T7(A14) UV7.T7(A14) UV8.T7(A14)
FBA_MA15: UV3.L17(MAA0_9) UV5.M7(NC5) UV6.M7(NC5) UV7.M7(NC5) UV8.M7(NC5)
FBA_ODTA0: UV3.L18(ADBIA0) UV5.K1(ODT) UV6.K1(ODT)
FBA_ODTA1: UV3.K16(ADBIA1) UV7.K1(ODT) UV8.K1(ODT)
FBA_RASA0#: UV3.G22(RASA0B) UV5.J3(R\A\S\) UV6.J3(R\A\S\)
FBA_RASA1#: UV3.G17(RASA1B) UV7.J3(R\A\S\) UV8.J3(R\A\S\)
FBA_RST#: RV9.1 RV15.1 UV5.T2(R\E\S\E\T\) UV6.T2(R\E\S\E\T\) UV7.T2(R\E\S\E\T\) UV8.T2(R\E\S\E\T\)
FBA_WEA0#: UV3.G25(WEA0B) UV5.L3(W\E\) UV6.L3(W\E\)
FBA_WEA1#: UV3.H10(WEA1B) UV7.L3(W\E\) UV8.L3(W\E\)
FDO: RV84.2 UV3.R5(GPIO28_FDO)
FN_LED#: JKB.26 RPC8.4(R4) UC1.AC1(GPP_C12/UART1_RXD/ISH_UART1_RXD)
FSCE#: RC311.1 UE1.101(NC1)
GPD7: RC351.2 UC1.AT15(GPD7/RSVD)
GPIO01: TP120.1 UTPM1.30(SCL/GPIO1)
GPIO03: TP121.1 UTPM1.6(GPIO3/BADD)
GPIO04: TP124.1 UTPM1.13(\\C\L\K\R\U\N\/GPIO04/\S\I\N\T\)
GPIO5_AC_BATT: DV2.2 RV111.2 RV113.2 UV3.T9(GPIO_5_AC_BATT)
GPIO6: CV142.1 RV62.2 UV3.T8(GPIO_6_TACH)
GPIO8_ROMSO: TPV3.1 UV3.P10(GPIO_8_ROMSO)
GPIO9_ROMSI: TPV4.1 UV3.P4(GPIO_9_ROMSI)
GPIO10_ROMSCK: TPV5.1 UV3.P2(GPIO_10_ROMSCK)
GPIO15: RV89.1 RV117.2 UV3.N1(GPIO_15_PWRCNTL_0)
GPIO19_CTF: RV74.2 RV86.1 UV3.M2(GPIO_19_CTF)
GPIO20: RV90.1 RV116.2 UV3.P8(GPIO_20_PWRCNTL_1)
GPIO22_ROMCSB: TPV6.1 UV3.N8(GPIO_22_ROMCSB)
GPP_B18: RC97.2 RC98.1 UC1.AR7(GPP_B18/GSPI0_MOSI)
GPP_B22: RC99.2 RC100.1 UC1.AN5(GPP_B22/GSPI1_MOSI)
GPP_B23: RC101.2 UC1.AM7(GPP_B23/SML1ALERT#/PCHHOT#)
GPP_C2: RC306.1 RC307.1 UC1.R10(GPP_C2/SMBALERT#)
GPP_C5: RC83.2 RC84.2 UC1.W1(GPP_C5/SML0ALERT#)
GPP_E0: RC388.2 UC1.H2(GPP_E0/SATAXPCIE0/SATAGP0)
GPU_VR_HOT#: PR610.1 RE9.1 RV113.1 RV114.1 UE1.66(ADC0/GPI0)
GREEN_LED: JRJ451.9(GREEN_LED+) RL16.2
GSENSE_INT: RG2.2 UGSEN1.11(INT1)
GSENSE_INT2: TG1.1 UGSEN1.9(INT2)
H_CPUPWRGD: T59.1 UC1.A68(PROCPWRGD)
H_HDMI_TX0+: CRE1.1 UC1.B50(DDI2_TXP[2])
H_HDMI_TX0-: CRE3.1 UC1.A50(DDI2_TXN[2])
H_HDMI_TX1+: CRE5.1 UC1.D52(DDI2_TXP[1])
H_HDMI_TX1-: CRE7.1 UC1.C52(DDI2_TXN[1])
H_HDMI_TX2+: CRE9.1 UC1.D50(DDI2_TXP[0])
H_HDMI_TX2-: CRE11.1 UC1.C50(DDI2_TXN[0])
H_HDMI_TXC+: CRE13.1 UC1.C51(DDI2_TXP[3])
H_HDMI_TXC-: CRE14.1 UC1.D51(DDI2_TXN[3])
H_PECI: RE1.1 UC1.A54(PECI)
H_PROCHOT_EC: QE1.2(G) UE1.80(DAC4/DCD0#/GPJ4)
H_THERMTRIP#: QV3.1(COLLECTOR) RC54.1
HDA_BCLK: RC364.1 RPC2.7(R7)
HDA_BCLK_R: RC364.2 UC1.AY22(HDA_BLK/I2S0_SCLK)
HDA_RST#: RPC2.8(R8) UC1.AW22(HDA_RST#/I2S1_SCLK)
HDA_SDOUT: RC21.2 RC299.1 RC302.1 RPC2.6(R6) UC1.BB22(HDA_SDO/I2S0_TXD)
HDA_SYNC: RC367.1 RPC2.5(R5) UC1.BA22(HDA_SYNC/I2S0_SFRM)
HDD_DETECT#: JHDD.12(GND5) RE15.2 UE1.15(ECSMI#/GPD4)
HDD_DEVSLP0: JHDD.10(VCC_3V3_3) RC88.2 UC1.J1(GPP_E4/DEVSLP0)
HDMI_CLK: RC277.2 UC1.N7(GPP_E20/DDPC_CTRLCLK) URE1.38(SCL_SRC)
HDMI_CLK_CON: D2.4(IN3) D2.7(OUT2) JHDMI.15(SCL) R4.2 URE1.32(SCL_SNK)
HDMI_DAT: RC287.2 UC1.N8(GPP_E21/DDPC_CTRLDATA) URE1.39(SDA_SRC)
HDMI_DAT_CON: D2.5(IN4) D2.6(OUT1) JHDMI.16(SDA) R5.2 URE1.33(SDA_SNK)
HDMI_HPD: UC1.L7(GPP_E14/DDPC_HPD1) URE1.3(HPD_SRC)
HDMI_HPD_CON: D2.2(IN2) D2.8(OUT3) JHDMI.19(HP_DET) URE1.28(HPD_SNK)
HDMI_TX0+_CON: D3.1(IN1) D3.9(OUT4) JHDMI.7(D0+) L1.2
HDMI_TX0+_REIN: CRE1.2 URE1.6(IN_D0P)
HDMI_TX0+_REOUT: L1.1 URE1.25(OUT_D0P)
HDMI_TX0-_CON: D3.2(IN2) D3.8(OUT3) JHDMI.9(D0-) L1.3
HDMI_TX0-_REIN: CRE3.2 URE1.7(IN_D0N)
HDMI_TX0-_REOUT: L1.4 URE1.24(OUT_D0N)
HDMI_TX1+_CON: D11.2(IN2) D11.8(OUT3) JHDMI.4(D1+) L2.2
HDMI_TX1+_REIN: CRE5.2 URE1.4(IN_D1P)
HDMI_TX1+_REOUT: L2.1 URE1.27(OUT_D1P)
HDMI_TX1-_CON: D11.1(IN1) D11.9(OUT4) JHDMI.6(D1-) L2.3
HDMI_TX1-_REIN: CRE7.2 URE1.5(IN_D1N)
HDMI_TX1-_REOUT: L2.4 URE1.26(OUT_D1N)
HDMI_TX2+_CON: D11.5(IN4) D11.6(OUT1) JHDMI.1(D2+) L3.2
HDMI_TX2+_REIN: CRE9.2 URE1.1(IN_D2P)
HDMI_TX2+_REOUT: L3.1 URE1.30(OUT_D2P)
HDMI_TX2-_CON: D11.4(IN3) D11.7(OUT2) JHDMI.3(D2-) L3.3
HDMI_TX2-_REIN: CRE11.2 URE1.2(IN_D2N)
HDMI_TX2-_REOUT: L3.4 URE1.29(OUT_D2N)
HDMI_TXC+_CON: D3.4(IN3) D3.7(OUT2) JHDMI.10(CK+) L4.2
HDMI_TXC+_REIN: CRE13.2 URE1.9(IN_CKP)
HDMI_TXC+_REOUT: L4.1 URE1.22(OUT_CKP)
HDMI_TXC-_CON: D3.5(IN4) D3.6(OUT1) JHDMI.12(CK-) L4.3
HDMI_TXC-_REIN: CRE14.2 URE1.10(IN_CKN)
HDMI_TXC-_REOUT: L4.4 URE1.21(OUT_CKN)
HG_1PH: PQ407.4(G) PU404.8(DRVH)
HG_A1: PQ401.4(G) PU402.8(DRVH)
HG_B1: PQ404.4(G) PU403.8(DRVH)
HGNDA: CA30.2 JU3AC.22 JU3AC.23 UA1.25(HGNDA)
HGNDB: CA29.2 JU3AC.20 JU3AC.21 UA1.26(HGNDB)
HP_OUTL: CA31.2 RA16.1 RA17.1 UA1.22(PORTA_L)
HP_OUTL_CON: JU3AC.26 RA17.2
HP_OUTR: CA32.2 RA22.1 RA23.1 UA1.23(PORTA_R)
HP_OUTR_CON: JU3AC.25 RA23.2
I2C_ADDR: RM27.1 RM28.2 UM1.3(OC_1/I2C_ADDR)
I2C_CLK_GSENSE: QV13.1(S1) UGSEN1.4(SCL/SPC)
I2C_DATA_GSENSE: QV13.4(S2) UGSEN1.6(SDA/SDI/SDO)
ISEN1: PC608.2 PR616.1 PU601.13(ISEN1)
ISEN2: PC628.2 PR632.1 PU601.12(ISEN2)
ITP_PMODE: RC354.1 UC1.E8(ITP_PMODE)
JSENSE: RA18.2 RA20.2 RA21.2 UA1.38(JSENSE)
JSENSE_CON: JU3AC.24 RA20.1 RA21.1
JTAG_TCK: RV67.1 TPV9.1 UV3.L3(JTAG_TCK)
JTAG_TDI: RV65.2 TPV8.1 UV3.L5(JTAG_TDI)
JTAG_TDO: RV66.2 TPV11.1 UV3.K4(JTAG_TDO)
JTAG_TMS: RV64.2 TPV10.1 UV3.L1(JTAG_TMS)
JTAG_TRSTB: RV63.2 TPV7.1 UV3.L6(JTAG_TRSTB)
KB_FN: JKB.29 RPE1.6(R6) UE1.20(L80LLAT/GPE7)
KBRST#: RPC22.4(R4) UC1.AW13(GPP_A0/RCIN#) UE1.4(KBRST#/GPB6)
KSI0: JKB.12 UE1.58(KSI0/STB#)
KSI1: JKB.1 UE1.59(KSI1/AFD#)
KSI2: JKB.8 UE1.60(KSI2/INIT#)
KSI3: JKB.9 UE1.61(KSI3/SLIN#)
KSI4: JKB.5 UE1.62(KSI4)
KSI5: JKB.6 UE1.63(KSI5)
KSI6: IT7.1 JKB.3 UE1.64(KSI6)
KSI7: IT6.1 JKB.2 UE1.65(KSI7)
KSO0: JKB.7 UE1.36(KSO0/PD0)
KSO1: JKB.11 RPE2.8(R8) UE1.37(KSO1/PD1)
KSO2: JKB.13 RPE2.7(R7) UE1.38(KSO2/PD2)
KSO3: JKB.18 UE1.39(KSO3/PD3)
KSO4: JKB.14 UE1.40(KSO4/PD4)
KSO5: JKB.10 UE1.41(KSO5/PD5)
KSO6: JKB.17 UE1.42(KSO6/PD6)
KSO7: JKB.15 UE1.43(KSO7/PD7)
KSO8: JKB.16 UE1.44(KSO8/ACK#)
KSO9: JKB.4 UE1.45(KSO9/BUSY)
KSO10: JKB.23 UE1.46(KSO10/PE)
KSO11: JKB.22 UE1.51(KSO11/ERR#)
KSO12: JKB.19 UE1.52(KSO12/SLCT)
KSO13: JKB.20 UE1.53(KSO13)
KSO14: JKB.21 UE1.54(KSO14)
KSO15: JKB.24 UE1.55(KSO15)
KSO16: JKB.31 UE1.56(KSO16/SMOSI/GPC3)
KSO17: JKB.32 UE1.57(KSO17/SMISO/GPC5)
LAN_PWRON: RL25.1 UE1.97(GPH4/ID4)
LAN_PWRON#: QL3.1(D) RL22.2 RL24.1
LAN_PWRON_R: QL3.2(G) RL23.1 RL25.2
LAN_WAKE#: RL18.1 RPE2.5(R5) UE1.125(GPE4)
LAN_WAKE#_R: RL18.2 RL26.2 UL1.2(LANWAKE_N)
LAN_XTALI: CL8.1 UL1.10(XTAL_IN) YL1.3
LAN_XTALO: CL7.1 UL1.9(XTAL_OUT) YL1.1
LANGND: CL10.2 CL11.1 CL12.1 DL3.1 DL4.1 DL5.1 DL6.1 JRJ451.13(G1) JRJ451.14(G2) JRJ451.15(G3) JRJ451.16(G4)
LANPHYPC: RL9.2 UC1.AW17(GPD11/LANPHYPC) UL1.3(LAN_DISABLE_N)
LG_1PH: PQ408.4(G) PU404.5(DRVL)
LG_A1: PQ402.4(G) PQ403.4(G) PU402.5(DRVL)
LG_B1: PQ405.4(G) PQ406.4(G) PU403.5(DRVL)
LID_SW#: D5.3 D22.1 RPE3.5(R5) U8.3(OUTPUT) UE1.109(LID_SW#)
LOGO_LED#: D1.2 JLCD.10 JLOGO.2 UE1.24(PWM0/GPA0)
LPC_AD0: UC1.AY13(GPP_A1/LAD0/ESPI_IO0) UE1.10(LAD0/GPM0)
LPC_AD1: UC1.BA13(GPP_A2/LAD1/ESPI_IO1) UE1.9(LAD1/GPM1)
LPC_AD2: UC1.BB13(GPP_A3/LAD2/ESPI_IO2) UE1.8(LAD2/GPM2)
LPC_AD3: UC1.AY12(GPP_A4/LAD3/ESPI_IO3) UE1.7(LAD3/GPM3)
LPC_FRAME#: RPE3.8(R8) UC1.BA12(GPP_A5/LFRAME#/ESPI_CS#) UE1.6(LFRAME#/GPM5)
LX_1.35V: PC310.1 PL301.2 PQ301.1(S1) PQ301.2(S2) PQ301.3(S3) PQ302.5(D) PR304.2 PU301.16(PHASE)
LX_CHG: PC118.1 PL102.1 PQ106.1(S1) PQ106.2(S2) PQ106.3(S3) PQ107.5(D) PR119.2 PU101.27(PHASE)
MAINPWON_EC: PD2.2 PQ201.5(G2) PR13.1 PR217.2 UE1.79(DAC3/TACH1B/GPJ3)
MCT1: DL3.2 RL10.2 TL1.22(TXCT1)
MCT2: DL4.2 RL11.2 TL1.21(TXCT2)
MCT3: DL5.2 RL12.2 TL1.16(TXCT3)
MCT4: DL6.2 RL13.2 TL1.15(TXCT4)
MDI_0+: DL1.1(IN1) DL1.9(OUT4) TL1.1(TD1+) UL1.13(MDI_PLUS[0])
MDI_0-: DL1.2(IN2) DL1.8(OUT3) TL1.2(TD1-) UL1.14(MDI_MINUS[0])
MDI_1+: DL1.4(IN3) DL1.7(OUT2) TL1.5(TD2+) UL1.17(MDI_PLUS[1])
MDI_1-: DL1.5(IN4) DL1.6(OUT1) TL1.6(TD2-) UL1.18(MDI_MINUS[1])
MDI_2+: DL2.1(IN1) DL2.9(OUT4) TL1.7(TD3+) UL1.20(MDI_PLUS[2])
MDI_2-: DL2.2(IN2) DL2.8(OUT3) TL1.8(TD3-) UL1.21(MDI_MINUS[2])
MDI_3+: DL2.4(IN3) DL2.7(OUT2) TL1.11(TD4+) UL1.23(MDI_PLUS[3])
MDI_3-: DL2.5(IN4) DL2.6(OUT1) TL1.12(TD4-) UL1.24(MDI_MINUS[3])
ME_FLASH: RC21.1 UE1.104(DSR0#/GPG6)
MIC_CLK_R: RA7.2 UA1.40(DMIC_CLK/MUSIC_REQ/GPIO0)
MIC_HW_EN: RC366.2 UC1.AH11(GPP_F6/I2C3_SDA)
MPLL_PVDD: CV17.1 CV18.1 CV19.1 LV3.2 UV3.L8(MPLL_PVDD)
NTC_V_1: PR9.1 PR10.2 PR11.2 PR12.1 PRT7.1 PU1.8(TMSNS1)
OCP_L: RV61.2 RV62.1 RV114.2
ON/OFF#: D5.2 D16.4(IN3) D16.7(OUT2) J1.2 JLINK.2(PWR_BOTTON) R71.2 SW1.3 SW1.4 UE1.110(PWRSW#)
ONEDOCK_DET#: JLINK.4(RETURN/DETECT) R88.2 R93.2 R98.2 RC368.1 UC1.G4(GPP_E2/SATAXPCIE2/SATAGP2)
OPC_RCOMP: RC56.2 UC1.H65(OPC_RCOMP)
OPCE_RCOMP: RC200.2 UC1.H66(OPCE_RCOMP)
OTP_N_002: PR12.2 PU1.7(RHYST1)
OTP_N_003: PR13.2 PU1.3(\\\\\\OT1)
OTP_RESET: PQ3.2(G) UE1.120(TMRI0/GPC4)
P2: PC102.1 PQ101.1(S1) PQ101.2(S2) PQ101.3(S3) PQ102.1(S1) PQ102.2(S2) PQ102.3(S3) PQ103.3(S) PR104.2 PR112.1
P3: PC103.2 PL101.1 PQ102.5(D)
PBTN_OUT#: RC379.2 TP129.1 UC1.BA15(GPD3/PWRBTN#) UE1.86(PS2DAT0/TMB1/GPF1)
PC_BEEP: CA24.2 UA1.10(PC_BEEP)
PCH_BEEP: CA23.1 DA1.3 RC95.1 RC300.1 UC1.AW5(GPP_B14/SPKR)
PCH_CMOS_ON: U4.4(EN) UC1.AM5(GPP_B19/GSPI1_CS#)
PCH_EDP_PWM: JLCD.12 UC1.R11(EDP_BKLTCTL)
PCH_ENVDD: R18.1 U3.4(EN) UC1.U13(EDP_VDDEN)
PCH_HDA_BCLK: CC538.1 RPC2.2(R2) UA1.5(BIT_CLK)
PCH_HDA_RST#: RPC2.1(R1) UA1.9(RESET#)
PCH_HDA_SDIN0: RA5.1 RC297.1 RC301.1 UC1.BA21(HDA_SDI0/I2S0_RXD)
PCH_HDA_SDIN0_R: RA5.2 UA1.6(SDATA_IN)
PCH_HDA_SDOUT: RPC2.3(R3) UA1.4(SDATA_OUT)
PCH_HDA_SYNC: RPC2.4(R4) UA1.8(SYNC)
PCH_INTRUDER#: RC16.2 UC1.AP16(INTRUDER#)
PCH_JTAG_TCK: RC372.1 T9.1 UC1.B56(PCH_JTAG_TCK)
PCH_JTAG_TDI: RC373.1 T10.1 UC1.D59(PCH_JTAG_TDI)
PCH_JTAG_TDO: T11.1 UC1.A56(PCH_JTAG_TDO)
PCH_JTAG_TMS: RC374.1 T12.1 UC1.C59(PCH_JTAG_TMS)
PCH_JTAG_TRST#: T8.1 UC1.C61(PCH_TRST#)
PCH_JTAGX: T13.1 UC1.A59(JTAGX)
PCH_OPIRCOMP: RC55.2 UC1.AU16(PCH_OPIRCOMP)
PCH_PCI_CLK_R: RC24.1 UC1.AW9(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
PCH_PWROK: RC41.1 UE1.99(GPH6/ID6)
PCH_RTCRST#: CC1.1 JCMOS1.1 RC12.2 UC1.AM16(RTCRST#)
PCH_RTCX1: CC3.1 RC13.1 UC1.AM18(RTCX1) YC1.1
PCH_RTCX2: CC4.1 RC13.2 UC1.AM20(RTCX2) YC1.2
PCH_SLP_LAN#: RL26.1 RPC18.6(R6) UC1.AW15(SLP_LAN#) UE1.87(GPF2)
PCH_SLP_WLAN#: RPC6.3(R3) UC1.BB17(GPD9/SLP_WLAN#) UE1.88(GPF3)
PCH_SMB_CLK: QC1.6(D1) RC375.1 UC1.R7(GPP_C0/SMBCLK)
PCH_SMB_DATA: QC1.3(D2) RC376.1 UC1.R8(GPP_C1/SMBDATA)
PCH_SML0_CLK: RC92.1 UC1.R9(GPP_C3/SML0CLK) UL1.28(SMB_CLK)
PCH_SML0_DAT: RC93.1 UC1.W2(GPP_C4/SML0DATA) UL1.31(SMB_DATA)
PCH_SML1CLK: QC2.6(D1) RC377.1 UC1.W3(GPP_C6/SML1CLK)
PCH_SML1DATA: QC2.3(D2) RC378.1 UC1.V3(GPP_C7/SML1DATA)
PCH_SPI_CLK: RC365.2 UC1.AV2(SPI0_CLK)
PCH_SRTCRST#: CC5.1 JME1.1 RC14.2 UC1.AN18(SRTCRST#)
PCH_SYSPWROK: CC527.2 UC1.B6(SYS_PWROK) UE1.82(EGAD/GPE1)
PCH_TSOFF#: D25.1 RPC10.3(R3) UC1.AD4(GPP_C23/UART2_CTS#)
PCH_XTAL24_IN: CC7.1 RC30.2 UC1.E37(XTAL24_IN) YC2.3
PCH_XTAL24_OUT: CC6.1 RC30.1 UC1.E35(XTAL24_OUT) YC2.1
PCIE1_PTX_DRX_N0: CC86.2 UC1.B23(PCIE9_TXN)
PCIE1_PTX_DRX_P0: CC87.2 UC1.A23(PCIE9_TXP)
PCIE2_PTX_DRX_N1: CC88.2 UC1.D23(PCIE10_TXN)
PCIE2_PTX_DRX_P1: CC89.2 UC1.C23(PCIE10_TXP)
PCIE3_CRX_DTX_N: JWLBT.43(PERN0) UC1.H16(PCIE3_RXN)
PCIE3_CRX_DTX_P: JWLBT.41(PERP0) UC1.G16(PCIE3_RXP)
PCIE3_CTX_C_DRX_N: CC18.1 JWLBT.37(PETN0)
PCIE3_CTX_C_DRX_P: CC19.1 JWLBT.35(PETP0)
PCIE3_CTX_DRX_N: CC18.2 UC1.D17(PCIE3_TXN)
PCIE3_CTX_DRX_P: CC19.2 UC1.C17(PCIE3_TXP)
PCIE3_PTX_DRX_N2: CC90.2 UC1.D24(PCIE11_TXN/SATA1B_TXN)
PCIE3_PTX_DRX_P2: CC23.2 UC1.C24(PCIE11_TXP/SATA1B_TXP)
PCIE4_CRX_DTX_N: CL2.1 UC1.G15(PCIE4_RXN)
PCIE4_CRX_DTX_N_C: CL2.2 UL1.39(PETN)
PCIE4_CRX_DTX_P: CL1.1 UC1.F15(PCIE4_RXP)
PCIE4_CRX_DTX_P_C: CL1.2 UL1.38(PETP)
PCIE4_CTX_C_DRX_N: CC92.1 UL1.42(PERN)
PCIE4_CTX_C_DRX_P: CC93.1 UL1.41(PERP)
PCIE4_CTX_DRX_N: CC92.2 UC1.B19(PCIE4_TXN)
PCIE4_CTX_DRX_P: CC93.2 UC1.A19(PCIE4_TXP)
PCIE4_PTX_DRX_N3: CC24.2 UC1.A25(PCIE12_TXN/SATA2_TXN)
PCIE4_PTX_DRX_P3: CC91.2 UC1.B25(PCIE12_TXP/SATA2_TXP)
PCIE6_CRX_DTX_N: JCR.1 UC1.G18(PCIE6_RXN)
PCIE6_CRX_DTX_P: JCR.2 UC1.F18(PCIE6_RXP)
PCIE6_CTX_C_DRX_N: CC20.1 JCR.4
PCIE6_CTX_C_DRX_P: CC21.1 JCR.5
PCIE6_CTX_DRX_N: CC20.2 UC1.D20(PCIE6_TXN)
PCIE6_CTX_DRX_P: CC21.2 UC1.C20(PCIE6_TXP)
PCIE_CRX_C_GTX_N0: CV133.2 UV3.AG31(PCIE_TX0N)
PCIE_CRX_C_GTX_N1: CV135.2 UV3.AF28(PCIE_TX1N)
PCIE_CRX_C_GTX_N2: CV137.2 UV3.AF26(PCIE_TX2N)
PCIE_CRX_C_GTX_N3: CV139.2 UV3.AD26(PCIE_TX3N)
PCIE_CRX_C_GTX_P0: CV132.2 UV3.AH30(PCIE_TX0P)
PCIE_CRX_C_GTX_P1: CV134.2 UV3.AG29(PCIE_TX1P)
PCIE_CRX_C_GTX_P2: CV136.2 UV3.AF27(PCIE_TX2P)
PCIE_CRX_C_GTX_P3: CV138.2 UV3.AD27(PCIE_TX3P)
PCIE_CRX_GTX_N0: CV133.1 UC1.E22(PCIE9_RXN)
PCIE_CRX_GTX_N1: CV135.1 UC1.F25(PCIE10_RXN)
PCIE_CRX_GTX_N2: CV137.1 UC1.E28(PCIE11_RXN/SATA1B_RXN)
PCIE_CRX_GTX_N3: CV139.1 UC1.E30(PCIE12_RXN/SATA2_RXN)
PCIE_CRX_GTX_P0: CV132.1 UC1.E23(PCIE9_RXP)
PCIE_CRX_GTX_P1: CV134.1 UC1.E25(PCIE10_RXP)
PCIE_CRX_GTX_P2: CV136.1 UC1.E27(PCIE11_RXP/SATA1B_RXP)
PCIE_CRX_GTX_P3: CV138.1 UC1.F30(PCIE12_RXP/SATA2_RXP)
PCIE_CTX_C_GRX_N0: CC86.1 UV3.AE31(PCIE_RX0N)
PCIE_CTX_C_GRX_N1: CC88.1 UV3.AD28(PCIE_RX1N)
PCIE_CTX_C_GRX_N2: CC90.1 UV3.AC31(PCIE_RX2N)
PCIE_CTX_C_GRX_N3: CC24.1 UV3.AB28(PCIE_RX3N)
PCIE_CTX_C_GRX_P0: CC87.1 UV3.AF30(PCIE_RX0P)
PCIE_CTX_C_GRX_P1: CC89.1 UV3.AE29(PCIE_RX1P)
PCIE_CTX_C_GRX_P2: CC23.1 UV3.AD30(PCIE_RX2P)
PCIE_CTX_C_GRX_P3: CC91.1 UV3.AC29(PCIE_RX3P)
PCIE_RCOMP: RC360.2 UC1.F5(PCIE_RCOMPN)
PCIE_WAKE#: RPC6.1(R1) UC1.BB15(WAKE#)
PECI: CE1.1 RE1.2 UE1.117(SMCLK2/PECI/GPF6)
PG_VDD: PR604.1 PR605.2 PU601.20(PGOOD)
PLANARID0: RC70.2 RC74.1 UC1.AB1(GPP_C8/UART0_RXD)
PLANARID1: RC409.2 RC410.1 UC1.U7(GPP_C16/I2C0_SDA)
PLT_RST_VGA#: DV1.1 PR606.1 RV43.2 RV44.1 UV3.AL27(PERSTB) UV4.4(OUT)
PLTRST#: RC26.1 UC1.AN10(GPP_B13/PLTRST#) UC3.2(IN_A) UV4.1(IN1)
PLTRST_FAR#: CC9.1 CE13.2 JCR.10 JWLBT.52(PERST0#) JWLBT.66(PERST1#) RC48.2 UE1.22(LPCRST#/GPD2) UL1.36(PE_RST_N) UTPM1.17(\\L\R\E\S\E\T\/\S\P\I\_\R\S\T\/)
PLTRST_NEAR#: CC102.1 RC348.2 USROM1.3(PROT#)
PM_SLP_A#: TP128.1 UC1.AN16(GPD6/SLP_A#) UE1.76(TACH2/GPJ0)
PM_SLP_S0#: T50.1 UC1.AT11(GPP_B12/SLP_S0#)
PM_SLP_S3#: D59.1 D62.1 TP125.1 UC1.AP15(GPD4/SLP_S3#) UE1.18(RI1#/GPD0)
PM_SLP_S4#: D63.1 TP126.1 UC1.BA16(GPD5/SLP_S4#) UE1.21(RI2#/GPD1)
PM_SLP_S5#: TP127.1 UC1.AY16(GPD10/SLP_S5#) UE1.77(GPJ1)
PM_SMB_CLK: JCP.11 JDIMM1.202(SCL) JDIMM2.202(SCL) QC1.1(S1) RC106.1 USROM1.6(SCL)
PM_SMB_DAT: JCP.7 JDIMM1.200(SDA) JDIMM2.200(SDA) QC1.4(S2) RC107.1 USROM1.5(SDA)
PME#: T62.1 UC1.AU11(GPP_A11/PME#)
PORTB_L: RA19.1 UA1.32(PORTB_L_LINE)
PORTB_R: RA24.1 UA1.33(PORTB_R_LINE)
PP: TP940.1 UTPM1.4(PP)
PROC_POPIRCOMP: RC151.2 UC1.AT16(PROC_POPIRCOMP)
PS8330_CAD: TP70.1 UM1.8(CAD_SRC)
PS8330_CFG1: RM23.2 RM26.1 UM1.40(EQ)
PS8330_REXT: RM19.2 RM34.2 UM1.7(CNTRL)
PS8330_RST: CM12.1 RM20.2 RM31.1 UM1.35(AUTO-EQ)
PS8401_CFG: RRE25.1 URE1.23(CFG / I2C_ADDR1)
PS8401_DCIN_EN: RRE26.1 URE1.13(DCIN_EN/SCL_CTL)
PS8401_DDCBUF: RRE21.2 RRE27.1 URE1.14(DDCBUF/SDA_CTL)
PS8401_EQ: RRE23.2 RRE29.1 URE1.17(EQ/I2C_ADDR0)
PS8401_ISET: RRE24.2 RRE30.1 URE1.34(ISET)
PS8401_PRE: RRE22.2 RRE28.1 URE1.16(PRE)
PS8713_RX1_C_N: L10.4 R32.2 R74.1
PS8713_RX1_C_P: L10.1 R29.2 R72.1
PS8713_RX1_N_R: R31.2 R32.1
PS8713_RX1_P_R: R28.2 R29.1
PS8713_RX2_C_N: L13.4 R48.2 R76.1
PS8713_RX2_C_P: L13.1 R46.2 R75.1
PS8713_RX2_N_R: R47.2 R48.1
PS8713_RX2_P_R: R34.2 R46.1
PS_0: CV153.1 RV98.2 RV99.2 UV3.AC19(PS_0)
PS_1: CV155.1 RV102.2 RV103.1 UV3.AD19(PS_1)
PS_2: CV154.1 RV100.2 RV101.1 UV3.AE17(PS_2)
PS_3: CV156.1 RV104.2 RV105.1 UV3.AE20(PS_3)
PSYS: PC127.2 PR124.1 PR413.2 PU401.46(PSYS)
PWM1_2PH: PU401.16(PWM1_2PH) PU403.2(PWM)
PWM_1A: PU401.22(PWM_1A) PU402.2(PWM)
PWM_1B: PU401.36(PWM_1B) PU404.2(PWM)
PWROK: CC528.2 RC41.2 RC403.2 UC1.BA20(PCH_PWROK)
Q27_G: Q29.2(G) R9456.1
REMOTE1+: C2.1 C4.1 Q1.1(COLLECTOR) Q1.2(BASE) U1.2(DP1)
REMOTE1-: C2.2 C4.2 Q1.3(EMITTER) U1.3(DN1)
REMOTE2+: C3.1 C5.1 Q2.1(COLLECTOR) Q2.2(BASE) U1.4(DP2/DN3)
REMOTE2-: C3.2 C5.2 Q2.3(EMITTER) U1.5(DN2/DP3)
RF_OFF#: JWLBT.56(W_DISABLE#1) RC371.2 UC1.AN8(GPP_B15/GSPI0_CS#)
RJ45_ACTIVITY#: JRJ451.12(YELLOW_LED-) UL1.27(LED1)
RJ45_GND: CL10.1 RL10.1 RL11.1 RL12.1 RL13.1
RJ45_LINKUP#: JRJ451.10(GREEN_LED-) UL1.26(LED0)
RJ45_TXD0N: JRJ451.2(PR1-) TL1.23(TX1-)
RJ45_TXD0P: JRJ451.1(PR1+) TL1.24(TX1+)
RJ45_TXD1N: JRJ451.6(PR2-) TL1.19(TX2-)
RJ45_TXD1P: JRJ451.3(PR2+) TL1.20(TX2+)
RJ45_TXD2N: JRJ451.5(PR3-) TL1.17(TX3-)
RJ45_TXD2P: JRJ451.4(PR3+) TL1.18(TX3+)
RJ45_TXD3N: JRJ451.8(PR4-) TL1.13(TX4-)
RJ45_TXD3P: JRJ451.7(PR4+) TL1.14(TX4+)
S3_1.35V: PC318.1 PR310.1 PR311.1 PU301.7(S3)
S5_1.35V: PC319.1 PR312.2 PR313.2 PU301.8(S5)
SA_CLK_DDR0: JDIMM1.101(CK0) UC1.AT53(DDR0_CKP[0])
SA_CLK_DDR1: JDIMM1.102(CK1) UC1.AT55(DDR0_CKP[1])
SA_CLK_DDR#0: JDIMM1.103(CK0#) UC1.AU53(DDR0_CKN[0])
SA_CLK_DDR#1: JDIMM1.104(CK1#) UC1.AU55(DDR0_CKN[1])
SA_DIMM_VREFDQ: CD2.1 RD2.1 UC1.AY68(DDR0_VREF_DQ)
SATA_PRX_C_DTX_N0: C26.2 JHDD.5(B-)
SATA_PRX_C_DTX_P0: C27.2 JHDD.6(B+)
SATA_PRX_DTX_N0: C26.1 UC1.F20(PCIE7_RXN/SATA0_RXN)
SATA_PRX_DTX_P0: C27.1 UC1.E20(PCIE7_RXP/SATA0_RXP)
SATA_PTX_C_DRX_N0: C25.2 JHDD.3(A-)
SATA_PTX_C_DRX_P0: C24.2 JHDD.2(A+)
SATA_PTX_DRX_N0: C25.1 UC1.B21(PCIE7_TXN/SATA0_TXN)
SATA_PTX_DRX_P0: C24.1 UC1.A21(PCIE7_TXP/SATA0_TXP)
SB_CLK_DDR0: JDIMM2.101(CK0) UC1.AP45(DDR1_CKP[0])
SB_CLK_DDR1: JDIMM2.102(CK1) UC1.AP46(DDR1_CKP[1])
SB_CLK_DDR#0: JDIMM2.103(CK0#) UC1.AN45(DDR1_CKN[0])
SB_CLK_DDR#1: JDIMM2.104(CK1#) UC1.AN46(DDR1_CKN[1])
SB_DIMM_VREFDQ: CD31.1 RD17.1 UC1.BA67(DDR1_VREF_DQ)
SCL_CTL: RM21.2 RM24.1 RM29.2 UM1.4(OP_0/SCL_CTL)
SDA_CTL: RM22.2 RM25.1 RM30.2 UM1.5(OP_1\SDACTL)
SERIRQ: R271.1 RPC22.1(R1) UC1.AY11(GPP_A6/SERIRQ) UE1.5(SERIRQ/GPM6)
SERIRQ_R: R261.1 R271.2 UTPM1.18(LAD2/\S\P\I\_\I\R\Q\)
SM_DIMM_VREFCA: CD12.1 RD10.2 UC1.AY67(DDR_VREF_CA)
SM_PG_CTRL: PR310.2 QD1.1(COLLECTOR) RD23.2
SM_RCOMP0: RC8.1 UC1.AR18(DDR_RCOMP[0])
SM_RCOMP1: RC9.1 UC1.AT18(DDR_RCOMP[1])
SM_RCOMP2: RC10.1 UC1.AU18(DDR_RCOMP[2])
SMBCLK: QV2.1(S1) RV72.2 UV3.U7(SMBCLK)
SMBDAT: QV2.4(S2) RV73.2 UV3.U8(SMBDATA)
SPI_CLK: R266.1 RC365.1 RPC23.7(R7) RPC24.7(R7)
SPI_CLK_4MB: RPC24.2(R2) UC4M1.6(CLK)
SPI_CLK_8MB: RC314.2 RPC23.2(R2) UC8M1.6(CLK)
SPI_CLK_R: R266.2 UTPM1.19(LCLK/SCLK)
SPI_CS0#_8MB: RC311.2 UC1.AU3(SPI0_CS0#) UC8M1.1(CS#)
SPI_CS1#_4MB: UC1.AU2(SPI0_CS1#) UC4M1.1(CS#)
SPI_CS2#_TPM: R265.1 UC1.AU1(SPI0_CS2#)
SPI_CS2_R: R265.2 R9456.2 UTPM1.20(\\L\F\R\A\M\E\/\S\C\S\)
SPI_FMISO: RC313.1 UE1.103(NC3)
SPI_FMOSI#: RC312.1 UE1.102(NC2)
SPI_FSCK: RC314.1 UE1.105(NC4)
SPI_IO2: RC117.2 RPC23.5(R5) RPC24.5(R5) UC1.AW2(SPI0_IO2)
SPI_IO2_4MB: RPC24.4(R4) UC4M1.3(WP#)
SPI_IO2_8MB: RPC23.4(R4) UC8M1.3(WP#)
SPI_IO3: RC118.2 RC380.1 RPC23.8(R8) RPC24.8(R8) UC1.AU4(SPI0_IO3)
SPI_IO3_4MB: RPC24.1(R1) UC4M1.7(HOLD#)
SPI_IO3_8MB: RPC23.1(R1) UC8M1.7(HOLD#)
SPI_SI: R263.1 RC298.1 RPC23.6(R6) RPC24.6(R6) UC1.AV3(SPI0_MOSI)
SPI_SI_4MB: RPC24.3(R3) UC4M1.5(DI)
SPI_SI_8MB: RC312.2 RPC23.3(R3) UC8M1.5(DI)
SPI_SI_R: R263.2 UTPM1.21(LAD1/MOSI)
SPI_SO: R264.1 RC102.2 RC103.2 RC308.1 UC1.AW3(SPI0_MISO)
SPI_SO_4MB: RC102.1 UC4M1.2(DO)
SPI_SO_8MB: RC103.1 RC313.2 UC8M1.2(DO)
SPI_SO_R: R264.2 UTPM1.24(LAD0/MISO)
SPK_L1-: RA8.1 UA1.14(LEFT-)
SPK_L1-_CON: CA25.2 JSPK.1 RA8.2
SPK_L2+: RA9.1 UA1.12(LEFT+)
SPK_L2+_CON: CA26.2 JSPK.2 RA9.2
SPK_R1-: RA10.1 UA1.15(RIGHT-)
SPK_R1-_CON: CA27.2 JSPK.3 RA10.2
SPK_R2+: RA12.1 UA1.17(RIGHT+)
SPK_R2+_CON: CA28.2 JSPK.4 RA12.2
SPKR_MUTE#: DA5.2 RA29.2 UA1.39(SPKR_MUTE#)
SPLL_PVDD: CV20.1 CV21.1 LV4.2 UV3.H7(SPLL_PVDD)
SPLL_VDDC: CV24.1 CV25.1 LV5.2 UV3.H8(SPLL_VDDC)
SRN: PR128.2 PU101.19(SRN)
SRP: PR125.2 PU101.20(SRP)
SSD_DEVSLP1: TP117.1 UC1.J2(GPP_E5/DEVSLP1)
SUS_STAT#: RC47.1 UC1.BA11(GPP_A14/SUS_STAT#/ESPI_RESET#)
SUSACK#: RC109.1 UC1.AP11(GPP_A15/SUSACK#)
SUSCLK_32K: JWLBT.50(SUSCLK) UC1.BA17(GPD8/SUSCLK)
SUSP: Q22.2(G) Q28.5(G2) Q28.6(D1) R156.2 R157.2
SUSP#: D23.1 D61.2 D62.2 PR311.2 Q24.2(G1) Q28.2(G1) RE48.2 U11.3(ON1) U11.5(ON2)
SUSP#_EC: D61.1 RPE4.8(R8) UE1.124(TMRI1/GPC6)
SUSWARN#: RC109.2 UC1.AR13(GPP_A13/SUSWARN#/SUSPWRDNACK)
SVI2_SVC: PR609.1 RV97.2 RV109.2 RV116.1 RV120.1 RV125.1 RV126.2
SVI2_SVD: PR615.1 RV96.2 RV107.2 RV117.1 RV118.1 RV121.1 RV122.2
SVI2_SVT: PR611.1 RV108.2 RV119.1 RV123.1 RV124.2
SW_1.00VS: PC704.2 PL701.1 PR708.2 PU701.6(SW1) PU701.7(SW2) PU701.8(SW3) PU701.9(SW4)
SW_1A: PR412.2 PR451.2
SW_1B: PR438.2 PR459.2
SW_1PH: PC462.1 PL408.1 PQ407.1(S1) PQ407.2(S2) PQ407.3(S3) PQ408.5(D) PR458.2 PR459.1 PU404.7(SW)
SW_A1: PC442.1 PL403.1 PQ401.1(S1) PQ401.2(S2) PQ401.3(S3) PQ402.5(D) PQ403.5(D) PR450.2 PR451.1 PU402.7(SW)
SW_B1: PC453.1 PL406.1 PQ404.1(S1) PQ404.2(S2) PQ404.3(S3) PQ405.5(D) PQ406.5(D) PR454.2 PR455.1 PU403.7(SW)
SYS_RESET#: RC108.2 UC1.B5(SYS_RESET#)
SYSON: D63.2 D64.2 PR312.1 R9492.1 RE49.2 U17.4(EN)
SYSON_EC: CE14.1 D64.1 RPE4.5(R5) UE1.107(DTR1#/SBUSY/GPG1/ID7)
TEST: R51.1 U6.14(TEST)
TEST_1: R38.1 U5.14(TEST)
TEST_2: R244.1 U16.14(TEST)
THRMTRIP#: RC53.2 RC54.2 UC1.C63(THERMTRIP#)
TON_1.35V: PR309.2 PU301.9(TON)
TOPAZ_VDDC_RTN: RV4.2 UV3.AD20(FB_GND_1)
TOPAZ_VDDC_SEN: RV3.2 UV3.AC20(FB_VDDC)
TP_CLK2: JCP.8 JTP.6 R63.2
TP_DATA2: JCP.9 JTP.1 R65.2
TP_RESET: JTP.2 R59.2 R60.2 R64.2
TP_REST: JCP.2 R64.1 R66.1 RC407.2 RE52.2
TP_REST_EC: RE52.1 UE1.72(ADC6/DSR1#/GPI6)
TP_REST_R: RC407.1 UC1.W4(GPP_C10/UART0_RTS#)
TS_OFF#: D22.2 D25.2 JTOUCH1.2 R113.2
USB3_RX4_N_OD: D17.2(IN2) D17.8(OUT3) JLINK.16(USB30_RX_N) L15.3 R117.2
USB3_RX4_P_OD: D17.1(IN1) D17.9(OUT4) JLINK.14(USB30_RX_P) L15.2 R116.2
USB3_TX1+_REIN: C30.2 U5.19(A_INP)
USB3_TX1+_REOUT: C121.1 U5.12(A_OUTP)
USB3_TX1-_REIN: C32.2 U5.20(A_INN)
USB3_TX1-_REOUT: C124.1 U5.11(A_OUTN)
USB3_TX2+_REIN: C36.2 U6.19(A_INP)
USB3_TX2+_REOUT: C125.1 U6.12(A_OUTP)
USB3_TX2-_REIN: C37.2 U6.20(A_INN)
USB3_TX2-_REOUT: C126.1 U6.11(A_OUTN)
USB3_TX4_N_C: C85.2 L16.4 R104.1
USB3_TX4_N_OD: D17.5(IN4) D17.6(OUT1) JLINK.22(USB30_TX_N) L16.3 R104.2
USB3_TX4_P_C: C86.2 L16.1 R103.1
USB3_TX4_P_OD: D17.4(IN3) D17.7(OUT2) JLINK.20(USB30_TX_P) L16.2 R103.2
USB3P1_RXN: C33.1 R31.1 UC1.H8(USB3_1_RXN)
USB3P1_RXN_CON: D7.5(IN4) D7.6(OUT1) JUSB1.5(STDA_SSRX-) L10.3
USB3P1_RXN_R: R74.2 U5.8(B_INN)
USB3P1_RXP: C31.1 R28.1 UC1.G8(USB3_1_RXP)
USB3P1_RXP_CON: D7.4(IN3) D7.7(OUT2) JUSB1.6(STDA_SSRX+) L10.2
USB3P1_RXP_R: R72.2 U5.9(B_INP)
USB3P1_TXN: C32.1 R33.1 UC1.C13(USB3_1_TXN)
USB3P1_TXN_C: C124.2 C130.2 L9.4
USB3P1_TXN_CON: D7.2(IN2) D7.8(OUT3) JUSB1.8(STDA_SSTX-) L9.3
USB3P1_TXN_R: C130.1 R33.2
USB3P1_TXP: C30.1 R27.1 UC1.D13(USB3_1_TXP)
USB3P1_TXP_C: C121.2 C122.2 L9.1
USB3P1_TXP_CON: D7.1(IN1) D7.9(OUT4) JUSB1.9(STDA_SSTX+) L9.2
USB3P1_TXP_R: C122.1 R27.2
USB3P2_RXN: C39.1 R47.1 UC1.J6(USB3_2_RXN/SSIC_1_RXN)
USB3P2_RXN_R: R76.2 U6.8(B_INN)
USB3P2_RXP: C38.1 R34.1 UC1.H6(USB3_2_RXP/SSIC_1_RXP)
USB3P2_RXP_R: R75.2 U6.9(B_INP)
USB3P2_TXN: C37.1 R62.1 UC1.B13(USB3_2_TXN/SSIC_1_TXN)
USB3P2_TXN_C: C126.2 C132.2 L12.4
USB3P2_TXN_R: C132.1 R62.2
USB3P2_TXP: C36.1 R44.1 UC1.A13(USB3_2_TXP/SSIC_1_TXP)
USB3P2_TXP_C: C125.2 C131.2 L12.1
USB3P2_TXP_R: C131.1 R44.2
USB3P3_RXN: L17.4 UC1.J10(USB3_3_RXN/SSIC_2_RXN)
USB3P3_RXN_C: JU3AC.8 L17.3
USB3P3_RXP: L17.1 UC1.H10(USB3_3_RXP/SSIC_2_RXP)
USB3P3_RXP_C: JU3AC.9 L17.2
USB3P3_TXN: L18.4 UC1.B15(USB3_3_TXN/SSIC_2_TXN)
USB3P3_TXN_C: JU3AC.5 L18.3
USB3P3_TXP: L18.1 UC1.A15(USB3_3_TXP/SSIC_2_TXP)
USB3P3_TXP_C: JU3AC.6 L18.2
USB3P4_RE_RXN: C188.1 R260.2 UC1.E10(USB3_4_RXN)
USB3P4_RE_RXN_R: C188.2 U16.23(B_OUTN)
USB3P4_RE_RXP: C187.1 R259.2 UC1.F10(USB3_4_RXP)
USB3P4_RE_RXP_R: C187.2 U16.22(B_OUTP)
USB3P4_RE_TXN: C85.1 R243.2 R256.2
USB3P4_RE_TXN_R: R243.1 U16.11(A_OUTN)
USB3P4_RE_TXP: C86.1 R242.2 R255.2
USB3P4_RE_TXP_R: R242.1 U16.12(A_OUTP)
USB3P4_RXN: L15.4 R117.1 R241.1 R258.1
USB3P4_RXN_C: R241.2 U16.8(B_INN)
USB3P4_RXN_R: R258.2 R260.1
USB3P4_RXP: L15.1 R116.1 R240.1 R257.1
USB3P4_RXP_C: R240.2 U16.9(B_INP)
USB3P4_RXP_R: R257.2 R259.1
USB3P4_TXN: C186.1 R254.1 UC1.C15(USB3_4_TXN)
USB3P4_TXN_C: C186.2 U16.20(A_INN)
USB3P4_TXN_R: R254.2 R256.1
USB3P4_TXP: C185.1 R253.1 UC1.D15(USB3_4_TXP)
USB3P4_TXP_C: C185.2 U16.19(A_INP)
USB3P4_TXP_R: R253.2 R255.1
