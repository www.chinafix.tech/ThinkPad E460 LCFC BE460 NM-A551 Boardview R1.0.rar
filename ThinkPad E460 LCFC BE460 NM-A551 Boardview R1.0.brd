# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D4: length 46.8
  IN3 w0.14: v2(47.33,139.42) 45.83,140.92 44.08,140.92 42,138.84 42,135.1 42.19,134.91 42.46,134.91 42.65,135.1 42.65,138.6 42.84,138.79 43.11,138.79 43.3,138.6 43.3,134.53 43.06,134.29 33.24,134.29 27.61,139.91 27.14,139.91 26.05,141 26.05,141.54 25.28,142.31 v2(25.01,142.31)
  BOTTOM w0.102: v2(47.33,139.42) 46.95,139.8 46.95,141.01 UV3.G29
  BOTTOM w0.14: v2(25.01,142.31) 25.01,141.59 24.51,141.09 24.51,140.36 UV5.F8
FBA_D5: length 46.7
  IN3 w0.14: v2(24.48,139.54) 24.48,139.26 24.67,139.07 26.31,139.07 26.41,138.97 27.28,138.97 29.1,137.15 29.1,135.09 32.09,132.1 39.91,132.1 40.1,132.29 40.1,132.56 39.91,132.75 34.42,132.75 34.23,132.94 34.23,133.21 34.38,133.35 43.8,133.35 44.24,133.79 44.24,136.78 45.28,137.82 45.28,138.83 v2(45.21,138.9)
  BOTTOM w0.102: UV3.F28 46.54,141.59 46.14,141.18 46.14,140.8 45.91,140.57 45.63,140.57 45.4,140.34 45.4,139.65 45.22,139.47
  BOTTOM w0.14: v2(24.48,139.54) 24.46,139.54 24.11,139.19 UV5.F7 ; v2(45.21,138.9) 45.21,139.46 45.22,139.47
FBA_D6: length 46.3
  IN3 w0.14: v1(46.57,138.31) 46.57,139.48 45.8,140.24 44.59,140.24 43.77,139.43 43.77,134.2 43.42,133.84 33.02,133.84 31.17,135.69 31.03,135.69 30.77,135.43 30.77,135.23 32.73,133.27 33.55,133.27 33.74,133.08 33.74,132.8 33.55,132.61 32.47,132.61 29.85,135.23 29.85,137.03 27.43,139.45 26.96,139.45 25.56,140.85 24.13,140.85 23.61,140.33 v1(22.92,140.33)
  BOTTOM w0.102: UV3.F32 46.54,138.34 v1(46.57,138.31)
  BOTTOM w0.14: v1(22.92,140.33) 22.87,140.33 22.51,139.97 UV5.H8
FBA_D7: length 46.6
  IN3 w0.14: v2(22.92,139.57) 23.87,138.62 26.02,138.62 26.87,137.78 27.79,137.78 28.66,136.91 28.66,134.91 31.91,131.66 44.96,131.66 45.15,131.85 45.15,132.12 44.96,132.3 40.82,132.3 40.63,132.49 40.63,132.76 40.78,132.91 44.36,132.91 44.68,133.23 44.68,136.6 45.63,137.55 46.04,137.55 46.25,137.34 v1(46.25,137.12)
  BOTTOM w0.102: UV3.F30 46.54,140.84 46.16,140.47 46.16,139.73
  BOTTOM w0.14: 46.16,139.73 46.07,139.64 46.07,137.3 v1(46.25,137.12) ; v2(22.92,139.57) 22.92,139.57 UV5.H7
FBA_D8: length 50.4
  TOP w0.14: UV6.A7 29.9,135.96 34.22,131.64 34.49,131.64 34.68,131.83 34.68,132.1 30.66,136.12 30.66,136.39 30.85,136.58 31.12,136.58 v4(34.73,132.96) 35.63,132.06 36.05,132.06 36.25,132.26 36.25,132.39 36.46,132.59 36.94,132.59 37.14,132.39 37.14,132.25 37.34,132.05 37.7,132.05 37.9,132.25 37.9,132.39 38.11,132.59 38.59,132.59 38.79,132.39 38.79,132.26 39,132.06 39.36,132.06 43.35,136.05 43.35,138.51 43.55,138.71 43.84,138.71 44.04,138.51 44.04,135.82 42.13,133.91 42.13,133.72 42.39,133.46 42.59,133.46 44.67,135.54 v2(44.67,138.41)
  BOTTOM w0.102: v2(44.67,138.41) 44.67,139.05 44.31,139.41 44.31,139.81 44.55,140.04 44.55,140.6 UV3.C30
FBA_D9: length 51.3
  TOP w0.14: v2(46.08,142.17) 45.98,142.17 45.8,141.99 45.8,141.71 46.11,141.41 46.11,141.08 45.96,140.93 44.91,140.93 44.71,140.73 44.71,140.54 44.91,140.34 45.46,140.34 45.66,140.14 45.66,139.9 45.32,139.55 45.32,139.45 45.66,139.11 45.66,138.62 45.14,138.1 45.14,137 45.79,136.36 45.79,135.67 45.67,135.55 45.24,135.55 40.63,130.94 40.35,130.94 40.15,131.14 40.15,131.41 41.88,133.14 41.88,133.41 41.69,133.6 41.42,133.6 39.5,131.68 v4(36.57,131.68) 35.14,131.68 34.93,131.48 34.93,131.12 35.14,130.92 39.73,130.92 39.94,130.72 39.94,130.43 39.73,130.23 35.11,130.23 29.79,135.55 26.11,135.55 UV6.D7
  BOTTOM w0.102: UV3.F27 46.54,142.41 46.45,142.32 46.24,142.32 v2(46.08,142.17)
FBA_D10: length 50.1
  TOP w0.14: UV6.C3 26.31,139.16 26.16,139.01 26.16,138.52 27.06,137.62 27.35,137.62 27.5,137.78 27.5,138.27 27.69,138.46 27.96,138.46 28.15,138.27 28.15,137.77 28.3,137.62 28.51,137.62 28.66,137.77 28.66,138.31 28.86,138.51 29.16,138.51 29.36,138.31 29.36,137.83 29.56,137.62 30,137.62 30.28,137.9 30.28,138.53 29.92,138.88 29.92,139.07 30.24,139.39 30.24,144.75 30.41,144.92 38.83,144.92 39.2,145.28 39.2,145.28 39.3,145.38 39.3,146.21 39.4,146.31 40.13,146.31 41.29,145.14 41.29,143.85 41.09,143.64 40.65,143.64 40.44,143.85 40.44,145.22 40.24,145.42 39.99,145.42 39.78,145.22 39.78,144.47 39.58,144.27 v4(35.77,144.27) 35.32,144.27 35.14,144.08 35.14,143.81 35.32,143.62 40.07,143.62 40.27,143.42 40.27,142.87 41.15,141.99 41.82,141.99 42.02,141.79 42.02,140.77 42.11,140.68 v2(42.65,140.68)
  BOTTOM w0.102: 43.19,141.54 43.42,141.54 43.54,141.66 44,141.66 UV3.A28
  BOTTOM w0.14: 43.19,141.54 42.65,141 v2(42.65,140.68)
FBA_D11: length 50.3
  TOP w0.14: v2(41.8,142.5) 41.98,142.32 42.21,142.32 42.3,142.41 42.3,142.65 41.98,142.97 41.98,143.52 41.73,143.77 41.73,144.56 41.84,144.67 42.25,144.67 42.45,144.88 42.45,145.47 42.25,145.68 41.28,145.68 40.24,146.72 39.15,146.72 38.92,146.49 38.92,145.52 38.68,145.28 30.83,145.28 30.64,145.47 30.64,145.74 30.83,145.93 38.22,145.93 38.41,146.12 38.41,146.39 38.22,146.58 v4(31.93,146.58) 30.79,146.58 29.84,145.62 29.84,139.56 29.25,138.97 28.3,138.97 UV6.A3
  BOTTOM w0.102: v2(41.8,142.5) 42.08,142.22 42.08,141.5 42.23,141.35 42.23,140.21 42.62,139.82 43,139.82 43.29,140.11 43.29,140.94 43.77,141.42 44.56,141.42 UV3.C28
FBA_D12: length 50.9
  TOP w0.14: UV6.C2 26.92,139.55 28.29,139.55 28.43,139.41 29.01,139.41 29.43,139.84 29.43,145.74 31.94,148.24 v4(32.65,148.24) 40.28,148.24 40.44,148.08 40.44,147.84 40.28,147.67 32.61,147.67 32.47,147.53 32.47,147.32 32.61,147.17 40.55,147.17 40.76,146.96 40.76,146.95 41.62,146.08 44.46,146.08 44.63,145.91 44.63,145.65 44.46,145.47 43.53,145.47 43.38,145.32 43.38,144.76 43.29,144.67 42.86,144.67 42.78,144.58 42.78,143.94 42.39,143.54 v2(42.39,143.21)
  BOTTOM w0.102: v2(42.39,143.21) 42.84,142.76 43.72,142.76 43.95,142.98 45.36,142.98 UV3.E27
FBA_D13: length 52.2
  TOP w0.14: v2(46.92,143.79) 46.92,143.67 46.54,143.28 46.54,142.82 46.83,142.52 46.83,140.3 46.53,140 46.53,139.17 46.76,138.94 46.99,138.94 47.7,138.23 47.7,137.74 46.83,136.86 46.83,134.27 41.94,129.38 41.68,129.38 41.49,129.57 41.49,129.84 44.1,132.45 44.1,132.72 43.91,132.91 43.64,132.91 40.12,129.39 v4(34.16,129.39) 33.02,129.39 30.48,131.94 30.21,131.94 30.02,131.75 30.02,131.48 31.5,129.99 31.5,129.73 31.31,129.54 31.05,129.54 29.41,131.17 29.41,132.59 28.95,133.05 26.78,133.05 26.11,133.71 26.11,134.76 UV6.C8
  BOTTOM w0.102: v2(46.92,143.79) 46.96,143.75 46.99,143.75 UV3.G26
FBA_D14: length 51
  TOP w0.14: v2(42.96,143.21) 43.35,143.6 43.92,143.6 44.05,143.72 44.05,144.05 44.18,144.18 44.41,144.18 44.53,144.05 44.53,143.67 44.66,143.54 44.95,143.54 45.08,143.67 45.08,146.54 44.54,147.07 42.11,147.07 40.48,148.7 33.32,148.7 33.13,148.89 33.13,149.16 33.32,149.35 39.97,149.35 40.14,149.52 40.14,149.75 39.97,149.92 v4(35.81,149.92) 32.98,149.92 29.05,146 29.05,145.65 28.85,145.45 28.56,145.45 28.35,145.24 28.35,144.91 28.56,144.71 28.85,144.71 29.05,144.51 29.05,144.18 28.85,143.97 28.55,143.97 28.35,143.77 28.35,143.49 28.55,143.29 28.85,143.29 29.05,143.09 29.05,140.23 28.67,139.85 28.22,139.85 UV6.A2
  BOTTOM w0.102: UV3.D26 44.95,143.79 43.94,143.79 43.8,143.64 43.4,143.64 v2(42.96,143.21)
FBA_D15: length 52.1
  TOP w0.14: v2(46.11,143.77) 46.11,142.8 46.53,142.38 46.53,140.61 46.09,140.18 46.09,138.49 45.78,138.17 45.78,136.89 46.16,136.51 46.16,134.12 45.18,133.13 44.91,133.13 44.72,133.32 44.72,133.59 45.64,134.52 45.64,134.79 45.45,134.98 45.19,134.98 40.03,129.83 34.99,129.83 29.79,135.03 29.52,135.03 29.33,134.84 29.33,134.57 v4(32.36,131.54) 33.53,130.37 33.53,130.1 33.34,129.91 33.07,129.91 29.15,133.84 28.53,133.84 28.18,133.49 27.37,133.49 27.15,133.7 27.15,133.9 26.91,134.15 26.91,135.01 27.06,135.16 UV6.B8
  BOTTOM w0.102: v2(46.11,143.77) 46.11,143.77 UV3.F25
FBA_D16: length 46.6
  TOP w0.14: UV6.H3 22.77,138.89 22.77,138.44 23.27,137.94 v2(23.29,137.94)
  IN1 w0.14: v2(43.58,144.05) 43.1,144.05 41.96,145.19 39.14,145.19 38.69,144.74 38.69,141.73 40.84,139.58 40.84,137.29 38.76,135.21 36.11,135.21 34.23,137.09 34.23,137.73 33.9,138.06 30.51,138.06 30.32,137.87 30.32,137.6 30.51,137.41 33.33,137.41 33.52,137.22 33.52,136.95 33.33,136.76 32.4,136.76 32.2,136.56 32.2,135.66 32.01,135.47 31.41,135.47 27.46,139.42 26.15,139.42 25.47,138.74 24.09,138.74 v2(23.29,137.94)
  BOTTOM w0.14: v2(43.58,144.05) 43.99,144.05 UV3.A25
FBA_D17: length 47
  TOP w0.14: UV6.E3 25.31,138.76 25.31,138.67 25.74,138.23 v2(25.74,138.17)
  IN1 w0.14: v2(25.74,138.17) 25.74,138.25 26.47,138.98 27.27,138.98 32.78,133.47 36.32,133.47 36.51,133.66 36.51,133.93 36.32,134.12 33.27,134.12 33.08,134.31 33.08,134.58 33.27,134.77 34.49,134.77 34.63,134.91 34.63,135.28 34.49,135.42 33.22,135.42 33.03,135.61 33.03,135.87 33.22,136.06 34.63,136.06 35.93,134.77 38.95,134.77 41.29,137.11 41.29,139.79 39.13,141.94 39.13,143.82 39.87,144.56 41.88,144.56 v2(42.23,144.2)
  BOTTOM w0.102: UV3.C25 44.56,144.58 43.93,144.58 43.81,144.46 42.49,144.46 v2(42.23,144.2)
FBA_D18: length 48
  TOP w0.14: v1(24.11,131.61) 24.1,131.61 24.1,132.28 23.06,133.32 23.06,134.12 22.97,134.22 22.97,134.7 UV6.H8
  IN1 w0.14: v2(46.12,144.6) 45.95,144.6 45.67,144.32 45.67,143.63 46.83,142.46 46.83,140.76 46.54,140.47 46.54,139.38 47.76,138.16 47.76,135.44 46.65,134.33 46.38,134.33 46.19,134.52 46.19,134.79 46.82,135.42 46.82,135.69 46.63,135.88 46.37,135.88 45.41,134.93 45.41,132.05 42.12,128.76 32.54,128.76 29.14,132.16 24.66,132.16 v1(24.11,131.61)
  BOTTOM w0.102: UV3.E25 45.74,144.22 v2(46.12,144.6)
FBA_D19: length 47.3
  TOP w0.14: v2(23.72,139.57) 23.68,139.61 23.66,139.61 UV6.G2
  IN1 w0.14: v2(23.72,139.57) 23.51,139.57 23.36,139.72 23.36,139.99 23.51,140.14 24.08,140.14 24.23,140.29 24.23,141.19 24.39,141.34 24.77,141.34 24.92,141.19 24.92,141.02 25.11,140.84 25.49,140.84 26.42,139.91 27.6,139.91 29.01,138.5 33.45,138.5 33.64,138.69 33.64,138.96 33.45,139.15 29.29,139.15 29.1,139.34 29.1,139.61 29.29,139.8 32.99,139.8 33.24,140.04 33.44,140.04 33.74,139.74 34.01,139.74 34.2,139.93 34.2,140.2 33.89,140.5 33.89,140.7 34.15,140.96 34.35,140.96 34.68,140.63 34.95,140.63 35.14,140.82 35.14,141.09 34.81,141.42 34.81,141.62 35.07,141.88 35.27,141.88 35.64,141.51 35.91,141.51 36.1,141.7 36.1,141.97 35.73,142.34 35.73,142.53 35.99,142.79 36.18,142.79 37.18,141.8 37.44,141.8 37.63,141.99 37.63,142.26 36.64,143.25 36.64,143.45 36.9,143.71 37.1,143.71 37.77,143.04 38.04,143.04 38.23,143.23 38.23,143.5 37.56,144.17 37.56,144.37 38.87,145.67 42.52,145.67 v2(42.89,145.3)
  BOTTOM w0.102: UV3.D24 44.92,145.42 43.02,145.42 v2(42.89,145.3)
FBA_D20: length 47.8
  TOP w0.14: v2(24.47,135.55) 24.47,135.56 24.11,135.92 UV6.F7
  IN1 w0.14: v1(46.07,145.32) 45.34,144.59 45.34,143.49 46.5,142.33 46.5,141.63 46.11,141.23 46.11,138.36 45.73,137.98 45.73,135.87 44.97,135.11 44.97,132.28 43.43,130.74 43.16,130.74 42.97,130.93 42.97,131.2 44.31,132.55 44.31,132.81 44.12,133 43.86,133 42.42,131.56 41.97,131.12 41.97,130.66 42.42,130.22 42.42,129.76 41.86,129.2 32.73,129.2 29.31,132.62 24.95,132.62 24.77,132.8 24.77,135.26 24.48,135.55 v2(24.47,135.55)
  BOTTOM w0.14: UV3.E23 45.74,145.65 v1(46.07,145.32)
FBA_D21: length 47.8
  TOP w0.14: v1(25.43,133.14) 25.33,133.14 24.47,133.99 24.47,134.79 UV6.F8
  IN1 w0.14: v1(25.43,133.14) 25.65,133.14 25.99,133.48 25.99,134.6 26.27,134.88 26.91,134.88 27.18,134.6 27.18,133.56 27.49,133.26 29.3,133.26 32.91,129.65 41.63,129.65 41.82,129.84 41.82,130.11 41.63,130.3 40,130.3 39.81,130.49 39.81,130.75 40,130.94 41.14,130.94 44.52,134.33 44.52,137.54 45.65,138.67 45.65,139.1 45.35,139.4 45.35,139.81 45.61,140.08 45.61,140.38 45.4,140.6 45.09,140.6 44.79,140.29 44.51,140.29 44.31,140.49 44.31,140.78 44.94,141.41 44.94,145.4 45.74,146.2 v2(46.11,146.2)
  BOTTOM w0.102: v2(46.11,146.2) 46.12,146.2 46.53,145.8 UV3.F23
FBA_D22: length 47.8
  TOP w0.14: UV6.H7 22.51,135.94 v1(22.12,135.55)
  IN1 w0.14: v1(43.3,146.59) 43.78,146.11 44.1,146.11 44.66,145.55 44.66,142.09 43.82,141.26 43.82,138.21 44.08,137.95 44.08,134.51 40.96,131.39 37.1,131.39 36.91,131.2 36.91,130.93 37.1,130.74 39.14,130.74 39.33,130.55 39.33,130.28 39.14,130.09 33.09,130.09 27.85,135.34 26.37,135.34 25.67,136.04 22.61,136.04 v1(22.12,135.55)
  BOTTOM w0.102: UV3.D22 44.94,146.99 43.71,146.99 v1(43.3,146.59)
FBA_D23: length 48.1
  TOP w0.14: UV6.F2 24.52,140.36 24.52,140.92 24.52,140.93 v2(24.52,141.86)
  IN1 w0.14: v2(45.96,146.79) 45.14,146.79 44.93,147 43.55,147 43.53,147.01 40.95,147.01 40.12,146.18 38.74,146.18 33.66,141.1 33.39,141.1 33.2,141.29 33.2,141.55 37.36,145.71 37.36,145.98 37.17,146.17 36.9,146.17 32.26,141.53 29.91,141.53 29.74,141.36 29.74,141.08 29.93,140.89 32.1,140.89 32.24,140.75 32.24,140.38 32.1,140.24 29.56,140.24 28.95,140.85 27.93,140.85 27.78,141 27.78,141.31 27.58,141.51 27.3,141.51 27.09,141.31 27.09,140.55 26.94,140.39 26.61,140.39 25.97,141.04 25.97,141.67 25.79,141.86 v2(24.52,141.86)
  BOTTOM w0.14: UV3.F21 46.54,147.38 46.29,147.13 46.29,147.12 v2(45.96,146.79)
FBA_D24: length 52.6
  BOTTOM w0.084: UV3.E21 45.53,147.4 45.11,147.81 44.47,147.81 44.4,147.88 44.37,147.88 44.36,147.9 43.84,147.9 43.69,147.74 43,147.74 42.7,147.44 42.41,147.44
  BOTTOM w0.14: 42.41,147.44 41.5,147.44 41.02,146.96 41.02,145.86 39.33,144.17 39.08,143.92 35.13,143.92 31.97,140.76 31.97,136.03 34.99,133 36.9,133 37.65,132.25 v4(37.65,130.56) 37.65,129.15 37.12,128.61 27.65,128.61 27.03,129.23 26.2,129.23 25.92,129.5 25.92,132.25 27.06,133.38 28.2,133.38 28.54,133.72 28.54,134.72 UV5.A2
FBA_D25: length 52.5
  BOTTOM w0.084: UV3.D20 45.19,148.34 44.88,148.34 44.63,148.59 44.46,148.59 44.33,148.47 43.93,148.47 43.82,148.58 43.28,148.58 42.51,147.81 42.44,147.81
  BOTTOM w0.14: 42.44,147.81 41.27,147.81 40.67,147.22 40.67,146.03 38.93,144.29 34.98,144.29 31.6,140.92 31.6,135.87 34.88,132.6 v4(36.1,132.6) 36.66,132.6 37.11,132.16 37.11,129.4 36.68,128.98 29.62,128.98 29.41,129.19 29.41,132.14 29.13,132.42 27.41,132.42 27.22,132.61 27.22,132.87 27.41,133.05 28.42,133.05 28.95,133.59 28.95,134.89 28.29,135.55 26.91,135.55 UV5.C2
FBA_D26: length 53.2
  BOTTOM w0.084: UV3.F19 46.09,148.55 44.91,148.55 44.7,148.76 44.39,148.76 44.28,148.65 44.01,148.65 43.91,148.75 43.14,148.75 42.66,148.26 42.36,148.26
  BOTTOM w0.14: 42.36,148.26 41.22,148.26 40.25,147.3 v4(40.25,146.73) 40.25,146.24 38.68,144.66 34.83,144.66 31.24,141.07 31.24,135.72 34.76,132.2 36.24,132.2 36.58,131.86 36.58,129.75 36.18,129.35 30.28,129.35 30.09,129.54 30.09,129.8 30.28,129.99 32.67,129.99 32.86,130.18 32.86,130.45 32.67,130.64 30.08,130.64 29.77,130.95 29.77,132.29 29.33,132.74 29.33,135.06 28.43,135.96 UV5.A3
FBA_D27: length 52.4
  BOTTOM w0.102: 42.4,148.63 42.72,148.63 43.07,148.97 44.11,148.97 UV3.A19
  BOTTOM w0.14: 42.4,148.63 41.01,148.63 39.82,147.44 39.82,146.33 38.55,145.06 v4(36.62,145.06) 34.71,145.06 30.85,141.21 30.85,135.58 34.61,131.82 35.43,131.82 35.72,131.53 35.72,130.41 35.29,129.98 33.79,129.98 33.59,130.18 33.59,131.22 33.38,131.43 33.1,131.43 32.9,131.63 32.9,132.27 32.71,132.47 32.43,132.47 32.24,132.27 32.24,131.6 32.04,131.4 31.71,131.4 31.5,131.6 31.5,133.57 31.36,133.71 30.99,133.71 30.85,133.57 30.85,131.53 30.65,131.32 30.35,131.32 30.14,131.53 30.14,136.41 29.76,136.79 27.34,136.79 UV5.C3
FBA_D28: length 52.9
  BOTTOM w0.084: UV3.D18 45.34,149.98 45.24,150.08 44.77,150.08 44.72,150.13 44.41,150.13 44.38,150.09 43.9,150.09 43.69,150.3 43.34,150.3 43.19,150.14
  BOTTOM w0.14: UV5.A7 28.11,138.35 28.25,138.21 28.51,138.21 28.63,138.34 28.63,139.05 28.75,139.17 28.98,139.17 29.11,139.05 29.11,138.45 29.24,138.32 29.48,138.32 29.61,138.45 29.61,142.12 29.48,142.25 28.19,142.25 28.06,142.37 28.06,145.52 28.16,145.63 28.67,145.63 28.8,145.5 28.8,143.03 28.92,142.91 29.48,142.91 29.61,143.03 v4(29.61,144.99) 29.61,145.97 33.64,149.99 33.9,149.99 34.09,149.8 34.09,149.53 30.32,145.76 30.32,145.5 30.51,145.31 30.78,145.31 35.16,149.69 35.61,149.69 35.81,149.49 35.81,148.77 35.94,148.65 36.25,148.65 36.37,148.77 36.37,149.88 36.51,150.02 36.79,150.02 36.93,149.88 36.93,149.61 37.06,149.49 37.36,149.49 37.49,149.61 37.49,149.88 37.63,150.02 39,150.02 39.14,149.88 39.14,149.58 39.28,149.44 39.65,149.44 39.79,149.58 39.79,149.88 39.93,150.02 40.43,150.02 40.64,149.81 42.86,149.81 43.19,150.14
FBA_D29: length 53.3
  BOTTOM w0.084: UV3.F17 46.18,150.23 45.47,150.23 45.45,150.25 44.83,150.25 44.79,150.3 44.31,150.3 44.28,150.26 43.99,150.26 43.77,150.48 43.14,150.48 42.9,150.23
  BOTTOM w0.14: UV5.B8 27.52,139.96 27.92,139.55 29.09,139.55 29.22,139.68 29.22,141.08 29.11,141.19 27.65,141.19 27.5,141.33 27.5,147.97 30.77,151.24 30.95,151.24 31.2,150.99 31.2,150.81 27.97,147.58 27.97,147.4 28.23,147.15 28.41,147.15 31.68,150.42 31.86,150.42 32.12,150.17 32.12,149.99 28.65,146.52 28.65,146.34 28.93,146.07 29.11,146.07 33.44,150.4 v4(34.27,150.4) 40.91,150.4 41.14,150.17 42.83,150.17 42.9,150.23
FBA_D30: length 52
  BOTTOM w0.084: 41.75,150.6 42.72,150.6 42.82,150.7 44.03,150.7 UV3.A17
  BOTTOM w0.14: 41.75,150.6 41.48,150.6 41.24,150.83 31.86,150.83 31.67,151.02 31.67,151.29 31.86,151.48 34.35,151.48 34.54,151.67 34.54,151.94 34.35,152.13 30.99,152.13 29.67,150.81 26.58,147.73 26.4,147.73 26.13,148.01 26.13,148.18 v4(27.91,149.97) 29.23,151.3 29.23,151.8 29.01,152.03 27.79,152.03 27.59,151.82 27.59,150.78 27.39,150.58 26.91,150.58 26.78,150.45 26.78,149.54 26.65,149.41 26.22,149.41 26.09,149.54 26.09,150.58 25.89,150.78 25.33,150.78 25.2,150.65 25.2,147.38 25.36,147.23 26.88,147.23 27.09,147.02 27.09,141.23 26.92,141.06 26.92,140.36 UV5.C8
FBA_D31: length 52.7
  BOTTOM w0.084: UV3.C17 44.94,150.83 44.84,150.94 42.83,150.94
  BOTTOM w0.14: UV5.D7 26.11,139.56 26.11,142.76 26.72,143.37 26.72,146.44 26.58,146.59 24.98,146.59 24.8,146.77 24.8,147.79 24.66,147.92 24.38,147.92 24.24,147.79 24.24,147.11 24.1,146.97 23.82,146.97 23.68,147.11 23.68,148.34 23.82,148.48 24.66,148.48 24.8,148.62 24.8,150.96 25.03,151.19 26.19,151.19 27.31,152.31 27.5,152.5 41.28,152.5 41.47,152.31 41.47,152.04 41.28,151.85 v4(36.28,151.85) 35.11,151.85 34.92,151.66 34.92,151.39 35.11,151.2 41.36,151.2 41.58,150.98 42.79,150.98 42.83,150.94
FBA_D32: length 48.3
  TOP w0.14: UV7.H8 22.91,154.69 22.91,153.41 v2(23.09,153.23)
  IN3 w0.14: v2(23.09,153.23) 23.3,153.23 23.5,153.03 23.5,152.81 23.65,152.66 23.99,152.66 24.15,152.81 24.15,152.99 24.28,153.13 24.63,153.13 25.22,152.53 25.22,152.35 25.36,152.21 25.73,152.21 25.87,152.35 25.87,152.63 26.02,152.79 26.37,152.79 26.52,152.63 26.52,152.35 26.66,152.21 27.03,152.21 27.17,152.35 27.17,152.64 27.32,152.79 27.66,152.79 27.81,152.64 27.81,152.25 27.97,152.1 28.49,152.1 28.66,151.93 37.89,151.93 38.08,151.74 38.08,151.47 37.89,151.28 29.74,151.28 29.55,151.09 29.55,150.82 29.74,150.63 43.03,150.63 43.15,150.51 44.32,150.51 44.97,151.16 44.97,151.69 45.18,151.9 45.45,151.9 45.57,151.77 45.57,151.53 45.99,151.12 v2(46.08,151.12)
  BOTTOM w0.14: UV3.E17 46.05,150.6 46.18,150.73 46.18,151.03 v2(46.08,151.12)
FBA_D33: length 48.3
  TOP w0.14: v2(22.89,155.47) 22.84,155.51 22.84,155.51 22.51,155.84 UV7.H7
  IN3 w0.14: v2(22.89,155.47) 22.55,155.13 22.55,154.49 22.79,154.25 24.05,154.25 24.2,154.41 24.2,154.89 24.35,155.04 24.69,155.04 24.85,154.89 24.85,154.41 25.01,154.25 25.81,154.25 25.87,154.19 29.26,154.19 31.77,156.7 32.41,156.7 32.6,156.51 32.6,156.24 32.41,156.05 31.92,156.05 31.73,155.86 31.73,155.59 31.92,155.4 39.09,155.4 39.25,155.24 39.25,154.92 39.09,154.76 35.6,154.76 35.41,154.57 35.41,154.3 35.6,154.11 38.98,154.11 39.17,153.92 39.17,153.65 38.98,153.46 36.57,153.46 36.38,153.27 36.38,153 36.57,152.81 39.38,152.81 40.27,151.92 44.28,151.92 44.45,151.75 44.45,151.29 44.12,150.96 43.69,150.96 v1(43.29,151.36)
  BOTTOM w0.084: UV3.D16 44.97,151.77 43.7,151.77 v1(43.29,151.36)
FBA_D34: length 48.7
  TOP w0.14: UV7.F7 24.11,155.86 24.44,155.53 24.45,155.53 v1(24.49,155.49)
  IN3 w0.14: v1(24.49,155.49) 24.51,155.49 24.52,155.5 25.01,155.5 25.14,155.37 25.95,155.37 26.09,155.23 26.09,154.82 26.24,154.67 26.58,154.67 26.74,154.82 26.74,155.23 26.88,155.37 29.77,155.37 32.84,158.44 35.05,158.44 35.24,158.25 35.24,157.98 35.05,157.79 33.19,157.79 33,157.6 33,157.33 33.19,157.14 39.62,157.14 39.81,156.95 39.81,156.69 39.62,156.5 33.22,156.5 33.04,156.32 33.04,156.06 33.03,156.05 33.03,156.04 33.22,155.85 39.27,155.85 39.69,155.42 39.69,153.22 40.54,152.38 45.76,152.38 45.83,152.3 47.01,152.3 v1(47.1,152.21)
  BOTTOM w0.102: UV3.F15 46.55,152.21 v1(47.1,152.21)
FBA_D35: length 47.5
  TOP w0.14: UV7.F8 24.11,155.01 24.47,154.65 24.47,154.18 24.62,154.03 24.62,154.03 25.18,153.47 v1(25.18,153.28)
  IN3 w0.14: v1(25.18,153.28) 25.22,153.24 28.26,153.24 28.34,153.16 28.87,153.16 30.67,154.96 34.59,154.96 34.78,154.77 34.78,154.5 34.59,154.31 30.98,154.31 30.79,154.12 30.79,153.85 30.98,153.66 35.73,153.66 35.92,153.48 35.92,153.21 35.73,153.02 29.53,153.02 29.34,152.83 29.34,152.56 29.53,152.37 39.09,152.37 39.28,152.18 39.28,151.91 39.09,151.72 38.78,151.72 38.59,151.53 38.59,151.26 38.78,151.07 41.5,151.07 v5(41.89,151.47)
  BOTTOM w0.084: v5(41.89,151.47) 42.7,151.47 43.36,152.12 44.07,152.12 UV3.A15
FBA_D36: length 48.1
  TOP w0.14: UV7.E3 25.07,159.1 26.04,158.13 v2(26.36,158.13)
  IN3 w0.14: v2(26.36,158.13) 26.87,158.64 26.87,158.85 25.8,159.92 25.8,160.19 25.99,160.38 26.26,160.38 27.12,159.52 27.69,159.52 28.14,159.96 28.14,160.34 28.54,160.75 29.15,160.75 30.95,162.55 30.95,163.15 31.15,163.35 31.45,163.35 31.66,163.15 31.66,162.94 31.82,162.77 32.15,162.77 32.32,162.94 32.32,163.24 32.44,163.37 34,163.37 34.14,163.51 34.14,163.87 34,164.01 31.39,164.01 31.2,164.2 31.2,164.47 31.39,164.66 38.32,164.66 38.49,164.5 38.49,163.75 38.65,163.58 38.97,163.58 39.14,163.75 39.14,164.26 39.33,164.45 39.59,164.45 39.78,164.26 39.78,163.77 39.97,163.58 40.24,163.58 40.43,163.77 40.43,164.05 40.61,164.23 40.91,164.23 42.91,162.24 42.91,159.19 44.36,157.73 44.36,155.98 44.19,155.81 44.19,154.16 43.17,153.14 v2(43.17,153.03)
  BOTTOM w0.084: v2(43.17,153.03) 43.59,153.45 44.36,153.45 44.81,153.26 44.84,153.25 44.84,153.24 44.9,153.18 44.9,153.18 arc(45.1,153.04) UV3.D14
FBA_D37: length 48.9
  TOP w0.14: UV7.F2 24.46,160.25 24.46,161.24 v1(24.14,161.56)
  IN3 w0.14: v1(24.14,161.56) 24.14,161.74 24.42,162.01 25.59,162.01 26.27,162.69 26.27,163.08 27.81,164.62 29.07,164.62 29.33,164.36 29.8,164.36 32.28,166.85 40.66,166.85 40.85,166.66 40.85,166.39 40.66,166.2 34.79,166.2 34.62,166.03 34.62,165.72 34.79,165.55 40.88,165.55 44.45,161.98 44.45,159.2 45.35,158.29 45.35,154.85 v2(45.84,154.37)
  BOTTOM w0.14: UV3.F13 46.41,153.8 v2(45.84,154.37)
FBA_D38: length 47.3
  TOP w0.14: v1(23.71,159.5) 23.31,159.9 UV7.G2
  IN3 w0.14: v1(23.71,159.5) 24.51,160.31 24.51,160.54 24.99,161.01 25.75,161.01 27.12,162.38 27.12,163.27 27.31,163.46 27.58,163.46 27.77,163.27 27.77,162.38 27.91,162.24 28.28,162.24 28.42,162.38 28.42,163.95 28.61,164.14 28.87,164.14 29.06,163.95 29.06,162.38 29.2,162.24 30.01,162.24 30.5,162.73 30.5,164.43 31.17,165.11 32.1,165.11 32.24,165.25 32.24,166.11 32.38,166.25 32.74,166.25 32.88,166.11 32.88,165.25 33.02,165.11 33.39,165.11 33.53,165.25 33.53,166.11 33.67,166.25 34.04,166.25 34.18,166.11 34.18,165.25 34.32,165.11 40.7,165.11 43.99,161.81 43.99,158.85 44.84,158.01 44.84,153.95 v2(46.04,152.75)
  BOTTOM w0.084: v2(46.04,152.75) 46.04,152.93 45.6,153.37 45.13,153.37 44.91,153.42 44.91,153.42 44.62,153.57 44.62,153.57 44.58,153.61 44.46,153.66 44.46,153.66 arc(44.31,153.76) UV3.A13
FBA_D39: length 48.2
  TOP w0.14: v2(24.02,158.04) 23.89,158.04 23.21,158.72 22.89,158.72 UV7.H3
  IN3 w0.14: v2(24.02,158.04) 24.02,157.75 24.79,156.98 24.79,156.36 25.34,155.81 29.54,155.81 33.89,160.16 36.53,160.16 36.68,160.01 36.68,159.7 36.51,159.53 34,159.53 33.81,159.34 33.81,159.08 34,158.89 40.37,158.89 40.56,158.7 40.56,158.43 40.37,158.24 35.87,158.24 35.69,158.06 35.69,157.8 35.68,157.79 35.68,157.78 35.87,157.59 40.13,157.59 40.42,157.3 40.42,153.15 v5(40.53,153.04)
  BOTTOM w0.084: 42.39,153.76 42.68,154.05 43.92,154.05 44.01,154.15 44.27,154.15 44.35,154.07 44.67,154.07 UV3.C13
  BOTTOM w0.14: v5(40.53,153.04) 41.25,153.76 42.39,153.76
FBA_D40: length 54.5
  TOP w0.14: v2(46.06,154.91) 46.13,154.91 46.71,155.49 46.71,155.88 46.83,156.01 46.83,156.8 46.09,157.55 45.7,157.55 45.44,157.81 45.44,158.26 44.66,159.03 44.66,161.86 44.08,162.44 44.08,163.14 43.75,163.46 39.97,163.46 39.78,163.65 39.78,163.92 39.97,164.11 44.44,164.11 44.63,164.3 44.63,164.57 44.44,164.76 31.59,164.76 31.4,164.95 31.4,165.22 31.59,165.41 36.01,165.41 36.2,165.6 36.2,165.86 36.01,166.05 v4(33.03,166.05) 31.12,166.05 29.32,164.25 29.32,163.6 29.18,163.46 28.64,163.46 28.45,163.27 28.45,163.01 28.64,162.82 29.18,162.82 29.32,162.68 29.32,159.8 28.62,159.1 UV7.A3
  BOTTOM w0.14: v2(46.06,154.91) 45.74,155.24 UV3.E11
FBA_D41: length 54.7
  TOP w0.14: v2(41.86,154.61) 41.34,154.1 40.76,154.1 39.9,153.23 39.9,152.42 42.93,149.38 45.42,149.38 45.63,149.18 45.63,148.9 45.42,148.7 42.6,148.7 40.43,150.87 27.5,150.87 27.29,150.66 27.29,150.39 27.48,150.2 v4(28.91,150.2) 30.73,150.2 30.92,150.01 30.92,149.74 30.73,149.55 27.58,149.55 27.39,149.36 27.39,149.09 27.58,148.9 29.48,148.9 29.62,148.76 29.62,148.39 29.48,148.25 26.96,148.25 26.58,148.63 26.58,151.92 26.3,152.2 26.3,153.48 26.06,153.71 26.06,154.09 26.1,154.13 26.1,155.5 UV7.D7
  BOTTOM w0.084: v2(41.86,154.61) 42.36,154.61 43.15,155.4 UV3.A11
FBA_D42: length 54.6
  TOP w0.14: UV7.C8 26.9,154.7 26.9,154.04 27.17,153.77 27.17,152.79 27.45,152.51 28.2,152.51 29.5,153.8 31.95,153.8 32.14,153.61 32.14,153.35 31.95,153.16 29.91,153.16 29.72,152.97 29.72,152.7 29.91,152.51 v4(32.14,152.51) 38.63,152.51 38.82,152.32 38.82,152.05 38.63,151.86 27.35,151.86 27.16,151.67 27.16,151.4 27.32,151.24 39.34,151.24 39.45,151.35 39.45,153.59 41.16,155.3 42.85,155.3 43.36,155.81 v2(43.36,156.06)
  BOTTOM w0.084: UV3.C11 44.93,155.4 44.58,155.74 43.68,155.74 v2(43.36,156.06)
FBA_D43: length 54.6
  TOP w0.102: v2(47.11,155.72) 47.34,155.95 47.34,157.94
  TOP w0.14: 47.34,157.94 47.32,157.97 47.32,158.37 47.08,158.61 46.74,158.61 45.57,159.77 45.57,165.51 43.69,167.39 43.69,168.28 43.54,168.43 43.04,168.43 42.89,168.28 42.89,167 42.75,166.86 42.38,166.86 42.24,167 42.24,168.54 42.09,168.69 41.74,168.69 41.59,168.54 41.59,167 41.45,166.86 41.08,166.86 40.94,167 40.94,169.48 40.79,169.63 40.45,169.63 40.3,169.48 40.3,167 40.16,166.86 39.79,166.86 39.65,167 39.65,168.97 39.5,169.12 39.15,169.12 39,168.97 39,167 38.86,166.86 38.49,166.86 38.35,167 38.35,167.34 38.21,167.48 27.34,167.48 v4(26.7,166.83) 25.79,165.92 25.79,161.58 26.11,161.26 26.11,160.42 26.51,160.02 UV7.C2
  BOTTOM w0.14: UV3.F11 46.79,155.4 v2(47.11,155.72)
FBA_D44: length 53.9
  TOP w0.14: v2(42.14,156.06) 40.63,156.06 40.46,155.9 30.22,155.9 30.03,156.09 30.03,156.35 30.22,156.54 40.51,156.54 40.7,156.73 40.7,157 40.51,157.19 31.44,157.19 31.25,157.38 31.25,157.65 31.44,157.84 37.71,157.84 37.9,158.03 37.9,158.3 37.71,158.49 v4(32.94,158.49) 31.08,158.49 28.49,155.9 UV7.A7
  BOTTOM w0.084: v2(42.14,156.06) 43.07,157 UV3.A9
FBA_D45: length 54.4
  TOP w0.14: UV7.B8 27.7,155.49 28.27,155.49 28.3,155.47 28.61,155.47 28.61,155.47 v4(34,155.47) 39.34,155.47 39.53,155.28 39.53,155.01 39.34,154.82 29.3,154.82 29.12,154.63 29.12,154.36 29.3,154.17 38.27,154.17 38.46,153.98 38.46,153.71 38.27,153.52 32.71,153.52 32.52,153.33 32.52,153.07 32.71,152.88 38.84,152.88 39.08,153.12 39.08,153.74 40.99,155.65 42.37,155.65 v2(42.78,156.06)
  BOTTOM w0.084: UV3.C9 44.56,156.62 43.98,156.62 43.86,156.74 43.46,156.74 v2(42.78,156.06)
FBA_D46: length 54.1
  TOP w0.14: v2(45.97,157.96) 45.97,158.35 45.19,159.12 45.19,164.75 44.82,165.13 36.98,165.13 36.79,165.32 36.79,165.58 36.98,165.77 43.86,165.77 44.05,165.96 44.05,166.23 43.82,166.46 37.6,166.46 37.46,166.6 37.46,166.75 37.3,166.9 36.96,166.9 36.81,166.75 36.81,166.6 36.67,166.46 36,166.46 35.86,166.6 35.86,166.77 35.72,166.91 35.35,166.91 35.21,166.77 35.21,166.6 35.07,166.46 34.7,166.46 34.56,166.6 34.56,166.77 34.42,166.91 34.06,166.91 33.92,166.77 33.92,166.6 33.78,166.46 33.41,166.46 33.27,166.6 33.27,166.77 33.13,166.91 32.76,166.91 32.62,166.77 32.62,166.6 32.48,166.46 32.11,166.46 31.97,166.6 31.97,166.77 31.83,166.91 31.47,166.91 31.33,166.77 31.33,166.6 31.19,166.46 v4(30.52,166.46) 30.11,166.46 29.88,166.23 29.88,165.69 29.65,165.46 29.32,165.46 29.09,165.69 29.09,166.68 29.06,166.68 28.79,166.96 27.64,166.96 27.19,166.5 27.19,162.39 28.02,161.56 28.02,161.18 27.7,160.87 27.7,160.36 28.11,159.96 UV7.A2
  BOTTOM w0.14: v2(45.97,157.96) 45.97,157.83 46.28,157.53 46.28,157.25 46.53,157 UV3.F9
FBA_D47: length 53.8
  TOP w0.14: v2(43.08,157.87) 43.06,157.88 43.06,157.88 43.01,157.93 43.01,160.72 42.3,161.43 31.21,161.43 31.02,161.62 31.02,161.89 31.21,162.08 42.16,162.08 42.35,162.27 42.35,162.54 42.16,162.73 v4(31.71,162.73) 31.01,162.73 30.82,162.92 30.82,163.18 31.01,163.37 31.34,163.37 31.53,163.56 31.53,163.83 31.34,164.02 30.54,164.02 30.06,163.53 30.06,159.49 28.36,157.8 27.51,157.8 26.88,158.43 26.88,158.73 UV7.C3
  BOTTOM w0.084: v2(43.08,157.87) 43.06,157.85 43.06,157.77 43.46,157.38 44.82,157.38 45.24,157.8 UV3.D8
FBA_D48: length 51.1
  BOTTOM w0.084: UV3.E7 45.75,158.59 45.75,158.28 45.6,158.13 44.38,158.13 44.34,158.08 43.92,158.08 43.78,158.22 42.92,158.22 42.68,157.98 42.68,157.37 42.62,157.31
  BOTTOM w0.14: 42.62,157.31 41.66,156.36 41.66,155.33 41.51,155.18 40.7,155.18 40.57,155.05 40.57,153.78 39.86,153.07 29.65,153.07 29.52,153.2 29.52,153.59 29.65,153.72 v4(33.88,153.72) 39.96,153.72 40.09,153.84 40.09,154.24 39.96,154.36 29.2,154.36 29.08,154.24 29.08,153.4 28.75,153.07 27.47,153.07 26.51,152.12 26.28,152.12 26.12,152.28 26.12,152.51 27.18,153.58 27.18,153.79 26.91,154.06 26.91,154.7 UV8.C2
FBA_D49: length 50.5
  BOTTOM w0.14: UV3.A7 43.98,158.75 42.28,158.75 41.8,158.27 41.8,157.85 41.67,157.72 41.25,157.72 40.65,157.12 40.65,156.6 40.45,156.4 34.73,156.4 34.54,156.59 34.54,156.85 34.73,157.04 39.96,157.04 40.09,157.17 40.09,157.57 39.96,157.69 31.95,157.69 31.76,157.88 31.76,158.15 31.95,158.34 40.88,158.34 41,158.47 41,158.86 40.88,158.99 v4(32.67,158.99) 31.95,158.99 29.39,156.43 28.33,156.43 28.18,156.29 28.18,155.97 UV8.A3
FBA_D50: length 50.7
  BOTTOM w0.084: UV3.C7 44.94,158.6 44.62,158.6 44.27,158.26 44.01,158.26 43.82,158.45 43.11,158.45
  BOTTOM w0.14: 43.11,158.45 42.64,158.45 42.27,158.08 42.27,157.5 41.93,157.16 41.41,157.16 41.14,156.89 41.14,156.15 40.97,155.98 40.19,155.98 40.01,155.8 40.01,154.92 39.82,154.73 29.13,154.73 28.94,154.92 28.94,155.19 29.13,155.38 39.17,155.38 39.36,155.57 39.36,155.84 39.17,156.03 30.83,156.03 30.64,156.22 30.64,156.49 30.83,156.68 v4(32.57,156.68) 33.97,156.68 34.16,156.87 34.16,157.13 33.97,157.32 30.8,157.32 30.1,156.62 30.1,156.17 29.97,156.03 29.16,156.03 28.23,155.1 UV8.A2
FBA_D51: length 51.3
  BOTTOM w0.084: 43.14,159.01 44.2,159.01 44.35,158.86 44.73,158.86 44.8,158.93 45.09,158.93 45.16,158.86 45.53,158.86 45.96,159.28 46.15,159.28 46.28,159.15 46.28,158.97 46.13,158.81 46.13,158.36 46.26,158.23 46.4,158.23 46.55,158.39 46.55,158.59 UV3.F7
  BOTTOM w0.14: UV8.C3 26.76,155.9 26.91,156.04 26.91,156.25 26.76,156.39 26.64,156.39 26.52,156.51 26.52,156.68 26.64,156.8 29.24,156.8 34.38,161.95 37.83,161.95 38.02,161.76 38.02,161.49 37.83,161.3 v4(37.17,161.3) 34.49,161.3 34.3,161.11 34.3,160.84 34.49,160.65 41.23,160.65 41.36,160.52 41.36,160.13 41.23,160 34.42,160 34.12,160.31 33.38,160.31 33.18,160.1 33.18,159.56 33.38,159.36 41.22,159.36 41.49,159.09 42.85,159.09 42.93,159.01 43.14,159.01
FBA_D52: length 49.9
  BOTTOM w0.14: UV8.A7 27.95,159.1 27.84,158.99 27.84,158.78 28.1,158.53 28.66,158.53 30.39,160.25 30.39,160.51 29.75,161.14 29.75,162.11 30.16,162.52 30.16,162.9 29.75,163.3 29.75,163.77 29.88,163.89 30.05,163.89 30.71,163.23 30.89,163.23 31.06,163.39 31.06,163.57 30.34,164.29 30.34,164.49 30.54,164.68 30.74,164.68 31.45,163.98 31.64,163.98 31.84,164.17 31.84,164.37 31.13,165.08 31.13,165.28 31.33,165.47 31.53,165.47 32.24,164.77 32.43,164.77 32.63,164.97 32.63,165.16 31.92,165.87 31.92,166.07 32.42,166.56 32.77,166.56 32.91,166.42 32.91,165.64 33.04,165.51 33.34,165.51 33.47,165.64 33.47,166.42 33.61,166.56 33.89,166.56 34.03,166.42 34.03,165.04 34.17,164.9 34.44,164.9 34.58,165.04 34.58,166.42 34.72,166.56 40.63,166.56 40.82,166.75 40.82,167.02 40.63,167.21 v4(37.98,167.21) 36.89,167.21 36.76,167.34 36.76,167.73 36.89,167.86 40.68,167.86 43.14,165.4 43.14,160.75 43.35,160.55 43.79,160.55 UV3.A5
FBA_D53: length 50.5
  BOTTOM w0.14: UV3.E5 46.11,160.57 46.11,161.31 45.96,161.46 45.55,161.46 45.4,161.62 45.4,162.75 44.89,163.25 44.89,163.45 45.28,163.83 45.28,164.03 45.08,164.23 44.88,164.23 44.44,163.79 44.13,163.79 43.96,163.95 43.96,165.62 42.94,166.64 42.94,166.84 43.6,167.5 43.6,167.72 43.36,167.96 43.14,167.96 42.48,167.3 42.28,167.3 42.02,167.56 42.02,167.76 42.94,168.67 42.94,168.89 42.47,169.35 42.26,169.35 41.38,168.48 41.19,168.48 40.93,168.74 40.93,168.94 41.43,169.44 41.43,169.7 41.27,169.87 39.45,169.87 39.3,169.72 39.3,168.77 39.15,168.61 38.79,168.61 38.65,168.75 38.65,169.72 38.51,169.86 38.15,169.86 38.01,169.72 38.01,168.75 37.87,168.61 32.49,168.61 31.68,169.42 31.5,169.42 31.1,169.03 30.91,169.03 v4(30.58,169.36) 30.25,169.68 30.03,169.68 29.79,169.44 29.79,169.22 30.45,168.57 30.45,168.37 30.19,168.11 29.99,168.11 29.43,168.66 29.22,168.66 28.98,168.42 28.98,168.21 29.53,167.65 29.53,167.45 28.91,166.83 28.91,166.35 28.56,166 28.56,165.51 28.68,165.39 28.89,165.39 28.96,165.31 28.96,164.73 28.83,164.6 28.43,164.6 28.3,164.47 28.3,163.99 28.43,163.86 28.84,163.86 28.96,163.74 28.96,163.28 28.84,163.15 28.43,163.15 28.3,163.02 28.3,162.52 28.43,162.39 28.83,162.39 28.96,162.26 28.96,160.71 28.81,160.56 28.55,160.56 28.29,160.31 28.29,160.31 28.28,160.3 27.49,160.3 27.31,160.12 UV8.B8
FBA_D54: length 49.8
  BOTTOM w0.14: UV8.C8 26.51,159.64 26.66,159.49 28.3,159.49 28.5,159.29 28.76,159.29 29.7,160.23 29.7,160.5 29.38,160.81 29.38,163.98 29.75,164.35 29.75,164.66 29.38,165.03 29.38,166.42 v4(30.32,167.35) 31.56,168.59 31.78,168.59 32.12,168.25 32.12,168.03 29.85,165.77 29.85,165.33 30.13,165.06 30.39,165.06 32.27,166.93 36.15,166.93 36.28,167.06 36.28,167.45 36.15,167.58 33.03,167.58 32.9,167.71 32.9,168.1 33.03,168.23 39.58,168.23 39.72,168.37 39.72,168.83 39.86,168.97 40.23,168.97 40.37,168.83 40.37,168.37 40.51,168.23 40.84,168.23 43.54,165.52 43.54,163.56 43.68,163.42 44.2,163.42 44.35,163.27 44.35,162.87 44.2,162.71 43.66,162.71 43.5,162.56 43.5,162.23 43.66,162.08 44.4,162.08 44.5,161.98 44.5,161.2 44.71,161 UV3.C3
FBA_D55: length 50
  BOTTOM w0.14: UV8.D7 26.11,159.49 26.11,161.09 25.64,161.56 25.64,162.19 25.88,162.43 25.88,162.83 25.74,162.97 25.08,162.97 24.93,163.12 24.93,163.47 25.08,163.62 25.74,163.62 25.88,163.76 25.88,166.38 25.68,166.58 24.9,166.58 24.75,166.73 24.75,167.14 24.9,167.29 26.27,167.29 26.42,167.44 26.42,167.58 26.58,167.73 27.08,167.73 27.24,167.58 27.24,166.68 27.39,166.53 27.85,166.53 28,166.68 28,167.05 28.15,167.2 28.4,167.2 28.55,167.35 28.55,168.23 28.41,168.37 27.82,168.37 27.67,168.52 27.67,168.86 27.82,169.01 28.41,169.01 28.55,169.15 v4(28.55,169.64) 28.55,170.08 28.79,170.31 29.41,170.31 29.65,170.08 31.72,170.08 32.67,169.13 36.7,169.13 37.8,170.24 40.55,170.24 40.67,170.35 40.67,170.73 40.81,170.87 41.18,170.87 41.32,170.73 41.32,170.4 41.48,170.24 41.85,170.24 41.99,170.38 41.99,170.78 42.13,170.92 42.5,170.92 42.64,170.78 42.64,169.89 42.91,169.62 44.79,169.62 44.94,169.46 44.94,168.84 44.79,168.69 44.13,168.69 44.01,168.56 44.01,166.19 44.33,165.87 44.33,165.56 45.75,164.14 45.75,161.81 UV3.E1
FBA_D56: length 47.5
  IN1 w0.14: v1(22.64,156.47) 22.51,156.61 21.34,156.61 20.78,156.05 20.78,154.95 20.93,154.8 21.4,154.8 21.55,154.95 21.55,155.68 21.81,155.94 23.2,155.94 23.33,156.08 24.59,156.08 24.94,155.72 26.42,155.72 26.55,155.86 26.55,156.15 26.69,156.29 27.06,156.29 27.2,156.15 27.2,155.86 27.34,155.72 27.83,155.72 28.17,156.05 28.17,156.74 32.34,160.92 32.34,161.19 32.15,161.38 31.89,161.38 30.09,159.59 29.88,159.59 29.63,159.83 29.63,160.05 31.7,162.11 37.28,162.11 37.47,161.92 37.47,161.65 37.28,161.46 36.67,161.46 36.48,161.27 36.48,161 36.67,160.81 43.92,160.81 45.6,159.13 46.38,159.13 46.66,159.42 47.33,159.42 47.72,159.03 v5(47.75,159.03)
  BOTTOM w0.14: UV3.G7 47.34,158.61 v5(47.75,159.03) ; UV8.H3 22.51,155.9 22.51,156.13 22.64,156.26 v1(22.64,156.47)
FBA_D57: length 46.9
  IN1 w0.14: v1(23.71,155.5) 23.71,155.48 24.14,155.04 24.82,155.04 25,155.21 29.1,155.21 32.26,158.38 33.63,159.74 33.63,160.01 33.44,160.2 33.17,160.2 29.24,156.28 29.03,156.28 28.79,156.52 28.79,156.74 29.06,157.01 30.75,158.7 33.71,161.67 35.35,161.67 35.47,161.55 35.47,161.28 35.28,161.09 34.38,161.09 34.12,160.83 34.12,160.56 34.31,160.37 42.86,160.37 43.06,160.17 43.06,160.01 42.87,159.82 42.34,159.82 42.15,159.63 42.15,159.39 42.33,159.21 45,159.21 45.52,158.69 46.37,158.69 46.7,159.01 v2(46.93,159.01)
  BOTTOM w0.14: UV8.G2 23.31,155.1 v1(23.71,155.5) ; v2(46.93,159.01) 47.31,159.4 UV3.G6
FBA_D58: length 46.2
  IN1 w0.14: v1(46.18,163.63) 44.99,163.63 40.99,167.63 33.74,167.63 33.56,167.81 33.56,168.08 33.75,168.27 38.58,168.27 38.77,168.46 38.77,168.73 38.58,168.92 33.18,168.92 28.77,164.51 28.77,162.94 28.52,162.69 26.49,162.69 25.76,161.96 25.76,159.15 25.32,158.71 24.65,158.71 24.42,158.48 24.2,158.48 23.88,158.81 23.88,159.02 24.36,159.5 v2(24.5,159.5)
  BOTTOM w0.14: UV8.F7 24.11,159.1 24.5,159.49 v2(24.5,159.5) ; v1(46.18,163.63) 46.18,163.47 47.2,162.45 47.2,161.94 UV3.G1
FBA_D59: length 46.9
  IN1 w0.14: v2(47.08,164.14) 47.08,164.32 46.88,164.52 46.16,164.52 45.78,164.14 45.12,164.14 41.14,168.13 39.42,168.13 39.29,168.26 39.29,168.53 39.48,168.72 39.83,168.72 40.02,168.91 40.02,169.17 39.83,169.36 32.99,169.36 32.07,168.44 30.24,168.44 28.24,166.44 28.24,166.17 28.43,165.98 28.7,165.98 30.55,167.84 30.82,167.84 31.01,167.65 31.01,167.38 28.06,164.43 26.64,164.43 26.45,164.24 26.45,163.91 26.58,163.78 28.09,163.78 28.27,163.59 28.27,163.31 28.1,163.14 26.29,163.14 24.79,161.63 v2(24.79,161.56)
  BOTTOM w0.14: v2(47.08,164.14) 47.08,163.04 47.6,162.52 47.6,162.18 47.75,162.03 47.75,161.64 47.34,161.23 UV3.G3 ; UV8.F8 24.49,160.28 24.49,161.27 v2(24.79,161.56)
FBA_D60: length 48
  IN1 w0.14: v1(25.25,156.81) 25.38,156.68 25.79,156.68 25.92,156.81 27.6,156.81 29.17,158.38 29.17,160.22 32.81,163.85 36.39,163.85 36.58,163.66 36.58,163.39 36.39,163.2 33.34,163.2 33.15,163.01 33.15,162.74 33.34,162.55 42.06,162.55 42.25,162.36 42.25,162.1 42.06,161.91 38.12,161.91 37.93,161.72 37.93,161.45 38.12,161.26 42.54,161.26 43.29,162.01 43.67,162.01 45.65,160.03 45.65,159.7 45.94,159.41 46.24,159.41 46.52,159.69 48.21,159.69 v2(48.41,159.89)
  BOTTOM w0.14: UV3.J6 48.87,159.4 48.41,159.86 v2(48.41,159.89) ; v1(25.25,156.81) 25.25,156.23 UV8.E3
FBA_D61: length 46.7
  IN1 w0.14: v1(22.07,159.52) 21.87,159.72 21.87,160.54 21.99,160.65 21.99,161.55 23.82,163.38 23.82,163.58 23.54,163.86 23.54,164.07 23.78,164.31 24,164.31 24.24,164.07 24.51,164.07 24.74,164.3 24.74,164.49 24.42,164.81 24.42,165.02 24.66,165.27 24.88,165.27 25.19,164.95 25.39,164.95 25.89,165.45 25.89,166.23 29.91,170.26 40.3,170.26 43.33,167.23 43.58,167.23 43.77,167.42 43.77,167.61 42.03,169.34 42.03,169.69 42.22,169.88 42.91,169.88 46.85,165.95 47,165.95 48.25,164.7 v1(48.25,163.47)
  BOTTOM w0.14: UV8.H7 22.09,159.52 v1(22.07,159.52) ; v1(48.25,163.47) 48.94,162.78 UV3.J1
FBA_D62: length 47.4
  IN1 w0.14: v5(47.57,164.62) 47.57,164.65 47.1,165.12 46.64,165.12 44.55,167.21 44.28,167.21 44.09,167.02 44.09,166.75 45.72,165.12 45.72,164.85 45.53,164.66 45.26,164.66 40.11,169.81 32.25,169.81 32.11,169.67 32.11,169.16 31.97,169.02 31.6,169.02 31.46,169.16 31.46,169.67 31.32,169.81 30.98,169.81 27.19,166.02 27.18,166.02 27.18,165.7 26.06,164.58 25.66,164.58 25.4,164.32 25.4,164.12 25.82,163.7 25.82,163.48 25.58,163.24 25.36,163.24 24.96,163.65 24.72,163.65 24,162.92 24,162.75 24.21,162.54 24.21,162.3 23.81,161.9 23.62,161.9 23.4,162.12 23.2,162.12 22.44,161.36 22.44,159.87 22.81,159.5 v2(22.96,159.5)
  BOTTOM w0.14: UV3.J3 48.54,161.4 48.54,161.99 48.66,162.11 48.66,162.45 48.06,163.05 47.84,163.05 47.57,163.32 v5(47.57,164.62) ; v2(22.96,159.5) 22.91,159.5 UV8.H8
FBA_D63: length 47.3
  IN1 w0.14: v1(24.35,153.66) 24.35,153.94 24.09,154.2 24.09,154.4 24.27,154.58 24.63,154.58 24.99,154.21 26.02,154.21 26.17,154.37 26.17,154.61 26.31,154.75 26.68,154.75 26.82,154.61 26.82,154.15 26.97,153.99 27.38,153.99 27.6,154.21 28,154.21 28.15,154.07 28.58,154.07 33.14,158.63 40.58,158.63 40.77,158.82 40.77,159.09 40.58,159.28 34.31,159.28 34.12,159.47 34.12,159.74 34.31,159.93 40.9,159.93 41.97,158.85 44.49,158.85 44.98,158.36 46.51,158.36 46.75,158.61 48.78,158.61 49.35,159.18 v2(49.35,159.79)
  BOTTOM w0.14: v1(24.35,153.66) 24.48,153.8 24.48,154.72 UV8.F2 ; v2(49.35,159.79) 48.95,160.2 UV3.J5
FBA_DQM0: length 46.1
  IN3 w0.14: v1(45.21,136.23) 45.5,135.94 45.5,132.91 45.69,132.72 45.96,132.72 46.14,132.91 46.14,136.48 46.3,136.64 46.64,136.64 46.79,136.48 46.79,132.72 45.29,131.21 39.78,131.21 39.64,131.07 39.64,130.43 39.5,130.29 39.13,130.29 39,130.43 39,131.07 38.86,131.21 31.73,131.21 29,133.94 28.42,133.94 28.21,134.14 28.21,134.73 28.21,135.02 27.87,135.36 27.87,135.73 28.21,136.07 28.21,136.73 27.7,137.24 26.75,137.24 26.44,137.55 26.42,137.55 v2(26.22,137.75)
  BOTTOM w0.14: UV3.E32 45.74,138.65 45.21,138.12 v1(45.21,136.23) ; v2(26.22,137.75) 26.22,137.75 26.22,138.58 26.07,138.73 25.34,138.73 UV5.E7
FBA_DQM1: length 50.4
  TOP w0.14: UV6.D3 26.12,139.56 26.12,141.16 26.09,141.18 26.09,141.56 26.11,141.58 26.11,142.19 25.89,142.41 25.89,142.44 25.32,143.01 25.32,146.25 25.66,146.59 26.2,146.59 26.37,146.41 28.92,146.41 29.12,146.61 29.12,146.88 28.92,147.07 24.09,147.07 23.88,147.28 23.88,148.17 24.09,148.37 26.04,148.37 26.25,148.17 26.25,147.96 26.45,147.76 29.68,147.76 v4(31.9,149.98) 32.4,150.48 40.13,150.48 43.05,147.56 45.19,147.56 45.46,147.29 45.46,143.19 45.33,143.05 44.86,143.05 44.66,142.85 44.66,141.58 44.86,141.38 v2(45.37,141.38)
  BOTTOM w0.102: UV3.E30 45.73,141 45.4,141.33 45.4,141.35 v2(45.37,141.38)
FBA_DQM2: length 47.2
  TOP w0.14: UV6.E7 25.38,136.43 v1(26.13,136.43)
  IN1 w0.14: v1(41.84,146.55) 42.48,146.55 43.41,145.62 43.93,145.62 44.36,145.19 44.36,143.23 44.02,142.88 44.02,142.14 43.38,141.5 43.38,140.47 43.24,140.33 43.02,140.33 42.88,140.19 42.88,139.82 43.02,139.68 43.24,139.68 43.38,139.54 43.38,139.17 43.24,139.03 43.02,139.03 42.88,138.89 42.88,138.52 43.02,138.38 43.24,138.38 43.38,138.24 43.38,138.02 43.63,137.77 43.63,134.69 40.8,131.86 33.78,131.86 33.59,131.67 33.59,131.4 33.78,131.21 36.27,131.21 36.46,131.02 36.46,130.75 36.27,130.56 33.25,130.56 28.03,135.79 26.77,135.79 v1(26.13,136.43)
  BOTTOM w0.102: v1(41.84,146.55) 42.02,146.73 42.8,146.73 43.3,147.24 43.98,147.24 UV3.A21
FBA_DQM3: length 52.3
  BOTTOM w0.084: 42.64,147.07 42.79,147.07 43.28,147.57 43.75,147.57 43.91,147.73 44.29,147.73 44.3,147.71 44.33,147.71 44.44,147.61 44.73,147.61 UV3.C21
  BOTTOM w0.14: 42.64,147.07 41.7,147.07 41.38,146.76 41.38,145.67 39.27,143.55 35.28,143.55 32.34,140.61 32.34,136.18 34.98,133.53 37.21,133.53 38.23,132.51 38.23,128.8 v4(37.95,128.51) 37.68,128.24 27.5,128.24 26.88,128.86 26.04,128.86 25.55,129.35 25.55,132.48 26.12,133.04 26.12,135.55 UV5.D3
FBA_DQM4: length 48.4
  TOP w0.14: v1(26.1,156.34) 26.09,156.34 26.07,156.36 25.37,156.36 UV7.E7
  IN3 w0.14: v1(26.1,156.34) 26.13,156.31 26.85,156.31 27.37,156.83 29.91,156.83 35.01,161.92 40.38,161.92 40.57,161.73 40.57,161.46 40.38,161.27 35.38,161.27 35.19,161.08 35.19,160.81 35.38,160.62 40.71,160.62 40.9,160.43 40.9,160.17 40.71,159.98 37.31,159.98 37.13,159.8 37.13,159.51 37.28,159.36 40.68,159.36 41.01,159.03 41.01,158.02 40.79,157.81 40.79,155 v1(41.14,154.65)
  BOTTOM w0.084: v1(41.14,154.65) 41.21,154.58 41.3,154.58 41.68,154.21 42.56,154.21 42.59,154.24 43.75,154.24 arc(43.81,154.25) 43.86,154.28 arc(43.92,154.33) 43.99,154.34 44.22,154.34 arc(44.24,154.34) 44.26,154.33 44.39,154.28 arc(44.46,154.26) 44.52,154.25 45.27,154.25 45.72,153.8 UV3.E13
FBA_DQM5: length 54.3
  TOP w0.14: UV7.D3 25.71,159.38 25.83,159.5 27.44,159.5 27.45,159.49 27.47,159.49 27.7,159.26 27.7,159.24 27.71,159.23 27.71,158.9 27.96,158.66 28.7,158.66 29.69,159.65 29.69,163.68 30.39,164.39 39.19,164.39 39.38,164.2 39.38,163.93 39.19,163.74 v4(37.36,163.74) 32.12,163.74 31.93,163.55 31.93,163.28 32.12,163.09 42.66,163.09 44.28,161.47 44.28,158.46 45.11,157.63 45.12,157.65 45.56,157.2 46.03,157.2 46.53,156.7 46.53,156.1 46.43,156 46.43,155.63 46.17,155.37 43.76,155.37 43,154.61 43,154.61 42.99,154.6 43,154.6 v2(43,154.61)
  BOTTOM w0.084: v2(43,154.61) 43,154.6 43.02,154.62 43.07,154.62 43.49,155.04 44.89,155.04 UV3.D12
FBA_DQM6: length 50.2
  BOTTOM w0.084: 43.1,159.38 43.29,159.19 44.27,159.19 44.42,159.04 44.65,159.04 44.71,159.11 45.17,159.11 45.25,159.04 45.44,159.04 45.73,159.32 45.73,159.62 45.58,159.77 45.52,159.77 45.37,159.92 45.37,160.33 45.47,160.43 45.47,160.66 45.37,160.76 45.37,161.11 45.45,161.2 45.54,161.2 UV3.E3
  BOTTOM w0.14: 43.1,159.38 43.02,159.45 41.97,159.45 41.84,159.58 41.84,160.89 41.72,161.02 38.59,161.02 38.4,161.21 38.4,161.48 38.59,161.67 41.72,161.67 41.84,161.79 41.84,162.19 41.72,162.31 35.69,162.31 35.57,162.44 35.57,162.84 35.69,162.96 41.72,162.96 41.84,163.09 41.84,163.48 41.72,163.61 35.53,163.61 v4(34.65,162.73) 29.14,157.22 26.84,157.22 26.45,157.61 25.91,157.61 25.75,157.46 25.75,156.68 25.64,156.57 25.64,155.96 UV8.D3
FBA_DQM7: length 46.5
  IN1 w0.14: v2(26.12,158.7) 26.48,159.05 27.17,159.05 27.32,159.21 27.32,159.55 27.17,159.7 26.39,159.7 26.23,159.85 26.23,160.2 26.39,160.35 27.09,160.35 27.24,160.5 27.24,160.85 27.09,161.01 26.46,161.01 26.31,161.16 26.31,161.67 26.81,162.17 28.89,162.17 32.78,166.06 32.78,166.33 32.59,166.52 32.32,166.52 29.7,163.9 29.43,163.9 29.24,164.09 29.24,164.34 32.08,167.18 40.78,167.18 41.09,166.87 41.09,166.67 40.34,165.92 40.34,165.62 40.53,165.43 40.78,165.43 41.55,166.21 41.75,166.21 45.52,162.44 46.67,162.44 46.67,162.41 v2(46.65,162.41)
  BOTTOM w0.14: UV3.F4 46.54,160.76 46.98,161.2 46.98,161.59 46.89,161.67 46.89,162.17 v2(46.65,162.41) ; UV8.E7 25.31,158.7 v2(26.12,158.7)
FBA_DQS0: length 47.5
  IN3 w0.14: v1(24.32,137.1) 24.12,136.9 24.12,136.4 24.23,136.29 25.57,136.29 26.14,135.72 26.14,133.65 26.97,132.82 28.56,132.82 31.34,130.04 34.18,130.04 34.53,129.7 34.53,129.01 34.72,128.81 35,128.81 35.2,129.01 35.2,129.75 35.48,130.03 36.05,130.03 36.33,129.75 36.33,128.96 36.47,128.82 36.84,128.82 36.97,128.96 36.97,129.75 37.26,130.03 37.82,130.03 38.11,129.75 38.11,128.96 38.24,128.82 44.45,128.82 48.25,132.63 48.25,134.78 47.97,135.07 47.97,141.04 47.43,141.57 47.43,141.77 v2(47.23,141.96)
  BOTTOM w0.102: v1(24.32,137.1) 24.11,136.9 24.11,136.6 23.71,136.19 23.71,136.09 23.84,135.96 UV5.F3
  BOTTOM w0.127: UV3.H28 47.4,141.8 v2(47.23,141.96)
FBA_DQS1: length 51.3
  TOP w0.127: v2(42.83,142.2) 42.99,142.04 42.99,141.41 43.29,141.11 43.87,141.11 44.08,140.91 44.08,140.07 43.87,139.87 42.85,139.87 42.61,139.64 42.61,136.33 39.59,133.31 35.4,133.31 32.05,136.66 32.05,141.15 32.21,141.31 33.05,141.31 33.38,141.64 33.38,142.19 33.05,142.53 32.1,142.53 31.91,142.72 31.91,142.99 32.1,143.18 32.92,143.18 32.95,143.15 33.54,143.15 33.56,143.18 34.26,143.18 34.6,143.51 34.6,144.05 34.26,144.38 v1(31.82,144.38) 31.17,144.38 30.8,144.02 30.8,137.7 30.16,137.06 27.18,137.06 26.68,136.55 26.68,136.13 UV6.C7
  BOTTOM w0.102: v2(42.83,142.2) 42.95,142.2 43.24,141.91 43.8,141.91 43.83,141.94 44,142.12 44.2,142.12 44.69,142.6 44.94,142.6 UV3.C27
FBA_DQS2: length 47.5
  TOP w0.127: v1(25.08,138.09) 24.82,138.35 24.82,138.51 24.55,138.78 23.91,138.78 23.83,138.87 23.83,139.09 23.9,139.16 UV6.F3
  IN1 w0.14: v1(41.42,143.21) 41.32,143.21 41.22,143.32 41.22,143.69 40.9,144 40.31,144 39.94,143.63 39.94,142.28 41.94,140.28 41.94,137.91 42.22,137.63 42.45,137.63 42.59,137.49 42.59,137.12 42.45,136.98 42.08,136.98 41.75,136.65 41.75,136.18 42.08,135.85 42.46,135.85 42.65,135.66 42.65,135.39 42.46,135.2 42.22,135.2 41.94,134.92 41.94,134.27 40.44,132.77 40.17,132.77 39.98,132.96 39.98,133.23 41.23,134.47 41.23,134.94 40.9,135.27 40.43,135.27 37.9,132.75 32.33,132.75 32.02,133.05 32.02,133.19 31.72,133.49 31.58,133.49 31.27,133.8 31.27,133.94 30.97,134.24 30.83,134.24 30.53,134.55 30.53,134.68 30.22,134.99 30.09,134.99 29.78,135.29 29.78,135.43 29.47,135.74 29.34,135.74 29.03,136.04 29.03,136.18 28.73,136.48 28.59,136.48 27.79,137.29 27.14,137.29 27.04,137.38 26.61,137.38 26.51,137.29 25.73,137.29 25.43,137.59 25.05,137.59 24.87,137.76 24.87,137.93 25.03,138.09 v1(25.08,138.09)
  BOTTOM w0.084: 42.49,145.59 42.5,145.6 42.5,145.64 42.88,146.02 44.08,146.02 44.14,145.96 UV3.A23
  BOTTOM w0.127: v1(41.42,143.21) 41.03,143.61 41.03,144.13 v1(41.43,144.53) 42.49,145.59
FBA_DQS3: length 53.5
  BOTTOM w0.084: UV3.E19 45.27,149.47 45.19,149.47 45.11,149.55 44.77,149.55 44.68,149.47 44.39,149.47 44.3,149.56 43.8,149.56 43.67,149.43 42.75,149.43 42.64,149.32 42.35,149.32 42.32,149.35 42.3,149.35
  BOTTOM w0.127: UV5.C7 26.9,139.55 27.48,139.55 27.71,139.32 27.71,139.09 27.72,139.07 27.72,137.99 27.9,137.82 29.92,137.82 30.12,138.02 30.12,143.95 34.81,148.64 35.18,148.64 35.59,148.24 35.59,147.87 31.04,143.33 31.04,143.06 31.23,142.88 31.49,142.88 38.08,149.47 38.54,149.47 38.86,149.15 38.86,148.7 36.48,146.32 36.48,146.06 36.67,145.87 36.93,145.87 37.56,146.5 37.93,146.5 38.35,146.08 38.53,146.08 38.8,146.35 38.8,146.53 38.38,146.95 38.38,147.32 38.81,147.75 38.81,147.8 39.24,148.23 39.28,148.23 40.41,149.35 v1(41.26,149.35) 42.3,149.35
FBA_DQS4: length 49
  TOP w0.114: v1(25.44,158.13) 25.36,158.13 24.77,158.72 24.25,158.72 24.11,158.85 UV7.F3
  IN3 w0.14: v1(25.44,158.13) 25.31,157.99 25.31,157.73 25.82,157.22 26.5,157.22 27.01,157.73 29.56,157.73 32.13,160.3 32.13,160.57 31.94,160.76 31.67,160.76 29.36,158.44 28.89,158.44 28.56,158.77 28.56,159.24 31.44,162.12 33.95,162.12 34.91,163.07 34.91,163.73 35.19,164.01 35.75,164.01 36.04,163.73 36.04,163.07 36.18,162.94 36.54,162.94 36.68,163.07 36.68,163.73 36.96,164.01 37.53,164.01 37.81,163.73 37.81,163.07 37.95,162.94 40.77,162.94 42.08,161.63 42.08,156.86 41.68,156.46 41.68,155.94 42.57,155.05 42.57,154.02 42.22,153.67 42.22,153.12 42.32,153.02 v2(42.5,153.02)
  BOTTOM w0.084: UV3.E15 45.29,152.65 44.45,152.65 44.26,152.73 44.01,152.73 arc(43.93,152.71) 43.87,152.67 43.77,152.57 42.34,152.57 42.17,152.74 42.17,152.89 42.3,153.02 v2(42.5,153.02)
