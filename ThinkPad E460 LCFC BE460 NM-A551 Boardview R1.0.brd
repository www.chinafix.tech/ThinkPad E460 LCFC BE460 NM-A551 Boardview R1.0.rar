# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D52: length 57.6
  IN3 w0.076: 129.64,124.22 129.08,123.65 123.76,123.65 121.78,121.68 121.32,121.68 120.22,120.57 118.43,120.57 118.22,120.78 117.17,120.78 116.8,121.15 v2(116.73,121.15)
  IN3 w0.114: v1(155.4,142.99) 154.96,142.55 151.7,142.55 151.59,142.66 151.59,142.99 151.47,143.11 151.24,143.11 151.13,142.99 151.13,142.66 151.02,142.55 150.79,142.55 150.67,142.66 150.67,142.99 150.56,143.11 150.33,143.11 150.22,142.99 150.22,142.66 150.1,142.55 146.79,142.55 146.68,142.44 146.68,142.28 146.92,142.04 146.92,141.88 146.75,141.72 146.59,141.72 146.36,141.95 146.2,141.95 146.03,141.79 146.03,141.63 146.27,141.4 146.27,141.23 146.11,141.07 145.95,141.07 145.71,141.31 145.55,141.31 143.61,139.37 143.61,138.56 143.33,138.28 142.52,138.28 139.96,135.72 139.81,135.72 138.7,134.61 138.7,133.65 136.35,131.3 134.88,129.83 134.88,129.08 131.76,125.96 131.01,125.96 129.64,124.6 129.64,124.22
  BOTTOM w0.076: UC1.AP27 v2(116.73,121.15)
  BOTTOM w0.114: JDIMM2.164 156.75,141.65 v1(155.4,142.99)
DDR_B_D53: length 57.7
  IN3 w0.076: v5(116.09,121.15) 116.09,121.14 116.62,120.61 118.16,120.61 118.37,120.4 120.35,120.4 121.46,121.51 122.07,121.51 123.88,123.32 129.22,123.32 129.29,123.4
  IN3 w0.114: v1(156.56,143) 156.56,142.53 156.25,142.22 147.73,142.22 146.02,140.51 145.86,140.51 145.63,140.74 145.47,140.74 145.31,140.57 145.31,140.41 145.54,140.18 145.54,140.02 145.38,139.86 145.21,139.86 144.99,140.09 144.82,140.09 144.66,139.93 144.66,139.77 144.89,139.54 144.89,139.38 144.73,139.21 144.57,139.21 144.34,139.44 144.18,139.44 144.02,139.28 144.02,139.12 144.24,138.89 144.24,138.73 143.27,137.75 143.11,137.75 142.93,137.93 142.77,137.93 142.61,137.77 142.61,137.61 142.79,137.43 142.79,137.27 142.63,137.11 141.82,137.11 140.1,135.39 139.94,135.39 139.03,134.47 139.03,133.51 136.02,130.5 135.21,129.69 135.21,128.94 131.9,125.63 131.14,125.63 129.91,124.39 129.91,124.02 129.29,123.4
  BOTTOM w0.076: UC1.AN27 v5(116.09,121.15)
  BOTTOM w0.114: JDIMM2.166 157.31,142.25 v1(156.56,143)
DDR_B_D54: length 57.2
  IN3 w0.076: 124.63,126.91 122.79,125.07 122,125.07 119.75,122.82 118.35,122.82 118.12,122.59 116.69,122.59 116.15,122.06 v2(116.09,122.06)
  IN3 w0.114: 124.63,126.91 127.47,126.91 133.87,133.3 133.87,134.87 134.52,135.52 134.52,136 145.35,146.82 155.77,146.82 156.02,146.58 156.02,146.28 155.9,146.16 v1(155.19,146.16)
  BOTTOM w0.076: UC1.AN25 v2(116.09,122.06)
  BOTTOM w0.114: v1(155.19,146.16) 156.71,144.65 JDIMM2.174
DDR_B_D55: length 56.8
  IN3 w0.076: v2(116.73,122.06) 116.8,122.06 117.17,122.43 118.22,122.43 118.43,122.63 119.88,122.63 122.1,124.85 122.8,124.85 124.54,126.59 125.35,126.59
  IN3 w0.114: v1(156.48,146.18) 156.48,145.36 156.16,145.04 155.54,145.04 154.09,146.49 145.48,146.49 145.23,146.24 145.23,146.07 145.35,145.95 145.35,145.79 145.19,145.63 145.03,145.63 144.9,145.75 144.74,145.75 144.58,145.59 144.58,145.43 144.7,145.3 144.7,145.14 144.54,144.98 144.38,144.98 144.26,145.1 144.09,145.1 134.85,135.86 134.85,135.38 134.2,134.73 134.2,133.17 127.62,126.59 125.35,126.59
  BOTTOM w0.076: UC1.AP25 v2(116.73,122.06)
  BOTTOM w0.114: JDIMM2.176 157.41,145.25 v1(156.48,146.18)
DDR_B_D56: length 59
  IN3 w0.076: 125.49,128.13 124.43,128.13 123.55,127.26 123.55,126.65 122.46,125.55 121.7,125.55 119.61,123.46 118.57,123.46 118.14,123.89 v2(118,123.89)
  IN3 w0.114: v1(154.15,148.48) 153.78,148.11 151.36,148.11 151.24,148.22 151.24,148.53 151.13,148.64 150.9,148.64 150.79,148.53 150.79,148.22 150.67,148.11 150.44,148.11 150.33,148.22 150.33,148.53 150.22,148.64 149.99,148.64 149.87,148.53 149.87,148.22 149.76,148.11 148.37,148.11 148.25,148.22 148.25,148.56 148.14,148.67 147.91,148.67 147.8,148.56 147.8,148.22 147.68,148.11 147.45,148.11 147.34,148.22 147.34,148.56 147.22,148.67 147,148.67 146.88,148.56 146.88,148.22 146.77,148.11 144.77,148.11 134.3,137.63 132.48,137.63 131.87,137.02 129.85,137.02 129.4,136.57 129.4,130.65 126.88,128.13 125.49,128.13
  BOTTOM w0.076: v2(118,123.89) 117.71,124.27 UC1.AT22
  BOTTOM w0.114: v1(154.15,148.48) 152.43,146.75 JDIMM2.181
DDR_B_D57: length 58.5
  IN3 w0.076: v2(118.65,123.89) 118.74,123.79 119.72,123.79 121.63,125.71 122.39,125.71 123.35,126.67 123.35,127.34 124.52,128.5 125.49,128.5
  IN3 w0.114: v1(152.87,148.54) 152.43,148.99 149.34,148.99 149.07,148.71 148.68,148.71 148.37,149.01 146.49,149.01 146.37,148.9 146.37,148.56 146.26,148.45 146.03,148.45 145.91,148.56 145.91,148.9 145.8,149.01 145.22,149.01 144.43,148.23 144.27,148.23 144.11,148.38 143.95,148.38 143.79,148.22 143.79,148.06 143.94,147.9 143.94,147.74 143.78,147.58 143.62,147.58 143.46,147.73 143.3,147.73 143.14,147.57 143.14,147.41 143.3,147.26 143.3,147.09 142.49,146.29 142.33,146.29 142.17,146.44 142.01,146.44 141.85,146.28 141.85,146.12 142,145.96 142,145.8 141.84,145.64 141.68,145.64 141.52,145.79 141.36,145.79 141.2,145.63 141.2,145.47 141.36,145.32 141.36,145.15 141.19,144.99 141.03,144.99 140.88,145.15 140.72,145.15 140.55,144.99 140.55,144.82 140.71,144.67 140.71,144.51 140.55,144.35 140.39,144.35 140.23,144.5 140.07,144.5 139.91,144.34 139.91,144.18 140.06,144.02 140.06,143.86 139.9,143.7 139.74,143.7 139.58,143.85 139.42,143.85 139.26,143.69 139.26,143.53 139.42,143.38 139.42,143.21 138.83,142.63 138.67,142.63 138.51,142.79 138.35,142.79 138.19,142.63 138.19,142.47 138.35,142.31 138.35,142.15 134.17,137.96 132.34,137.96 131.73,137.35 129.72,137.35 129.07,136.71 129.07,130.79 126.79,128.5 125.49,128.5
  BOTTOM w0.076: UC1.AU22 118.36,124.27 v2(118.65,123.89)
  BOTTOM w0.114: v1(152.87,148.54) 152.87,148.43 151.79,147.35 JDIMM2.183
DDR_B_D58: length 57.6
  IN3 w0.076: 125.66,129.42 124.34,129.42 122.47,127.54 122.47,126.65 122.16,126.34 121.25,126.34 120.01,125.1 118.95,125.1 v2(118.65,124.8)
  IN3 w0.114: v1(153.49,151.21) 153.26,151.21 152.51,150.46 143.89,150.46 143.64,150.21 143.48,150.21 143.24,150.44 142.98,150.44 142.87,150.33 142.87,150.17 143.16,149.88 143.16,149.72 142.49,149.05 142.33,149.05 142.28,149.1 142.12,149.1 141.96,148.93 141.96,148.77 142,148.73 142,148.57 141.84,148.41 141.68,148.41 141.59,148.49 141.38,148.49 141.24,148.36 141.24,148.19 141.36,148.08 141.36,147.92 141.19,147.76 141.03,147.76 140.94,147.85 140.78,147.85 140.62,147.69 140.62,147.52 140.71,147.44 140.71,147.27 140.55,147.11 140.39,147.11 140.3,147.2 140.14,147.2 139.97,147.04 139.97,146.88 140.06,146.79 140.06,146.63 139.9,146.47 139.74,146.47 139.65,146.55 139.49,146.55 139.33,146.39 139.33,146.23 139.42,146.14 139.42,145.98 135.74,142.3 135.74,141.58 133.57,139.41 131.74,139.41 131.13,138.8 129.12,138.8 127.63,137.3 127.63,131.39 125.66,129.42
  BOTTOM w0.076: UC1.AU21 v2(118.65,124.8)
  BOTTOM w0.114: JDIMM2.191 152.04,149.75 v1(153.49,151.21)
DDR_B_D59: length 58.3
  IN3 w0.076: v2(118,124.8) 118.08,124.8 118.54,125.27 119.95,125.27 124.43,129.75 125.52,129.75
  IN3 w0.114: v1(152.63,151.22) 152.19,150.79 142.56,150.79 142.35,150.58 142.35,149.79 141.43,148.88 141.09,148.88 141.02,148.95 140.86,148.95 140.69,148.79 140.69,148.63 140.81,148.51 140.81,148.35 140.65,148.19 140.49,148.19 140.37,148.3 140.21,148.3 140.05,148.14 140.05,147.98 140.17,147.86 140.17,147.7 140.01,147.54 139.84,147.54 139.72,147.66 139.56,147.66 139.4,147.5 139.4,147.33 139.52,147.22 139.52,147.05 139.3,146.83 138.56,146.83 138.11,146.38 138.11,146.21 138.56,145.76 138.56,145.6 138.4,145.44 138.24,145.44 137.78,145.89 137.62,145.89 137.46,145.73 137.46,145.57 137.91,145.12 137.91,144.96 137.75,144.79 137.59,144.79 137.14,145.24 136.98,145.24 136.5,144.77 136.5,143.7 135.41,142.61 135.41,141.71 133.43,139.74 131.61,139.74 130.99,139.13 128.98,139.13 127.26,137.4 127.26,131.48 125.52,129.75
  BOTTOM w0.076: UC1.AT21 v2(118,124.8)
  BOTTOM w0.114: v1(152.63,151.22) 151.76,150.35 JDIMM2.193
DDR_B_D60: length 60.2
  IN3 w0.076: v5(116.09,123.89) 116.63,123.36 118.21,123.36 118.49,123.08 119.68,123.08 121.83,125.23 122.59,125.23 124.88,127.51 125.52,127.51
  IN3 w0.114: v1(155.03,148.45) 155.03,147.86 154.62,147.45 145.05,147.45 133.96,136.36 132.63,136.36 132.45,136.19 132.45,135.93 132.61,135.78 133.02,135.78 133.13,135.67 133.13,135.44 133.02,135.32 132.61,135.32 132.45,135.17 132.45,134.94 132.57,134.83 133.08,134.83 133.2,134.71 133.2,134.41 133.08,134.3 132.96,134.3 132.84,134.18 132.84,133.96 132.96,133.84 133.08,133.84 133.2,133.73 133.2,133.51 132.94,133.25 132.78,133.25 132.66,133.37 132.5,133.37 132.33,133.21 132.33,133.05 132.45,132.93 132.45,132.77 127.2,127.51 125.52,127.51
  BOTTOM w0.076: v5(116.09,123.89) UC1.AN22
  BOTTOM w0.114: JDIMM2.180 157.5,146.45 157.24,146.71 156.44,146.71 155.03,148.12 v1(155.03,148.45)
DDR_B_D61: length 59.9
  IN3 w0.076: v2(116.73,123.89) 117.09,123.53 118.27,123.53 118.54,123.25 119.63,123.25 121.77,125.39 122.52,125.39 123.74,126.6 123.74,126.91 124.66,127.84 125.6,127.84
  IN3 w0.114: v1(155.72,148.46) 155.26,148.92 154.87,148.92 154.59,148.64 154.59,148.17 154.2,147.78 144.91,147.78 133.83,136.69 129.99,136.69 129.73,136.43 129.73,132.22 129.85,132.1 130.53,132.1 130.65,131.99 130.65,131.76 130.53,131.65 129.86,131.65 129.73,131.52 129.73,131.29 129.85,131.18 129.92,131.18 130.04,131.06 130.04,130.83 129.92,130.72 129.85,130.72 129.73,130.61 129.73,130.51 127.05,127.84 125.6,127.84
  BOTTOM w0.076: UC1.AP22 116.41,124.27 v2(116.73,123.89)
  BOTTOM w0.114: JDIMM2.182 157.12,147.05 v1(155.72,148.46)
DDR_B_D62: length 59.4
  IN3 w0.076: 125.34,130.03 124.48,130.03 119.96,125.5 118.54,125.5 118.24,125.2 117.13,125.2 v2(116.73,124.8)
  IN3 w0.114: 125.34,130.03 126.88,131.58 126.88,137.49 128.85,139.46 130.61,139.46 132.09,140.93 133.26,140.93 133.54,141.21 133.71,141.21 133.84,141.08 134,141.08 134.16,141.24 134.16,141.41 134.03,141.54 134.03,141.7 134.19,141.86 134.35,141.86 134.48,141.73 134.64,141.73 134.81,141.89 134.81,142.05 134.68,142.18 134.68,142.34 136.17,143.84 136.17,144.9 142.38,151.12 150.95,151.12 151.51,151.68 153.93,151.68 v1(154.42,151.2)
  BOTTOM w0.076: UC1.AP21 v2(116.73,124.8)
  BOTTOM w0.114: JDIMM2.192 157.48,150.05 157.12,150.41 155.2,150.41 v1(154.42,151.2)
DDR_B_D63: length 60.4
  IN3 w0.076: 125.07,130.23 124.46,130.23 119.96,125.73 118.53,125.73 118.17,125.37 116.66,125.37 116.09,124.8 v2(116.09,124.8)
  IN3 w0.114: 125.07,130.23 126.55,131.71 126.55,137.63 128.71,139.79 130.47,139.79 131.95,141.26 133.13,141.26 135.84,143.97 135.84,145.04 142.29,151.49 148.94,151.49 149.06,151.6 149.06,151.84 149.17,151.96 149.4,151.96 149.52,151.84 149.52,151.6 149.63,151.49 149.86,151.49 149.97,151.6 149.97,151.84 150.09,151.96 150.32,151.96 150.43,151.84 150.43,151.6 150.54,151.49 150.79,151.49 151.36,152.06 154.03,152.06 154.41,151.68 154.8,151.68 v1(155.29,151.19)
  BOTTOM w0.076: UC1.AN21 v2(116.09,124.8)
  BOTTOM w0.114: v1(155.29,151.19) 155.61,150.87 157.38,150.87 157.6,150.65 JDIMM2.194
DDR_B_DQS0: length 67.5
  IN3 w0.114: v1(155.37,93.13) 155.16,92.92 155.16,92.75 154.65,92.24 152.74,92.24 147.92,87.42 147.92,86.6 143.76,82.45 115.87,82.45 111.49,86.83 111.49,90.38 111.75,90.64 111.75,94.53 111.98,94.77 112.09,94.77 v2(112.38,95.06)
  BOTTOM w0.076: v2(112.38,95.06) 112.63,94.81 112.74,94.81 112.83,94.9 112.83,96.58 112.88,96.68 112.88,96.84 112.84,96.95 112.84,97.08 112.84,97.09 112.84,97.22 112.87,97.3 112.87,97.55 112.84,97.74 112.81,97.77 112.65,97.77 112.6,97.73 UC1.AG70
  BOTTOM w0.114: JDIMM2.12 157.4,93.65 157.26,93.51 156.7,93.51 155.8,92.62 155.49,92.62 155.37,92.73 v1(155.37,93.13)
DDR_B_DQS1: length 64.1
  IN3 w0.076: v2(113.62,100.65) 113.62,100.46 113.72,100.35 114.01,100.35 114.11,100.26 114.18,100.18 114.18,98.81 116.22,96.79 116.22,96.75
  IN3 w0.114: v1(154.53,99.41) 154.83,99.41 154.97,99.27 154.97,99.09 154.75,98.87 152.89,98.87 142.5,88.48 142.34,88.48 142.23,88.59 142.23,88.89 142,89.12 141.44,89.12 141.21,88.89 141.21,88.28 141.09,88.17 140.7,88.17 140.59,88.28 140.59,88.89 140.36,89.12 139.8,89.12 139.57,88.89 139.57,88.59 139.45,88.48 139.06,88.48 138.94,88.59 138.94,88.89 138.71,89.12 138.16,89.12 137.93,88.89 137.93,88.59 137.81,88.48 137.24,88.48 136.92,88.16 136.57,88.16 136.25,88.48 135.6,88.48 135.35,88.23 134.86,88.23 134.61,88.48 133.96,88.48 133.71,88.23 133.22,88.23 132.97,88.48 132.32,88.48 132.07,88.23 131.58,88.23 131.33,88.48 130.67,88.48 130.43,88.23 129.94,88.23 129.69,88.48 129.03,88.48 128.74,88.18 128.34,88.18 128.05,88.48 127.39,88.48 127.15,88.23 126.36,88.23 125.47,89.12 124.11,89.12 123.63,89.6 123.63,90.33 122.38,91.58 121.95,91.58 120.47,93.06 119.53,93.06 119.22,93.37 119.22,93.9 117.58,95.54 117.43,95.54 116.22,96.75
  BOTTOM w0.076: UC1.AH65 v2(113.62,100.65)
  BOTTOM w0.114: v1(154.53,99.41) 154.81,99.41 154.98,99.24 154.98,99.04 154.7,98.76 152.86,98.76 152.66,98.56 151.7,98.56 151.51,98.75 JDIMM2.29
DDR_B_DQS2: length 50.9
  IN3 w0.076: v2(117.36,102.86) 117.36,102.75 117.63,102.49 118.99,102.49 119.27,102.77 119.85,102.77 120.62,102 120.64,102 120.65,101.99
  IN3 w0.114: 120.65,101.99 121.19,101.45 122.41,101.45 124.23,99.63 124.23,98.94 124.79,98.38 128.74,98.38 128.85,98.27 140.93,98.27 151.56,108.89 154.41,108.89 154.57,109.06 154.57,109.22 v1(154.32,109.47)
  BOTTOM w0.076: v2(117.36,102.86) 117,103.22 UC1.AR60
  BOTTOM w0.114: JDIMM2.64 157.53,109.25 157.34,109.06 156.74,109.06 155.47,110.33 154.77,110.33 154.53,110.09 154.53,109.68 v1(154.32,109.47)
DDR_B_DQS3: length 52
  IN3 w0.076: 120.95,97.66 120.94,97.67 120.92,97.67 120.05,98.54 120.05,99.23 119.54,99.75 117.78,99.75 117.61,99.57 117.39,99.57 117.24,99.71 117.24,100 v2(117.36,100.12)
  IN3 w0.114: v1(154.42,104.58) 154.58,104.58 154.7,104.47 154.7,104.23 154.55,104.08 152.72,104.08 142.15,93.52 126.03,93.52 125.68,93.86 124.69,93.86 123.1,95.46 123.1,95.92 121.54,97.48 121.12,97.48 120.95,97.66
  BOTTOM w0.076: v2(117.36,100.12) 117,100.48 UC1.AR65
  BOTTOM w0.114: JDIMM2.47 151.42,104.15 151.61,103.96 151.8,103.96 151.91,104.07 154.54,104.07 154.67,104.21 154.67,104.47 154.56,104.58 v1(154.42,104.58)
DDR_B_DQS4: length 50.6
  IN3 w0.076: 131.72,118.21 131.61,118.21 131.07,117.68 131.07,117.47 130.27,116.67 123.58,116.67 123.01,116.1 121.7,116.1 121.41,115.8 121.41,115.35 121.07,115.02 119.82,115.02 118.99,114.18 117.83,114.18 117.6,114.42 117.6,114.52 v2(117.34,114.77)
  IN3 w0.114: 131.72,118.21 133.46,118.21 134.14,118.9 134.33,118.9 141.96,126.53 141.96,126.71 143.33,128.08 143.33,128.65 144.03,129.35 144.59,129.35 146.31,131.06 147.24,131.06 148.95,132.77 149.78,132.77 151.33,134.32 153.17,134.32 153.32,134.17 153.32,133.95 153.21,133.83 v1(152.86,133.83)
  BOTTOM w0.076: UC1.AR38 v2(117.34,114.77)
  BOTTOM w0.114: v1(152.86,133.83) 153.19,133.83 153.33,133.68 153.33,133.49 153.2,133.36 151.7,133.36 151.51,133.55 JDIMM2.137
DDR_B_DQS5: length 53
  IN3 w0.076: v2(117.36,118.38) 117.6,118.61 117.6,118.78 117.78,118.96 119.14,118.96 119.36,118.75 120.58,118.75 121.68,119.86 122.54,119.86 123.26,120.57 123.99,120.57 124.01,120.58 124.03,120.58
  IN3 w0.114: 124.03,120.58 129.63,120.58 131.46,122.42 131.46,122.78 131.92,123.24 132.67,123.24 137.66,128.23 137.66,128.56 139.06,129.96 139.06,130.38 142.43,133.75 142.93,133.75 147.1,137.92 147.97,137.92 149.42,139.37 154.41,139.37 155,139.97 155.7,139.97 156.01,139.66 156.01,139.39 v1(156.27,139.13)
  BOTTOM w0.076: UC1.AR32 117,118.84 v2(117.36,118.38)
  BOTTOM w0.114: JDIMM2.154 157.4,138.65 157.21,138.46 156.38,138.46 156.06,138.77 156.06,138.93 v1(156.27,139.13)
DDR_B_DQS6: length 56.4
  IN3 w0.076: v2(117.36,121.15) 117.27,121.24 117.27,121.47 117.38,121.58 117.59,121.58 117.65,121.52 118.93,121.52 119.25,121.2 119.85,121.2 120.38,121.72 120.38,121.92 121.88,123.43 122.69,123.43 123.69,124.42 123.69,124.78 124.05,125.14 124.35,125.14 124.36,125.13 124.37,125.13
  IN3 w0.114: 124.37,125.13 128.31,125.13 130.46,127.29 131.24,127.29 133.57,129.61 133.57,130.34 137.01,133.79 137.01,135.87 141.07,139.93 141.6,139.93 146.13,144.46 152.53,144.46 152.94,144.87 154.54,144.87 154.75,144.66 154.75,144.4 154.58,144.23 v1(154.42,144.23)
  BOTTOM w0.076: UC1.AR27 v2(117.36,121.15)
  BOTTOM w0.114: v1(154.42,144.23) 154.61,144.23 154.74,144.1 154.74,143.87 154.54,143.67 151.88,143.67 151.76,143.56 151.61,143.56 151.42,143.75 JDIMM2.171
DDR_B_DQS7: length 58.6
  IN3 w0.076: 119.68,124.78 119.66,124.78 119.64,124.77 119.27,124.77 118.95,124.45 117.72,124.45 v5(117.36,124.8)
  IN3 w0.114: v1(154.98,149.76) 154.64,150.1 154.64,150.33 154.41,150.56 153.5,150.56 152.78,149.84 144.15,149.84 136.36,142.04 136.36,141.32 133.83,138.78 132,138.78 131.39,138.17 129.38,138.17 128.25,137.05 128.25,131.13 126.21,129.09 124.51,129.09 122.75,127.32 122.75,126.64 122.21,126.1 121.3,126.1 119.98,124.78 119.68,124.78
  BOTTOM w0.076: UC1.AR21 v5(117.36,124.8)
  BOTTOM w0.114: v1(154.98,149.76) 154.71,149.48 154.71,149.38 154.83,149.26 156.53,149.26 157.13,148.66 157.34,148.66 157.53,148.85 JDIMM2.188
DDR_B_DQS#0: length 67.5
  IN3 w0.114: v2(112.38,94.41) 112.22,94.57 112.06,94.57 111.94,94.45 111.94,90.56 111.69,90.3 111.69,86.91 115.95,82.65 143.68,82.65 147.72,86.68 147.72,87.5 152.66,92.44 154.56,92.44 154.96,92.84 154.96,92.97 154.8,93.13 v1(154.62,93.13)
  BOTTOM w0.076: UC1.AG69 112.75,98.06 113,97.81 113.04,97.56 113.04,97.27 113,97.19 113,96.98 113.05,96.88 113.05,96.64 113,96.54 113,96.01 113,96.01 113,94.83 112.81,94.64 112.62,94.64 v2(112.38,94.41)
  BOTTOM w0.114: v1(154.62,93.13) 154.75,93.13 155.16,92.73 155.16,92.64 155.4,92.4 155.89,92.4 156.79,93.3 157.15,93.3 157.4,93.05 JDIMM2.10
DDR_B_DQS#1: length 64.2
  IN3 w0.076: 116.08,96.61 116.07,96.61 116.07,96.64 116.04,96.67 116.04,96.74 114.02,98.74 114.02,100.11 113.94,100.19 113.79,100.19 v2(113.62,100.02)
  IN3 w0.114: v1(155.38,99.41) 155.17,99.19 155.17,99.01 154.83,98.67 152.98,98.67 142.58,88.28 142.26,88.28 142.03,88.51 142.03,88.81 141.91,88.93 141.52,88.93 141.41,88.81 141.41,88.2 141.18,87.97 140.62,87.97 140.39,88.2 140.39,88.81 140.27,88.93 139.88,88.93 139.77,88.81 139.77,88.51 139.53,88.28 138.98,88.28 138.75,88.51 138.75,88.81 138.63,88.93 138.24,88.93 138.12,88.81 138.12,88.51 137.89,88.28 137.32,88.28 137,87.96 136.49,87.96 136.17,88.28 135.68,88.28 135.43,88.03 134.78,88.03 134.53,88.28 134.04,88.28 133.79,88.03 133.14,88.03 132.89,88.28 132.4,88.28 132.15,88.03 131.5,88.03 131.25,88.28 130.76,88.28 130.51,88.03 129.85,88.03 129.61,88.28 129.12,88.28 128.83,87.99 128.26,87.99 127.97,88.28 127.48,88.28 127.23,88.03 126.28,88.03 125.39,88.93 124.02,88.93 123.43,89.52 123.43,90.25 122.3,91.38 121.87,91.38 120.38,92.86 119.44,92.86 119.02,93.28 119.02,93.82 117.5,95.34 117.35,95.34 116.08,96.61
  BOTTOM w0.076: UC1.AH66 v2(113.62,100.02)
  BOTTOM w0.114: v1(155.38,99.41) 155.2,99.22 155.2,98.95 154.79,98.55 152.95,98.55 152.75,98.34 151.7,98.34 151.51,98.15 JDIMM2.27
DDR_B_DQS#2: length 50.8
  IN3 w0.076: v2(117.36,101.94) 117.74,102.32 119.06,102.32 119.34,102.61 119.78,102.61 120.5,101.88 120.5,101.86 120.51,101.85
  IN3 w0.114: 120.51,101.85 121.11,101.25 122.33,101.25 124.03,99.55 124.03,98.86 124.71,98.18 128.65,98.18 128.77,98.07 141.02,98.07 151.64,108.69 154.49,108.69 154.77,108.98 154.77,109.18 v1(155.06,109.47)
  BOTTOM w0.076: UC1.AR61 117,102.31 v2(117.36,101.94)
  BOTTOM w0.114: JDIMM2.62 157.53,108.65 157.34,108.84 156.65,108.84 155.38,110.12 154.86,110.12 154.74,110 154.74,109.79 v1(155.06,109.47)
DDR_B_DQS#3: length 52
  IN3 w0.076: 120.81,97.52 120.8,97.53 120.8,97.55 119.88,98.47 119.88,99.16 119.47,99.58 117.85,99.58 117.68,99.4 117.57,99.4 v2(117.36,99.2)
  IN3 w0.114: 120.81,97.52 121.04,97.29 121.45,97.29 122.9,95.84 122.9,95.38 124.61,93.67 125.6,93.67 125.95,93.32 142.23,93.32 152.8,103.88 154.63,103.88 154.89,104.14 154.89,104.32 v1(155.16,104.58)
  BOTTOM w0.076: v2(117.36,99.2) 117,99.56 UC1.AR66
  BOTTOM w0.114: JDIMM2.45 151.39,103.55 151.59,103.74 151.89,103.74 152,103.86 154.63,103.86 154.89,104.12 154.89,104.32 v1(155.16,104.58)
DDR_B_DQS#4: length 50.6
  IN3 w0.076: v5(117.97,114.77) 117.85,114.77 117.76,114.69 117.76,114.48 117.9,114.35 118.92,114.35 119.76,115.18 121,115.18 121.24,115.42 121.24,115.87 121.63,116.26 122.94,116.26 123.51,116.83 130.2,116.83 130.91,117.54 130.91,117.75 131.55,118.4 131.68,118.4 131.7,118.41 131.72,118.41
  IN3 w0.114: v1(153.83,133.83) 153.52,134.14 153.52,134.25 153.25,134.52 151.25,134.52 149.7,132.97 148.87,132.97 147.16,131.26 146.23,131.26 144.51,129.54 143.95,129.54 143.13,128.73 143.13,128.17 141.76,126.8 141.76,126.61 134.25,119.1 134.06,119.1 133.38,118.41 131.72,118.41
  BOTTOM w0.076: UC1.AT38 117.65,115.2 v5(117.97,114.77)
  BOTTOM w0.114: JDIMM2.135 151.51,132.95 151.7,133.14 153.29,133.14 153.55,133.4 153.55,133.63 153.75,133.83 v1(153.83,133.83)
DDR_B_DQS#5: length 53.1
  IN3 w0.076: 124.03,120.39 124.01,120.39 123.99,120.4 123.32,120.4 122.61,119.69 121.75,119.69 120.64,118.59 119.29,118.59 119.08,118.8 117.85,118.8 117.76,118.71 117.76,118.61 v5(118,118.38)
  IN3 w0.114: 124.03,120.39 129.71,120.39 131.66,122.33 131.66,122.7 132,123.04 132.75,123.04 137.86,128.15 137.86,128.48 139.25,129.87 139.25,130.3 142.51,133.55 143.01,133.55 147.18,137.72 148.05,137.72 149.51,139.18 154.49,139.18 155.08,139.77 155.62,139.77 155.81,139.58 155.81,139.3 155.64,139.13 v1(155.51,139.13)
  BOTTOM w0.076: UC1.AT32 117.65,118.84 v5(118,118.38)
  BOTTOM w0.114: v1(155.51,139.13) 155.73,139.13 155.85,139.01 155.85,138.68 156.29,138.24 157.21,138.24 157.4,138.05 JDIMM2.152
DDR_B_DQS#6: length 56.4
  IN3 w0.076: v5(117.39,122.02) 117.71,121.69 118.99,121.69 119.32,121.36 119.79,121.36 120.21,121.79 120.21,121.99 121.81,123.59 122.63,123.59 123.53,124.49 123.53,124.85 123.98,125.31 124.35,125.31 124.37,125.33
  IN3 w0.114: v1(155.16,144.23) 154.95,144.43 154.95,144.74 154.62,145.07 152.86,145.07 152.45,144.65 146.04,144.65 141.52,140.13 140.99,140.13 136.82,135.96 136.82,133.87 133.37,130.42 133.37,129.69 131.16,127.48 130.38,127.48 128.23,125.33 124.37,125.33
  BOTTOM w0.076: UC1.AR25 117,122.5 v5(117.39,122.02)
  BOTTOM w0.114: v1(155.16,144.23) 154.95,144.02 154.95,143.78 154.63,143.46 151.97,143.46 151.85,143.34 151.59,143.34 151.39,143.15 JDIMM2.169
DDR_B_DQS#7: length 58.7
  IN3 w0.076: 119.68,124.58 119.66,124.58 119.64,124.6 119.34,124.6 119.02,124.28 117.69,124.28 117.36,123.96 v2(117.36,123.89)
  IN3 w0.114: 119.68,124.58 120.06,124.58 121.38,125.9 122.29,125.9 122.95,126.56 122.95,127.24 124.6,128.89 126.29,128.89 128.45,131.05 128.45,136.96 129.46,137.97 131.47,137.97 132.08,138.59 133.91,138.59 136.56,141.24 136.56,141.96 144.23,149.64 152.86,149.64 153.59,150.36 154.33,150.36 154.44,150.25 154.44,149.96 v1(154.24,149.76)
  BOTTOM w0.076: UC1.AR22 v2(117.36,123.89)
  BOTTOM w0.114: v1(154.24,149.76) 154.49,149.51 154.49,149.29 154.74,149.04 156.44,149.04 157.04,148.44 157.34,148.44 157.53,148.25 JDIMM2.186
DDR_B_MA0: length 49.8
  IN3 w0.165: v1(156.73,120.63) 157.23,120.63 157.48,120.88 157.48,121.55 157.12,121.91 150.93,121.91 136.89,107.87 131.72,107.87 130.66,108.93 v2(130.2,108.93)
  BOTTOM w0.076: 127.61,110.78 125.25,110.78 124.57,111.46 123.05,111.46 123.05,111.46 122.56,111.46 122.46,111.55 121.21,111.55 120.94,111.29 UC1.BA46
  BOTTOM w0.178: v2(130.2,108.93) 128.35,110.78 127.61,110.78 ; JDIMM2.98 156.24,121.85 156.04,121.65 156.04,121.31 v1(156.73,120.63)
DDR_B_MA1: length 51
  IN3 w0.076: 131.72,106.98 130.41,108.29 128.02,108.29 127.91,108.4 127.91,108.59 v2(128.25,108.93)
  IN3 w0.165: v1(154.03,120.63) 153.64,121.02 151.3,121.02 137.26,106.98 131.72,106.98
  BOTTOM w0.076: 123.14,110.79 122.8,111.13 122.45,111.13 122.45,111.13 122.42,111.13 122.32,111.22 121.77,111.22 121.57,111.02 121.31,111.02 121.19,111.08 121.05,111.08 120.82,111.01 120.69,111.01 120.47,111.09 120.37,111.19 UC1.AY46
  BOTTOM w0.178: v1(154.03,120.63) 154.59,120.63 155.16,121.2 155.16,122.48 155,122.64 154.49,122.64 154.06,122.21 152.07,122.21 151.4,121.55 JDIMM2.97 ; v2(128.25,108.93) 128.25,109.61 127.72,110.14 125.19,110.14 124.54,110.79 123.14,110.79
DDR_B_MA2: length 50.7
  IN3 w0.076: v2(127.6,108.93) 127.44,108.93 127.03,108.52 127.03,108.26 127.25,108.05 130.19,108.05
  IN3 w0.165: 130.19,108.05 131.71,106.53 137.45,106.53 150.91,120 152.68,120 152.84,120.16 152.84,120.39 v1(152.73,120.51)
  BOTTOM w0.076: UC1.AY47 120.1,110.89 120.52,110.89 120.68,110.84 120.83,110.84 121.04,110.9 121.16,110.9 121.24,110.87 121.27,110.86 121.64,110.86 121.84,111.06 122.25,111.06 122.35,110.96 122.54,110.96 123.15,110.35
  BOTTOM w0.178: v2(127.6,108.93) 127.8,109.13 127.8,109.38 127.42,109.76 124.96,109.76 124.38,110.35 123.15,110.35 ; v1(152.73,120.51) 152.73,120.42 153.46,119.69 155.04,119.69 155.44,119.3 155.94,119.3 156.12,119.47 156.12,119.88 156.29,120.06 156.79,120.06 157.23,120.5 157.23,120.96 157.52,121.25 JDIMM2.96
DDR_B_MA3: length 49
  IN3 w0.076: 131.66,107.42 130.56,108.52 129.46,108.52 129.38,108.59 129.38,108.76 v2(129.55,108.93)
  IN3 w0.165: v1(155.42,120.63) 155.67,120.87 155.67,121.22 155.42,121.46 151.12,121.46 137.08,107.42 131.66,107.42
  BOTTOM w0.076: UC1.BB46 121.52,111.39 122.39,111.39 122.49,111.29 122.98,111.29 124.44,111.29 125.27,110.46 125.97,110.46
  BOTTOM w0.178: 125.97,110.46 128.01,110.46 v2(129.55,108.93) ; v1(155.42,120.63) 155.24,120.63 154.76,120.15 153.75,120.15 152.45,121.45 151.82,121.45 151.32,120.95 JDIMM2.95
DDR_B_MA4: length 49.5
  IN3 w0.076: 131.77,106.09 130.04,107.82 126.56,107.82 126.35,108.03 126.35,108.33 v2(126.95,108.93)
  IN3 w0.165: v1(156.6,118.72) 156.95,119.08 156.95,119.49 156.37,120.07 153.38,120.07 152.86,119.55 151.09,119.55 137.63,106.09 131.77,106.09
  BOTTOM w0.076: 125.67,109.48 124.82,109.48 124.24,110.06 123.02,110.06 122.81,110.27 121.81,110.27 121.68,110.39 121.28,110.39 121.28,110.39 121.19,110.36 120.99,110.36 120.91,110.39 120.9,110.39 120.9,110.4 120.89,110.4 120.66,110.4 UC1.BA47
  BOTTOM w0.178: v1(156.6,118.72) 156.6,119.13 157.51,120.05 JDIMM2.92 ; v2(126.95,108.93) 126.39,109.48 125.67,109.48
DDR_B_MA5: length 50.3
  IN3 w0.076: 131.88,105.64 129.88,107.65 125.62,107.65 125.33,107.93 125.33,108.61 v2(125.65,108.93)
  IN3 w0.165: 131.88,105.64 137.81,105.64 151.27,119.11 153.04,119.11 153.56,119.62 155.12,119.62 155.3,119.44 155.3,119.08 v1(154.95,118.72)
  BOTTOM w0.076: UC1.AY48 120.32,110.16 120.48,110.16 120.58,110.2 120.58,110.2 120.67,110.23 120.87,110.23 120.96,110.19 121.21,110.19 121.22,110.19 121.31,110.23 121.57,110.23 121.69,110.11 122.74,110.11 122.95,109.9 124.18,109.9 124.75,109.32 125.25,109.32 v2(125.65,108.93)
  BOTTOM w0.178: JDIMM2.91 151.37,119.75 151.4,119.78 151.48,119.78 152.72,119.78 153.27,119.23 154.85,119.23 155.03,119.06 155.03,118.81 v1(154.95,118.72)
DDR_B_MA6: length 48.7
  IN3 w0.076: v2(124.34,108.93) 124.34,108.08 125.13,107.29 129.58,107.29 132.11,104.76 132.58,104.76
  IN3 w0.165: v1(154.05,118.56) 154.27,118.56 154.71,118.13 154.71,117.89 154.54,117.73 151.15,117.73 138.18,104.76 132.58,104.76
  BOTTOM w0.076: v2(124.34,108.93) 123.71,109.57 122.82,109.57 122.7,109.68 121.28,109.68 120.99,109.96 UC1.BA48
  BOTTOM w0.178: JDIMM2.90 157.51,119.45 157.33,119.27 157.33,118.76 156.66,118.09 154.53,118.09 v1(154.05,118.56)
DDR_B_MA7: length 51.6
  IN3 w0.076: v2(116.73,109.26) 117.08,108.91 118.86,108.91 119.05,108.72 122.71,108.72 123.53,107.91 123.53,107.05 124.48,106.09 130.14,106.09 132.37,103.87
  IN3 w0.165: v1(154.82,116.45) 154.82,116.67 154.65,116.84 151.52,116.84 138.55,103.87 132.37,103.87
  BOTTOM w0.076: UC1.AP48 v2(116.73,109.26)
  BOTTOM w0.178: v1(154.82,116.45) 155.65,117.28 156.42,117.28 157.39,118.25 JDIMM2.86
DDR_B_MA8: length 47.4
  IN3 w0.076: 132.02,105.2 129.76,107.47 125.41,107.47 124.99,107.89 v2(124.99,108.93)
  IN3 w0.165: v1(153.42,118.6) 152.99,118.17 150.97,118.17 138,105.2 132.02,105.2
  BOTTOM w0.076: v2(124.99,108.93) 124.77,109.16 124.67,109.16 124.1,109.73 122.88,109.73 122.67,109.94 121.62,109.94 121.6,109.96 UC1.BB48
  BOTTOM w0.178: JDIMM2.89 151.46,119.15 151.63,119.32 152.53,119.32 152.71,119.15 152.71,118.07 153.75,117.02 154.01,117.02 154.18,117.2 154.18,117.51 153.42,118.27 v1(153.42,118.6)
DDR_B_MA9: length 49.1
  IN3 w0.076: 122.79,106.2 121.32,106.2 119.57,107.95 117.12,107.95 v2(116.73,108.34)
  IN3 w0.165: v1(153.48,116.37) 153.48,116.12 152.65,115.3 151.24,115.3 138.92,102.98 132.16,102.98 130.41,104.73 124.27,104.73 122.79,106.2
  BOTTOM w0.076: UC1.AP50 v2(116.73,108.34)
  BOTTOM w0.178: v1(153.48,116.37) 153.48,116.45 152.16,117.76 151.72,117.76 151.53,117.95 JDIMM2.85
DDR_B_MA10: length 50.1
  IN3 w0.165: v1(153.83,125.71) 154.2,125.71 154.57,125.34 154.57,125.02 154.29,124.73 153.61,124.73 153.44,124.89 153.44,125.06 153.28,125.23 152.95,125.23 152.78,125.06 152.78,124.89 152.62,124.73 152.32,124.73 151.72,124.13 150.01,124.13 136.05,110.18 135.82,110.18 135.62,110.38 132.83,110.38 132.54,110.09 131.86,110.09 131.22,110.73 127.7,110.73 127.53,110.89 v2(127.53,111.6)
  BOTTOM w0.076: UC1.AW46 119.65,111.19 119.84,111.38 120.05,111.48 120.54,111.48 120.78,111.72 122.53,111.72 122.62,111.62 123.12,111.62 124.69,111.62 125.19,111.12 126.7,111.12
  BOTTOM w0.178: v1(153.83,125.71) 154.34,125.2 154.34,124.95 154.12,124.74 152.3,124.74 152.11,124.55 JDIMM2.107 ; 126.7,111.12 127.05,111.12 v2(127.53,111.6)
DDR_B_MA11: length 52.2
  IN3 w0.076: 132.39,104.31 132.25,104.31 130.13,106.43 125.26,106.43 125.25,106.45 124.56,106.45 123.86,107.15 123.86,108.01 122.87,109 119.45,109 118.73,109.72 116.55,109.72 v2(116.09,109.26)
  IN3 w0.165: v1(156.32,116.46) 155.5,117.28 151.34,117.28 138.37,104.31 132.39,104.31
  BOTTOM w0.076: UC1.AN48 v2(116.09,109.26)
  BOTTOM w0.178: JDIMM2.84 157.5,117.65 v1(156.32,116.46)
DDR_B_MA12: length 51.2
  IN3 w0.076: 120.14,107.97 119.81,108.3 119.23,108.3 118.79,108.74 116.49,108.74 v5(116.09,108.34)
  IN3 w0.165: 120.14,107.97 120.35,107.76 120.58,107.76 120.88,108.06 121.12,108.06 121.35,107.82 121.35,107.59 121.05,107.29 121.05,107.06 121.5,106.61 121.84,106.61 122,106.78 122,107.59 122.17,107.75 122.5,107.75 122.66,107.59 122.66,106.78 122.83,106.61 123.02,106.61 124.4,105.22 130.4,105.22 132.2,103.42 138.73,103.42 151.11,115.8 152.52,115.8 152.81,116.09 v1(152.81,116.36)
  BOTTOM w0.076: UC1.AN50 v5(116.09,108.34)
  BOTTOM w0.178: v1(152.81,116.36) 152.81,116.47 151.98,117.3 151.54,117.3 151.49,117.35 JDIMM2.83
DDR_B_MA13: length 47.1
  IN3 w0.076: v2(127.39,113.17) 127.01,112.79 127.01,112.64 127.15,112.5 129.62,112.5
  IN3 w0.165: v1(152.81,127.58) 152.81,127.27 152.65,127.1 151.33,127.1 150.14,125.91 148.45,125.91 147.1,124.57 147.1,123.93 135.97,112.8 135.33,112.15 132.43,112.15 132.08,112.5 129.62,112.5
  BOTTOM w0.076: v2(127.39,113.17) 126.98,112.76 124.64,112.76 124.48,112.61 123.53,112.61 123.53,112.61 123.1,112.61 122.63,113.08 122.56,113.08 122.3,113.35 121.8,113.35 121.67,113.21 121.54,113.21 121.53,113.21 121.28,113.21 121.15,113.26 121.04,113.26 120.94,113.22 120.91,113.21 120.67,113.21 UC1.BA43
  BOTTOM w0.178: v1(152.81,127.58) 153.47,128.23 153.63,128.23 153.88,128.48 153.88,128.9 153.7,129.08 153.29,129.08 152.36,128.15 JDIMM2.119
DDR_B_MA14: length 51.5
  IN3 w0.076: v2(116.09,107.43) 116.44,107.78 119.35,107.78 121.97,105.16 123.17,105.16
  IN3 w0.165: 123.17,105.16 124.1,104.23 130.4,104.23 132.1,102.53 139.1,102.53 151.42,114.85 152.88,114.85 153.45,115.43 154.49,115.43 v1(154.93,114.99)
  BOTTOM w0.076: UC1.AN52 115.7,107.82 v2(116.09,107.43)
  BOTTOM w0.178: JDIMM2.80 157.12,116.45 155.66,114.99 v1(154.93,114.99)
DDR_B_MA15: length 51.4
  IN3 w0.076: 122.57,104.65 120.99,104.65 118.75,106.9 116.47,106.9 v2(116.09,106.52)
  IN3 w0.165: v1(155.99,114) 155.93,114.06 154.31,114.06 154.21,113.96 151.79,113.96 139.47,101.64 131.47,101.64 130.53,102.58 124.65,102.58 122.57,104.65
  BOTTOM w0.076: UC1.AN53 v2(116.09,106.52)
  BOTTOM w0.178: JDIMM2.78 157.66,115.85 155.99,114.18 v1(155.99,114)
DDR_B_RAS#: length 49.9
  IN3 w0.076: 131.27,112.06 129.36,112.06 129.17,112.25 126.23,112.25 v2(125.58,111.6)
  IN3 w0.165: v1(156.65,125.69) 156.83,125.52 157.37,125.52 157.73,125.88 157.73,126.47 157.15,127.05 153.22,127.05 152.83,126.66 151.51,126.66 150.32,125.46 148.63,125.46 147.55,124.38 147.55,123.75 136.15,112.35 135.51,111.71 132.28,111.71 131.93,112.06 131.27,112.06
  BOTTOM w0.076: v2(125.58,111.6) 125.39,111.79 123.18,111.79 123.18,111.79 122.69,111.79 122.59,111.88 120.78,111.88 120.54,112.12 120.07,112.12 120,112.14 119.79,112.25 119.63,112.42 UC1.AW44
  BOTTOM w0.178: JDIMM2.110 156.9,125.45 v1(156.65,125.69)
DDR_B_WE#: length 51
  IN3 w0.165: v2(128.69,113.17) 128.86,113.34 130.82,113.34 130.87,113.39 135.31,113.39 135.6,113.69 145.27,123.36 145.27,123.8 146.22,124.75 146.22,124.93 148.08,126.8 149.66,126.8 151.37,128.51 152.29,128.51 152.93,129.14 154.69,129.14 155.88,127.95 155.88,127.72 155.65,127.49 155.27,127.49 v1(155.25,127.51)
  BOTTOM w0.076: v2(128.69,113.17) 128.69,112.78 128.29,112.38 124.84,112.38 124.73,112.28 123.39,112.28 122.93,112.28 122.83,112.38 122.82,112.38 121.78,112.38 121.58,112.58 121.31,112.58 121.19,112.53 121.05,112.53 120.82,112.59 120.69,112.59 120.47,112.52 120.46,112.52 120.36,112.42 UC1.AY44
  BOTTOM w0.178: v1(155.25,127.51) 155.25,126.62 154.81,126.18 151.8,126.18 151.63,126.35 JDIMM2.113
DDR_PG_CTRL: length 112.1
  TOP w0.114: v1(175.59,128.81) 175.59,131.97 RD24.1 174.28,132.75 QD1.3
  BOTTOM w0.076: UC1.AW67 119.51,98.84 119.52,98.84 119.74,99.06 119.74,99.07 119.94,99.26 120.55,99.26 120.57,99.27 120.63,99.3 120.91,99.3 121.04,99.25 121.14,99.25 121.28,99.3 121.62,99.3 121.89,99.03 121.89,98.9 122.14,98.66 122.45,98.66 122.66,98.44 122.66,95.93 125.08,93.5 125.46,93.5
  BOTTOM w0.114: 125.46,93.5 127.95,93.5 130.83,90.62 130.83,89.43 v4(131.18,89.07) 132.45,87.8 133.65,87.8 137.15,84.3 157.4,84.3 158.34,85.24 161.16,85.24 162.87,83.53 166.5,83.53 173.63,90.66 173.63,92.78 175.68,94.83 175.68,102.1 175.57,102.21 175.57,113.77 175.41,113.93 175.41,128.62 v1(175.59,128.81)
DDRA_CKE0_DIMMA: length 63.5
  IN1 w0.165: v1(165.8,114.95) 165.36,114.52 164.35,114.52 164.1,114.76 163.69,114.76 163.44,114.52 162.85,114.52 161.29,112.96 160.58,112.96 157.63,110 153.47,110 152.86,109.39 152.58,109.39 152.41,109.56 152.41,109.72 152.25,109.89 151.92,109.89 151.75,109.72 151.75,109.56 151.59,109.39 151.33,109.39 143.11,101.18 131.88,101.18 130.36,102.7 129.48,102.7 129.31,102.87 129.31,103.11 v5(129.77,103.57)
  BOTTOM w0.076: 125.31,102.71 122.95,105.07 122.48,105.07 122.36,104.95 121.68,104.95 121.61,104.88 121.31,104.88 121.31,104.88 121.06,105 121.06,105.01 121.06,105.01 120.91,105.15 UC1.BA56
  BOTTOM w0.178: v1(165.8,114.95) 165.8,114.68 165.32,114.2 164.75,114.2 164.6,114.35 JDIMM1.73 ; v5(129.77,103.57) 130.24,103.1 132.15,103.1 132.36,102.89 132.36,102.59 132.15,102.39 129.23,102.39 128.97,102.66 125.36,102.66 125.31,102.71
DDRA_CKE1_DIMMA: length 62.1
  IN1 w0.165: v2(128.47,103.57) 127.76,102.86 127.76,102.49 127.97,102.28 130.2,102.28 131.74,100.73 143.3,100.73 151.51,108.95 157.2,108.95 160.77,112.51 161.47,112.51 163.03,114.07 167,114.07 167.57,114.65 v1(167.9,114.65)
  BOTTOM w0.076: UC1.BB56 121.45,105.11 122.29,105.11 122.41,105.24 123.02,105.24 125.17,103.08 125.31,103.08
  BOTTOM w0.178: v1(167.9,114.65) 167.49,114.24 167.49,113.82 167.83,113.48 169.7,113.48 170.87,114.65 JDIMM1.74 ; v2(128.47,103.57) 127.99,103.08 125.31,103.08
DDRA_CS0_DIMMA#: length 66.1
  IN1 w0.076: v2(118.63,111.09) 118.95,111.41 118.95,111.73 120.83,113.62 129.86,113.62 130.09,113.38
  IN1 w0.165: v1(170.25,126.68) 170.25,126.38 170.42,126.2 170.92,126.2 171.17,126.46 171.17,127.75 170.56,128.37 159.48,128.37 159.31,128.2 159.31,128.09 159.15,127.92 158.82,127.92 158.65,128.09 158.65,128.2 158.49,128.37 157.9,128.37 157.6,128.06 152.52,128.06 152.26,127.79 152.26,127.3 152.09,127.14 150.98,127.14 147.64,123.79 147.64,123.42 137.93,113.72 132.3,113.72 131.96,113.38 130.09,113.38
  BOTTOM w0.076: UC1.AU45 v2(118.63,111.09)
  BOTTOM w0.178: JDIMM1.114 170.25,126.65 v1(170.25,126.68)
DDRA_CS1_DIMMA#: length 68.9
  IN1 w0.076: v2(118.63,112) 118.63,112.12 121.18,114.67 121.64,114.67 121.75,114.56 121.75,114.21 121.85,114.1 122.26,114.1 122.38,114.23 122.38,114.55 122.51,114.67 123.04,114.67 123.82,113.89 130.2,113.89
  IN1 w0.165: 130.2,113.89 131.94,113.89 132.21,114.17 136.31,114.17 136.47,114.33 136.47,114.56 136.64,114.73 136.97,114.73 137.13,114.56 137.13,114.33 137.3,114.17 137.75,114.17 147.19,123.61 147.19,123.98 151.72,128.5 157.31,128.5 157.62,128.81 165.67,128.81 165.92,129.06 166.2,129.06 166.45,128.81 166.69,128.81 166.89,129.01 166.89,129.24 v1(166.78,129.34)
  BOTTOM w0.076: UC1.AU43 v2(118.63,112)
  BOTTOM w0.178: v1(166.78,129.34) 166.78,129.57 167.02,129.8 168.01,129.8 168.32,129.49 168.32,128.92 168.98,128.26 168.98,127.81 168.74,127.57 168.38,127.57 167.26,128.69 165.6,128.69 165.55,128.75 JDIMM1.121
DDRA_ODT0_DIMMA#: length 66.5
  IN1 w0.076: v2(118,111.09) 118.39,110.69 119.38,110.69 121.16,112.47 124.62,112.47 124.92,112.77 129.22,112.77 129.46,113 131.03,113
  IN1 w0.165: 131.03,113 132.12,113 132.4,113.28 138.12,113.28 148.08,123.24 148.08,123.61 151.16,126.69 152.48,126.69 152.65,126.86 154.92,126.86 155.07,127.01 155.48,127.01 155.63,126.86 156.33,126.86 157.07,127.59 158.52,127.59 158.67,127.44 159.52,127.44 160.01,127.92 168.78,127.92 168.98,127.72 168.98,127.29 168.78,127.09 168.6,127.09 168.4,126.9 168.4,126.2 168.65,125.96 169.08,125.96 v1(169.19,125.85)
  BOTTOM w0.076: UC1.AT45 v2(118,111.09)
  BOTTOM w0.178: v1(169.19,125.85) 168.75,126.3 168.75,126.75 169.25,127.25 JDIMM1.116
DDRA_ODT1_DIMMA#: length 67.9
  IN1 w0.076: 119.99,114 v2(118,112)
  IN1 w0.165: 119.99,114 121.14,115.15 123.24,115.15 124.12,114.27 130.58,114.27 130.75,114.43 130.75,114.79 130.91,114.95 131.2,114.95 131.41,114.75 131.41,114.43 131.57,114.27 131.76,114.27 132.11,114.61 132.36,114.61 132.52,114.78 132.52,114.84 132.69,115.01 133.02,115.01 133.18,114.84 133.18,114.78 133.35,114.61 133.68,114.61 133.84,114.78 133.84,114.84 134.01,115.01 134.34,115.01 134.5,114.84 134.5,114.78 134.67,114.61 134.95,114.61 135.51,115.17 138.12,115.17 146.75,123.79 146.75,124.16 151.53,128.95 153.36,128.95 153.68,129.27 154.02,129.27 154.34,128.95 155.47,128.95 155.64,129.11 155.64,129.16 155.8,129.32 156.14,129.32 156.3,129.16 156.3,129.11 156.47,128.95 157.13,128.95 157.43,129.25 157.73,129.25 157.98,129.5 158.39,129.5 158.64,129.25 159.06,129.25 159.3,129.5 159.72,129.5 159.96,129.25 161.75,129.25 162.04,129.55 162.41,129.55 162.7,129.25 163.07,129.25 163.36,129.55 163.73,129.55 164.02,129.25 164.34,129.25 164.9,129.81 167.46,129.81 167.78,129.49 167.78,129.24 168.08,128.94 169.51,128.94 169.7,129.13 v1(169.7,129.57)
  BOTTOM w0.076: UC1.AT43 v2(118,112)
  BOTTOM w0.178: v1(169.7,129.57) 169.7,128.84 170.09,128.45 JDIMM1.120
DDRB_CKE0_DIMMB: length 48.1
  IN3 w0.076: 122.44,103.63 121.64,103.63 121.14,104.13 119.28,104.13 119.15,104.27 119.15,104.77 118.75,105.16 116.56,105.16 v2(116.09,104.69)
  IN3 w0.165: v1(152.91,112.7) 152.11,112.7 139.93,100.53 131,100.53 129.86,101.67 124.4,101.67 122.44,103.63
  BOTTOM w0.076: UC1.AN56 v2(116.09,104.69)
  BOTTOM w0.178: JDIMM2.73 151.19,114.35 152.84,112.7 v1(152.91,112.7)
DDRB_CKE1_DIMMB: length 50.5
  IN3 w0.076: v2(116.73,105.6) 117.1,105.98 118.83,105.98 120.43,104.38 121.32,104.38 121.77,103.92 122.71,103.92
  IN3 w0.165: 122.71,103.92 124.57,102.06 130.1,102.06 131.19,100.97 139.75,100.97 152.07,113.29 154.55,113.29 v1(154.8,113.54)
  BOTTOM w0.076: UC1.AP55 v2(116.73,105.6)
  BOTTOM w0.178: JDIMM2.74 158.55,114.36 157.69,113.49 154.85,113.49 v1(154.8,113.54)
DDRB_CS0_DIMMB#: length 50.2
  IN3 w0.076: v2(123.94,113.05) 125.12,114.23 130.03,114.23 130.75,114.95
  IN3 w0.165: v1(155.34,129.61) 155.81,130.08 155.81,130.31 155.53,130.59 151.42,130.59 150.9,130.07 150.73,130.07 149.02,128.36 147.43,128.36 144.65,125.58 144.65,125.39 143.71,124.45 143.71,124 135.9,116.19 135.27,116.19 134.63,115.56 134.03,114.95 130.75,114.95
  BOTTOM w0.076: UC1.BB42 121.45,113.68 122.43,113.68 122.57,113.54 123.45,113.54 v2(123.94,113.05)
  BOTTOM w0.178: v1(155.34,129.61) 155.58,129.37 155.58,129.18 155.4,129 154.75,129 154.57,128.82 154.57,128.46 154.75,128.29 155.4,128.29 155.58,128.11 155.58,128.07 155.96,127.69 155.96,127.49 156.8,126.65 JDIMM2.114
DDRB_CS1_DIMMB#: length 52.1
  IN3 w0.165: v2(126.09,113.17) 126.09,113.51 126.32,113.75 130.54,113.75 130.85,114.07 134.82,114.07 135.16,114.41 135.16,114.83 135.63,115.31 136.27,115.31 144.6,123.64 144.6,124.08 145.54,125.03 145.54,125.21 147.8,127.47 149.38,127.47 151.09,129.18 152.02,129.18 v1(152.51,129.67)
  BOTTOM w0.076: UC1.AY42 120.38,113.91 120.87,113.91 121.25,114.06 121.27,114.07 121.76,114.07 121.82,114.01 122.57,114.01 122.71,113.87 124.26,113.87 124.62,114.23
  BOTTOM w0.178: JDIMM2.121 151.58,128.75 v1(152.51,129.67) ; 124.62,114.23 130.21,114.23 130.39,114.06 130.39,113.85 130.15,113.61 126.52,113.61 v2(126.09,113.17)
DDRB_ODT0_DIMMB#: length 51
  IN3 w0.076: v2(125.44,113.17) 125.23,113.38 125.23,113.6 125.67,114.04 130.34,114.04
  IN3 w0.165: 130.34,114.04 130.82,114.51 134.21,114.51 135.45,115.75 136.08,115.75 144.15,123.82 144.15,124.27 145.1,125.21 145.1,125.4 147.61,127.91 149.2,127.91 150.91,129.63 151.09,129.63 151.61,130.14 154.3,130.14 154.46,129.98 v1(154.46,129.6)
  BOTTOM w0.076: UC1.BA42 120.91,113.64 121.06,113.78 121.06,113.79 121.06,113.79 121.31,113.91 121.64,113.91 121.7,113.84 122.5,113.84 122.64,113.71 124.9,113.71 v2(125.44,113.17)
  BOTTOM w0.178: JDIMM2.116 157.17,127.25 156.04,128.38 156.04,129.64 154.58,131.1 154.21,131.1 154.02,130.91 154.02,129.83 154.25,129.6 v1(154.46,129.6)
DDRB_ODT1_DIMMB#: length 52.2
  IN3 w0.076: v2(123.29,113.01) 124.16,113.89 124.24,113.89 124.82,114.47 129.91,114.47 130.65,115.21 130.65,115.54 131.03,115.92 131.26,115.92
  IN3 w0.165: v1(156.57,129.68) 156.57,129.83 157.68,130.94 157.68,131.28 157.37,131.59 156.94,131.59 156.38,131.03 151.24,131.03 150.72,130.51 150.54,130.51 148.83,128.8 147.25,128.8 144.21,125.77 144.21,125.58 143.26,124.63 143.26,124.19 135.72,116.64 135.08,116.64 134.36,115.92 131.26,115.92
  BOTTOM w0.076: UC1.AW42 119.7,113.41 119.92,113.41 119.96,113.38 120.27,113.38 120.31,113.41 120.58,113.41 120.66,113.38 120.87,113.38 120.98,113.43 121.21,113.43 121.23,113.41 121.31,113.38 121.51,113.38 121.52,113.38 121.6,113.38 121.73,113.51 122.36,113.51 122.56,113.32 122.77,113.32 123.08,113.01 v2(123.29,113.01)
  BOTTOM w0.178: v1(156.57,129.68) 156.57,128.63 156.75,128.45 JDIMM2.120
DGPU_HOLD_RST#: length 66.2
  IN3 w0.114: v1(87.37,139.11) 87.22,139.11 86.97,139.36 79.71,139.36 v1(73.42,133.06)
  BOTTOM w0.076: 107.87,137.28 107.87,136.16 108.02,136.01 108.04,135.89 108.04,135.65 107.99,135.51 107.99,135.32 108.11,135.12 108.6,134.62 108.6,133.04 107.95,132.39 UC1.U9
  BOTTOM w0.114: 107.87,137.28 107.87,137.64 107,138.51 107,139.55 106.34,140.2 105.4,140.2 104.08,141.52 99.05,141.52 98.29,140.76 98.29,140.38 97.75,139.83 96.91,139.83 96.67,140.08 94.51,140.08 92.27,142.32 92.27,142.49 91.68,143.08 90.26,143.08 87.57,140.38 87.57,139.31 v1(87.37,139.11) 87.37,138.35 87.71,138.01 87.71,136.08 88.65,135.13 89.04,135.13 89.64,134.53 89.64,134.14 89.75,134.03 RPC26.2 ; v1(73.42,133.06) 71.92,133.06 v4(70.99,132.13) 70.21,131.35 66.15,131.35 65.94,131.14 65.94,130.67 66.39,130.22 UV4.2
DGPU_PWREN#: length 62.6
  TOP w0.114: RV135.1 RV134.2 73.64,156.5 74.02,156.12 75.08,156.12 v4(75.37,156.41) 75.67,156.12 76.32,156.12 76.94,155.49 79.98,155.49 80.1,155.37 v1(80.61,155.37)
  IN3 w0.114: v1(79.03,148.88) 79.03,148.04 73.79,142.81 70.74,142.81 68.06,140.13 55.93,140.13 55.47,139.67 55.47,129.35 v1(55.62,129.21)
  BOTTOM w0.114: v1(80.61,155.37) 80.84,155.37 81.73,154.48 81.73,153.11 81.42,152.8 QV8.3 80.66,152.47 80.66,150.15 79.39,148.88 v1(79.03,148.88) 78.09,148.88 76.99,149.97 RV139.1 ; v1(55.62,129.21) 55.87,129.21 56.56,129.9 56.56,130.8 RV142.1
DGPU_PWROK: length 126.6
  TOP w0.114: RC389.2 112.11,145.82 112.11,146.05 RC67.2 112.64,145.89 RC71.1 v1(112.49,145.39)
  IN1 w0.14: v1(123.81,166.91) 122.66,165.77 112,165.77 111.36,165.13 v1(111.36,164.68) 111.36,164.63 110.38,163.65 110.38,160.7 107.78,158.1 105.88,158.1 104.55,156.78 100.28,156.78 100.16,156.9 86.77,156.9 85.09,155.21 v1(84.9,155.21) 84.33,155.21 82.64,156.9 78.26,156.9 73.83,161.34 73.76,161.34 66.18,168.92 65.18,168.92 63.73,170.37 62.72,170.37 v1(62.25,170.84)
  IN3 w0.114: v1(108.22,141.98) 109.09,141.98 v1(112.49,145.39)
  BOTTOM w0.114: UV11.3 62.36,174.15 63.14,173.38 ; v1(123.81,166.91) 124.57,166.91 125.65,165.83 RC384.1 ; v1(62.25,170.84) 62.32,170.84 v4(62.79,171.31) ; v1(84.9,155.21) 85.34,155.21 85.82,154.73 96.45,154.73 98.6,152.58 98.6,149.57 101.14,147.02 101.14,143.87 101.51,143.51 107.05,143.51 108.22,142.34 v1(108.22,141.98)
  BOTTOM w0.14: 63.14,173.38 63.14,172.49 63.8,171.83 63.8,171.62 63.48,171.31 v4(62.79,171.31)
  BOTTOM w0.254: v1(111.36,164.68) 111.36,165.26 PR605.1
DGPU_PWROK_R: length 43
  BOTTOM w0.076: 122.55,131.64 122.55,131.26 122.17,130.88 121.47,130.88 UC1.BB11
  BOTTOM w0.114: 122.55,131.64 122.55,132.62 123.88,133.94 126.21,133.94 128.44,136.17 128.44,139.77 127.58,140.64 127.58,143.4 128.42,144.24 128.42,145.65 125.56,148.51 124.25,148.51 122.32,150.44 122.32,158.05 v4(122.35,158.08) 122.35,160 RC408.2 124.78,162.43 124.78,162.64 125.65,163.51 RC384.2
DH_1.35V: length 6.2
  IN3 w0.762: 177.38,171 171.3,171 v1(171.2,170.9)
  vias: v1(170.56,170.91) v1(177.31,171.21) v1(177.91,170.87)
DH_CHG: length 6.1
  IN3 w0.762: 223.53,111.46 225.69,111.46 228.48,114.26
  vias: v1(222.54,111.16) v1(223.17,111.16) v1(229.19,115.12) v1(229.22,114.48)
DIFFCLK_BIASREF: length 19.7
  TOP w0.381: v1(90.21,112.62) 90.02,112.43 RC362.1 v4(85.53,113.66)
  IN3 w0.381: v1(90.21,112.62) 92.03,114.44 96.98,114.44 98.5,112.92 v2(101.92,112.92)
  BOTTOM w0.381: UC1.E42 101.51,113.33 v2(101.92,112.92)
DISCRETE_PRESENCE: length 26.7
  TOP w0.254: RC29.2 RC32.2 ; RC29.2 127.87,146.82 v1(127.5,147.19) ; RC29.2 v4(128.25,145.73)
  IN3 w0.114: v2(116.76,131.19) 117.2,130.74 118.8,130.74 119.06,130.99 119.06,131.72 120.79,133.45 120.79,134.53
  IN3 w0.254: 120.79,134.53 120.79,135.63 122.61,137.45 122.61,139.55 126.22,143.15 127.12,143.15 127.92,143.95 127.92,146.77 v1(127.5,147.19)
  BOTTOM w0.076: UC1.AR10 117,131.43 v2(116.76,131.19)
DISP_A0N_L_C: length 38.8
  TOP w0.114: v1(277.37,122.64) 277.56,122.45 279.43,122.45 279.7,122.72 D18.8 D18.2 281.99,122.72 282.12,122.59 285.86,122.59 286.2,122.25 286.2,120.27 285.92,120 285.44,120 JLINK.5 ; CM15.2 263.47,138.01 263.58,137.89 263.58,135.55 v1(263.32,135.29)
  IN3 w0.114: v1(263.32,135.29) 263.55,135.52 263.55,136.59 264.05,137.09 264.95,137.09 265.61,136.43 265.61,133.77 276.96,122.42 277.15,122.42 277.37,122.64 v1(277.37,122.64)
DISP_A0P_L_C: length 38.8
  TOP w0.114: JLINK.3 285.3,120.64 285.71,120.23 285.83,120.23 285.97,120.37 285.97,122.16 285.77,122.36 282.1,122.36 281.96,122.22 D18.1 D18.9 280.56,122.22 280.29,122.49 279.79,122.49 279.52,122.22 277.5,122.22 277.39,122.1 v1(277.39,121.83) ; CM13.2 264.28,138.12 263.93,138.12 263.81,138.01 263.81,135.4 263.93,135.29 v1(264.08,135.29)
  IN3 w0.114: v1(264.08,135.29) 263.89,135.29 263.76,135.42 263.76,136.51 264.13,136.89 264.87,136.89 265.41,136.35 265.41,133.68 276.87,122.22 277.15,122.22 277.23,122.22 277.39,122.07 v1(277.39,121.83)
DISP_A1N_L_C: length 44.4
  TOP w0.114: JLINK.11 285.5,117.66 285.89,117.66 286.75,118.53 286.75,122.5 285.93,123.32 283.57,123.32 282.67,124.22 D18.5 D18.6 280.08,124.22 279.89,124.41 277.58,124.41 v1(277.43,124.56) ; v1(260.9,135.29) 260.9,135.33 261.17,135.6 261.17,137.89 261.06,138.01 CM19.2
  IN3 w0.114: v1(260.9,135.29) 261.1,135.49 261.1,136.68 262.23,137.8 265.24,137.8 266.31,136.73 266.31,134.78 276.68,124.42 277.3,124.42 v1(277.43,124.56)
DISP_A1P_L_C: length 44.4
  TOP w0.114: v1(277.43,123.79) 277.43,123.92 277.69,124.18 279.8,124.18 279.98,123.99 280.24,123.99 280.38,123.86 280.52,123.72 D18.7 D18.4 281.94,123.72 282.21,123.99 282.57,123.99 283.47,123.1 v1(283.76,123.1) 285.83,123.1 286.52,122.4 286.52,118.62 285.79,117.89 285.65,117.89 285.3,118.24 JLINK.9 ; v1(261.66,135.29) 261.51,135.29 261.4,135.4 261.4,138.01 261.54,138.15 261.84,138.15 CM17.2
  IN3 w0.114: v1(261.66,135.29) 261.53,135.29 261.31,135.5 261.31,136.59 262.31,137.6 265.16,137.6 266.11,136.65 266.11,134.7 276.59,124.21 277.13,124.21 277.43,123.91 v1(277.43,123.79)
DL_1.35V: length 8.5
  IN3 w0.762: 178.37,173.23 176.63,174.97 170.56,174.97 v1(170.56,174.98)
  vias: v1(169.92,175) v1(178.68,172.78) v1(179.15,172.31)
DL_CHG: length 14.1
  IN3 w1.016: 223.3,113.54 227.67,117.91 235.54,117.91
  vias: v1(222.38,112.66) v1(222.87,113.09) v1(236.25,118.24) v1(236.53,117.66)
DMIC_CLK: length 185.2
  TOP w0.114: RA7.1 CA40.1 189.87,51.29 v1(190.02,51.44) ; v1(53.58,115.73) 53.72,115.73 54.05,116.06 54.05,116.07 54.4,116.42
  IN3 w0.114: v1(190.02,51.44) 189.63,51.84 189.63,58.29 188.04,59.88 185.13,59.88 183.77,61.23 183.77,62.43 176.88,69.32 143.94,69.32 142.67,70.59 119.56,70.59 118.87,71.28 108.28,71.28 103.94,75.62 103.6,75.62 102.91,76.31 102.27,76.31 101.69,76.89 98.24,76.89 96.67,78.47 96.67,82.16 95.13,83.7 93.7,83.7 90.62,86.79 90.62,104.27 80.36,114.53 78.52,114.53 78.1,114.11 70.51,114.11 69.95,114.67 67.53,114.67 67.06,115.14 63.33,115.14 61.66,113.47 61.37,113.47 60.48,112.58 57.87,112.58 54.72,115.73 v1(53.58,115.73)
DMIC_DATA: length 188.5
  TOP w0.114: JLCD.14 54.27,115.72 54.27,115.72 53.88,115.33 v3(53.88,114.84) 53.5,114.84 v1(53.32,115.02) ; v1(190.89,53.07) CA43.1 190.23,53.47 189.48,54.23 UA1.1
  IN3 w0.114: v1(190.89,53.07) 189.99,53.96 189.99,58.45 188.19,60.24 185.29,60.24 184.14,61.39 184.14,62.58 177.04,69.69 144.09,69.69 142.13,71.65 108.44,71.65 104.09,75.99 103.75,75.99 103.06,76.68 102.43,76.68 101.85,77.26 98.39,77.26 97.03,78.62 97.03,82.32 95.28,84.07 93.86,84.07 90.98,86.94 90.98,104.43 80.51,114.9 78.37,114.9 77.94,114.48 70.66,114.48 70.1,115.04 67.69,115.04 67.22,115.51 63.17,115.51 61.96,114.29 60.79,114.29 60.2,114.88 58.86,114.88 57.92,113.94 57.03,113.94 54.72,116.25 53.38,116.25 52.95,115.82 52.95,115.39 v1(53.32,115.02)
DOCK_AUXN: length 231.8
  TOP w0.114: v1(269.37,144.28) 269.13,144.52 267.99,144.52 267.65,144.17 CM6.1
  IN3 w0.076: v5(102.54,108.31) 102.33,108.1 102.33,107.99 102.13,107.78 100.71,107.78 100.69,107.77 100.67,107.77
  IN3 w0.114: 100.67,107.77 100.32,107.77 99.83,107.27 99.83,98.61 101.73,96.7 101.73,95.71 105.51,91.93 105.51,84.44 112.42,77.53 163.19,77.53 171.24,85.58 181.52,85.58 199.01,103.07 199.01,104.26 228.59,133.84 228.59,135.08 240.32,146.81 250.14,146.81 251.15,145.79 257.09,145.79 258.14,146.85 267.09,146.85 268.18,145.76 269.7,145.76 270.16,145.3 270.16,144.73 269.88,144.45 269.54,144.45 v1(269.37,144.28)
  BOTTOM w0.076: UC1.G50 v5(102.54,108.31)
