# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SLG5NT1533VTR_STDFN8-6_1X1P6
  rect 0.889x0.279 smd: 1(0,0) 2(0,-0.4) 5(1,-0.4) 6(1,0)
  rect 0.787x0.584 smd: 3(0,-1) 4(1,-1)
SUYIN_020053GR009M283ZL_9P
  oval 1.016x0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x3.2 hole 0.711x2.591: 10(4.35,-2.38) 12(-11.35,-2.38)
  oval 1.295x2.388 hole 0.711x1.803: 11(4.35,-9.49) 13(-11.35,-9.49)
SW_NTC010-AK1G-B160T_4P
  rect 2.007x1.295 smd: 1(0,0) 2(7,0) 3(0,-4.5) 4(7,-4.5)
SYX198BQNC_QFN10_3X3
  oval 0.711x0.356 smd: 1(0,0) 2(0,0.45) 3(0,0.9) 4(0,1.35) 5(0,1.8) 6(0,2.25)
  rect 0.33x1.219 smd: 7(0.662,2.215)
  rect 2.007x0.864 smd: 8(2,2.09)
  custom 0.47x0.47 smd: 9(1.775,1.075)
  rect 1.143x0.787 smd: 10(1.6,0.113)
SYX198CQNC_QFN10_3X3
  oval 0.711x0.356 smd: 1(0,0) 2(0,0.45) 3(0,0.9) 4(0,1.35) 5(0,1.8) 6(0,2.25)
  rect 0.33x1.219 smd: 7(0.662,2.215)
  rect 2.007x0.864 smd: 8(2,2.09)
  custom 0.47x0.47 smd: 9(1.775,1.075)
  rect 1.143x0.787 smd: 10(1.6,0.113)
TAIMA_IH-189-A_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TC7SG17FE_SON5
  oval 0.305x0.457 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.35) 5(0,1.35)
TDK_FLF3215T-4R7M_2P
  rect 1.194x2.007 smd: 1(0,0) 2(3.2,0)
TDK_MPZ1608S300AT_2P
  rect 0.61x0.787 smd: 1(0,0) 2(1.4,0)
TE_2041180-2_2P-T
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0)
  rect 2.108x2.997 smd: 3(2.55,2.9) 4(-3.8,2.9)
TE_2199230-8_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.406x1.651 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
TPC12
  round 0.305 smd: 1(0,0)
TPC20
  round 0.508 smd: 1(0,0)
TPC32
  round 0.813 smd: 1(0,0)
TPC40
  round 1.016 smd: 1(0,0)
TPCA8059-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPCA8065-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPS2546RTER_QFN16_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
TPS22965DSGR_WSON8_2X2
  oval 0.61x0.381 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.9,-1.5) 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0)
  rect 0.889x1.6 smd: 9(0.95,-0.75)
TPS22966DPUR_WSON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51367RVER_QFN28_3P5X4P5
  oval 0.305x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 15(3.2,3.17) 16(2.8,3.17) 17(2.4,3.17) 18(2,3.17) 19(1.6,3.17) 20(1.2,3.17) 21(0.8,3.17) 22(0.4,3.17) 23(0,3.17)
  oval 0.889x0.305 smd: 10(3.685,0.785) 11(3.685,1.185) 12(3.685,1.585) 13(3.685,1.985) 14(3.685,2.385) 24(-0.485,2.385) 25(-0.485,1.985) 26(-0.485,1.585) 27(-0.485,1.185) 28(-0.485,0.785)
  rect 3.099x2.108 smd: 29(1.6,1.585)
TYCO_2041180-4_4P-T
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,2.9) 6(-6.3,2.9)
unnamed#2
  round 1.016 smd: 1(0,0)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI219LM-QREF-A0_QFN48_6X6
  oval 0.305x1.092 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6) 26(4,6) 27(3.6,6) 28(3.2,6) 29(2.8,6) 30(2.4,6) 31(2,6) 32(1.6,6) 33(1.2,6) 34(0.8,6) 35(0.4,6) 36(0,6)
  oval 1.092x0.305 smd: 13(5.2,0.8) 14(5.2,1.2) 15(5.2,1.6) 16(5.2,2) 17(5.2,2.4) 18(5.2,2.8) 19(5.2,3.2) 20(5.2,3.6) 21(5.2,4) 22(5.2,4.4) 23(5.2,4.8) 24(5.2,5.2) 37(-0.8,5.2) 38(-0.8,4.8) 39(-0.8,4.4) 40(-0.8,4) 41(-0.8,3.6) 42(-0.8,3.2) 43(-0.8,2.8) 44(-0.8,2.4) 45(-0.8,2) 46(-0.8,1.6) 47(-0.8,1.2) 48(-0.8,0.8)
  rect 2.997x2.997 smd: 49(2.2,3)
Y_8Y24000011_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_8Y25000010_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G027000FG1H-HX_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.8VSP_LX: PL801.1 PR803.2 PU801.1(LX1) PU801.2(LX2) PU801.3(LX3)
3V5V_ON: PC213.2 PQ201.6(D1) PR206.2 PR208.1 PU201.1(EN1) PU202.1(EN)
+0.95VS_VGA: CV22.1 CV29.1 CV30.1 CV31.1 CV32.1 CV33.1 CV34.1 CV35.1 CV36.1 CV70.1 CV71.1 JV1.2 LV5.1 RV47.2 RV48.2 UV3.AD14(DP_VDDC) UV3.L23(PCIE_VDDC_1) UV3.L24(PCIE_VDDC_2) UV3.L25(PCIE_VDDC_3) UV3.L26(PCIE_VDDC_4) UV3.M22(PCIE_VDDC_5) UV3.N22(PCIE_VDDC_6) UV3.N23(PCIE_VDDC_7) UV3.N24(PCIE_VDDC_8) UV3.R21(BIF_VDDC_1) UV3.R22(PCIE_VDDC_9) UV3.T22(PCIE_VDDC_10) UV3.U21(BIF_VDDC_2) UV3.U22(PCIE_VDDC_11) UV3.V22(PCIE_VDDC_12)
+0.95VS_VGA_GATE: QV10.3(D2) RV129.2 RV130.1
+0.675VS: CD23.1 CD24.1 CD25.1 CD26.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 JDIMM1.203(VTT1) JDIMM1.204(VTT2) JDIMM2.203(VTT_1) JDIMM2.204(VTT_2) PJ303.1 R159.1
+0.675VSP: PC308.1 PC309.1 PJ303.2 PU301.2(VTTSNS) PU301.20(VTT)
+1.8V_LDO: CA6.2 CA7.1 UA1.3(FILT_1.8V)
+1.8VALW: CV176.1 PJ802.1 RC173.1 UV12.1(VIN1) UV12.2(VIN2)
+1.8VALW_PCH: CC61.1 RC173.2 UC1.AA1(VCCATS_1P8) UC1.AF16(VCCPGPPF)
+1.8VS_VGA: CV9.1 CV26.1 CV27.1 CV28.1 CV66.1 CV67.1 CV145.1 CV150.1 CV177.1 LV3.1 LV4.1 PR644.1 RV54.1 RV55.1 RV98.1 RV100.1 RV102.1 RV104.1 RV121.2 RV123.2 RV125.2 TPV14.1 UV3.AA20(VDD_GPIO18_1) UV3.AA21(VDD_GPIO18_2) UV3.AB20(VDD_GPIO18_3) UV3.AB21(VDD_GPIO18_4) UV3.AD17(TSVDD) UV3.AF14(DP_VDDR) UV3.AM30(PCIE_PVDD) UV9.8(VCC(B)) UV12.7(VOUT1) UV12.8(VOUT2)
+1.8VSP: PC805.1 PC806.1 PC807.1 PC808.1 PJ802.2 PL801.2 PR804.1
+1.35V: CC94.1 CC205.1 CC206.1 CC207.1 CC208.1 CC209.1 CC210.1 CC340.1 CC341.1 CC342.1 CC343.1 CC344.1 CC526.1 CD8.1 CD9.1 CD10.1 CD11.1 CD13.1 CD14.1 CD15.1 CD16.1 CD19.1 CD20.1 CD21.1 CD22.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CRF1.1 CRF2.1 CRF3.1 CRF4.1 CV163.1 JDIMM1.75(VDD1) JDIMM1.76(VDD2) JDIMM1.81(VDD3) JDIMM1.82(VDD4) JDIMM1.87(VDD5) JDIMM1.88(VDD6) JDIMM1.93(VDD7) JDIMM1.94(VDD8) JDIMM1.99(VDD9) JDIMM1.100(VDD10) JDIMM1.105(VDD11) JDIMM1.106(VDD12) JDIMM1.111(VDD13) JDIMM1.112(VDD14) JDIMM1.117(VDD15) JDIMM1.118(VDD16) JDIMM1.123(VDD17) JDIMM1.124(VDD18) JDIMM2.75(VDD_1) JDIMM2.76(VDD_2) JDIMM2.81(VDD_3) JDIMM2.82(VDD_4) JDIMM2.87(VDD_5) JDIMM2.88(VDD_6) JDIMM2.93(VDD_7) JDIMM2.94(VDD_8) JDIMM2.99(VDD_9) JDIMM2.100(VDD_10) JDIMM2.105(VDD_11) JDIMM2.106(VDD_12) JDIMM2.111(VDD_13) JDIMM2.112(VDD_14) JDIMM2.117(VDD_15) JDIMM2.118(VDD_16) JDIMM2.123(VDD_17) JDIMM2.124(VDD_18) PJ301.1 PJ302.1 QD1.2(BASE) RD1.1 RD9.1 RD15.1 RD21.1 RRE32.2 UC1.AL23(VCCPLL_OC) UC1.AM40(VDDQC) UC1.AU23(VDDQ_AU23) UC1.AU28(VDDQ_AU28) UC1.AU35(VDDQ_AU35) UC1.AU42(VDDQ_AU42) UC1.BB23(VDDQ_BB23) UC1.BB32(VDDQ_BB32) UC1.BB41(VDDQ_BB41) UC1.BB47(VDDQ_BB47) UC1.BB51(VDDQ_BB51) UV11.1(VIN1) UV11.2(VIN2)
+1.35VP: PC301.1 PC311.1(P) PC312.1 PC313.1 PC314.1 PJ301.2 PJ302.2 PL301.1 PR305.1 PU301.5(VDDQ) PU301.19(VLDOIN)
+1.35VS_VGA: CV1.1 CV2.1 CV3.1 CV4.1 CV5.1 CV6.1 CV7.1 CV8.1 CV78.1 CV79.1 CV80.1 CV81.1 CV82.1 CV83.1 CV84.1 CV85.1 CV86.1 CV87.1 CV88.1 CV89.1 CV90.1 CV91.1 CV92.1 CV93.1 CV94.1 CV95.1 CV96.1 CV97.1 CV98.1 CV99.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV110.1 CV111.1 CV112.1 CV113.1 CV114.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV120.1 CV121.1 CV122.1 CV123.1 CV124.1 CV125.1 CV126.1 CV166.1 RV5.1 RV7.1 RV18.1 RV24.1 RV30.1 RV36.1 UV3.H13(VMEMIO_1) UV3.H16(VMEMIO_2) UV3.H19(VMEMIO_3) UV3.J9(VMEMIO_7) UV3.J10(VMEMIO_4) UV3.J23(VMEMIO_5) UV3.J24(VMEMIO_6) UV3.K9(VMEMIO_11) UV3.K10(VMEMIO_8) UV3.K23(VMEMIO_9) UV3.K24(VMEMIO_10) UV3.L11(VMEMIO_12) UV3.L12(VMEMIO_13) UV3.L13(VMEMIO_14) UV3.L20(VMEMIO_15) UV3.L21(VMEMIO_16) UV3.L22(VMEMIO_17) UV5.A1(VDDQ_1) UV5.A8(VDDQ_2) UV5.B2(VDD_1) UV5.C1(VDDQ_3) UV5.C9(VDDQ_4) UV5.D2(VDDQ_5) UV5.D9(VDD_2) UV5.E9(VDDQ_6) UV5.F1(VDDQ_7) UV5.G7(VDD_3) UV5.H2(VDDQ_8) UV5.H9(VDDQ_9) UV5.K2(VDD_4) UV5.K8(VDD_5) UV5.N1(VDD_6) UV5.N9(VDD_7) UV5.R1(VDD_8) UV5.R9(VDD_9) UV6.A1(VDDQ_1) UV6.A8(VDDQ_2) UV6.B2(VDD_1) UV6.C1(VDDQ_3) UV6.C9(VDDQ_4) UV6.D2(VDDQ_5) UV6.D9(VDD_2) UV6.E9(VDDQ_6) UV6.F1(VDDQ_7) UV6.G7(VDD_3) UV6.H2(VDDQ_8) UV6.H9(VDDQ_9) UV6.K2(VDD_4) UV6.K8(VDD_5) UV6.N1(VDD_6) UV6.N9(VDD_7) UV6.R1(VDD_8) UV6.R9(VDD_9) UV7.A1(VDDQ_1) UV7.A8(VDDQ_2) UV7.B2(VDD_1) UV7.C1(VDDQ_3) UV7.C9(VDDQ_4) UV7.D2(VDDQ_5) UV7.D9(VDD_2) UV7.E9(VDDQ_6) UV7.F1(VDDQ_7) UV7.G7(VDD_3) UV7.H2(VDDQ_8) UV7.H9(VDDQ_9) UV7.K2(VDD_4) UV7.K8(VDD_5) UV7.N1(VDD_6) UV7.N9(VDD_7) UV7.R1(VDD_8) UV7.R9(VDD_9) UV8.A1(VDDQ_1) UV8.A8(VDDQ_2) UV8.B2(VDD_1) UV8.C1(VDDQ_3) UV8.C9(VDDQ_4) UV8.D2(VDDQ_5) UV8.D9(VDD_2) UV8.E9(VDDQ_6) UV8.F1(VDDQ_7) UV8.G7(VDD_3) UV8.H2(VDDQ_8) UV8.H9(VDDQ_9) UV8.K2(VDD_4) UV8.K8(VDD_5) UV8.N1(VDD_6) UV8.N9(VDD_7) UV8.R1(VDD_8) UV8.R9(VDD_9) UV11.7(VOUT1) UV11.8(VOUT2)
+1.65V_LDO: CA8.1 CA9.1 UA1.29(VREF_1.65V)
+1VALW: C749.2 C8534.2 JC2.1 PJ702.1 PJ703.1 Q23.5(D1) Q23.6(D2) Q23.7(D3) Q23.8(D4) QV9.5(D1) QV9.6(D2) QV9.7(D3) QV9.8(D4) RC176.1 RC362.2 U148.A1(IN) U149.3(D)
+1VALW_CLK2: LC3.1 UC1.K19(VCCCLK2)
+1VALW_CLK4: LC4.1 UC1.N20(VCCCLK4)
+1VALW_CLK5: LC5.1 UC1.L19(VCCCLK5)
+1VALW_PCH: CC49.1 CC95.1 CC535.2 LC2.1 LC3.2 LC4.2 LC5.2 RC176.2 RC304.1 RC354.2 RC373.2 RC374.2 UC1.A10(VCCCLK6) UC1.A14(VCCCLK1) UC1.AB17(VCCPRIM_1P0_AB17) UC1.AB19(VCCPRIM_1P0_AB19) UC1.AB20(VCCPRIM_1P0_AB20) UC1.AK20(VCCPRIM_1P0_AK20) UC1.K17(VCCMPHYAON_1P0_K17) UC1.L1(VCCMPHYAON_1P0_L1) UC1.L21(VCCCLK3) UC1.P18(VCCPRIM_1P0_P18) UC1.T1(VCCPRIM_1P0_T1) UC1.Y18(VCCPRIM_1P0_Y18)
+1VALW_PLL: CC539.1 LC2.2 UC1.V15(VCCAPLL_1P0)
+1VS_VGA: CV161.1 CV162.1 JV1.1 QV9.1(S1) QV9.2(S2) QV9.3(S3) RV141.2
+3V_AVDD_HP: CA13.1 RA2.1 RA3.2 RA30.1 UA1.24(AVDD_HP)
+3V_DDR: C751.1 RD23.1 U17.1(OUT)
+3V_LDO: CA10.1 CA11.1 UA1.27(AVDD_3.3)
+3V_PWRGD: PR210.1 PU201.2(PG)
+3V_SPI: C8496.1 C8497.1 C8498.1 C8499.1 CC25.1 CC26.1 Q29.3(S) R261.2 RC110.2 RC117.1 RC118.1 RC310.2 UC1.AJ16(VCCSPI) UC4M1.8(VCC) UC8M1.8(VCC) UTPM1.1(VSB) UTPM1.14(VDD2) UTPM1.22(VDD3)
+3V_VIN: PC201.1 PC202.1 PC230.1 PJ201.1 PR201.1 PU201.7(EN2) PU201.8(IN)
+3V_WLAN: C67.1 C182.1 C183.1 JWLBT.2(3.3VAUX1) JWLBT.4(3.3VAUX2) JWLBT.72(3.3VAUX4) JWLBT.74(3.3VAUX5) Q27.1(D) R94.2 R95.2
+3VALW: C73.1 C748.1 C750.1 CG1.1 PD4.1 PJ202.1 PR4.2 PR11.1 PR16.1 PR130.1 PR209.1 Q27.3(S) QG1.3(S) QL2.3(S) R25.1 R84.1 R93.1 R95.1 R722.2 RA2.2 RC310.1 RC341.1 RC351.1 RC353.1 RC379.1 RC382.1 RE15.1 RE48.1 RE49.1 RG1.1 RL1.1 RPC6.5(R5) RPC6.6(R6) RPC6.7(R7) RPC6.8(R8) RPC18.1(R1) RPC18.2(R2) RPC18.3(R3) RPC18.4(R4) RPE1.1(R1) RPE1.2(R2) RPE1.3(R3) RPE1.4(R4) RPE2.1(R1) RPE2.2(R2) RPE2.3(R3) RPE2.4(R4) U11.6(VIN2_1) U11.7(VIN2_2) U17.5(IN) U149.1(VDD) UC3.5(VCC)
+3VALW_FB: PC212.1 PU201.3(FB)
+3VALW_GS: C8527.1 CC101.1 CG2.1 CG3.1 QG1.1(D) QV13.2(G1) QV13.5(G2) RC350.2 RG1.2 RG2.1 UGSEN1.1(VDD_IO) UGSEN1.14(VDD)
+3VALW_LAN: CL3.1 QL2.1(D) RL1.2 RL4.2 RL5.1 RL6.1 RL9.1 RL15.1 RL16.1 UL1.4(VDD3P3_4) UL1.5(VDD3P3_IN) UL1.15(VDD3P3_15) UL1.19(VDD3P3_19) UL1.29(VDD3P3_29)
+3VALW_LOGO: C180.1 C181.1 D1.3 JLCD.9 R25.2
+3VALW_OUT: PR203.1 PU201.4(OUT)
+3VALW_P: PC204.1 PC205.1 PC206.1 PC207.1 PC210.1 PC211.1 PJ202.2 PL201.2 PR203.2 PR207.2
+3VALW_PCH: CC530.1 CC531.1 CC532.1 RA27.1 RC83.1 RC92.2 RC93.2 RC95.2 RC97.1 RC99.1 RC101.1 RC132.1 RC298.2 RC306.2 RC308.2 RC326.1 RC330.1 RC333.1 RC341.2 RC367.2 RC368.2 RC371.1 RC375.2 RC376.2 RC377.2 RC378.2 RPC15.1(R1) RPC15.2(R2) RPC15.3(R3) RPC15.4(R4) RPC26.6(R6) UC1.AD15(VCCPGPPG) UC1.AG15(VCCPGPPB) UC1.AK15(VCCPGPPA) UC1.T16(VCCPGPPE) UC1.Y15(VCCPGPPD) UC1.Y16(VCCPGPPC)
+3VALW_PRIM: CC97.1 RC326.2 UC1.AJ21(VCCPRIM_3P3_AJ21) UC1.V19(VCCPRIM_3P3_V19)
+3VALW_RTCPRIM: C200.1 C201.1 CC58.1 RC333.2 UC1.AK17(VCCRTCPRIM_3P3)
+3VBS: PR202.1 PU201.6(BS)
+3VDMIC: JLCD.5 R22.2
+3VL: C53.1 CE4.1 CE5.1 CE6.1 CE8.1 CE9.1 CE10.1 LE1.1 PR10.1 PR18.2 PR205.2 PR216.1 PR217.1 R71.1 RA30.2 RC127.1 RE3.2 RE4.1 RE31.2 RE33.2 RE39.2 RPE3.4(R4) RPE5.1(R1) RPE5.2(R2) U8.2(VDD) UE1.26(VSTBY1) UE1.50(VSTBY2) UE1.92(VSTBY3) UE1.112(VSTBY0) UE1.114(VSTBY4) UE1.121(VSTBY5) UE1.127(VSTBY(PLL))
+3VL_AVCC: CE2.1 CE3.1 LE1.2 UE1.74(AVCC)
+3VLX: PC203.2 PL201.1 PR204.2 PU201.10(LX)
+3VS: C1.1 C8.1 C10.1 C28.1 C29.1 C34.1 C35.1 C50.1 C51.1 C52.1 C74.1 C115.1 C116.1 C184.1 C189.1 C204.1 C205.1 CA1.1 CA12.1 CC22.1 CD29.1 CD30.1 CD57.1 CD58.1 CRE23.1 CRE24.1 J6.2 JCR.12 JCR.13 JCR.14 JDIMM1.199(VDDSPD) JDIMM2.199(VDDSPD) JHDD.8(VCC_3V3_1) JHDD.9(VCC_3V3_2) JTOUCH1.1 JU3AC.15 PR308.2 PR406.2 PR704.2 QC1.2(G1) QC1.5(G2) QC2.2(G1) QC2.5(G2) QV5.3(S) R3.2 R17.1 R22.1 R35.2 R36.2 R37.2 R38.2 R39.2 R40.2 R41.2 R42.2 R43.2 R49.2 R50.2 R51.2 R52.2 R53.2 R54.2 R55.2 R56.2 R57.2 R60.1 R70.1 R94.1 R106.1 R111.1 R113.1 R244.2 R245.2 R246.2 R247.2 R248.2 R249.2 R250.2 R251.2 R252.2 R268.2 RA3.1 RA4.2 RA18.1 RA25.1 RA28.1 RC1.1 RC2.1 RC29.1 RC52.2 RC67.1 RC70.1 RC88.1 RC106.2 RC107.2 RC108.1 RC110.1 RC165.1 RC277.1 RC287.1 RC347.2 RC388.1 RC408.1 RC409.1 RD19.1 RE8.2 RE9.2 RE41.1 RE47.2 RM14.1 RPC8.5(R5) RPC8.6(R6) RPC8.7(R7) RPC8.8(R8) RPC10.5(R5) RPC10.6(R6) RPC10.7(R7) RPC10.8(R8) RPC22.5(R5) RPC22.6(R6) RPC22.7(R7) RPC22.8(R8) RPC26.7(R7) RPC26.8(R8) RPC200.1(R1) RPC200.2(R2) RPC200.3(R3) RPC200.4(R4) RPE3.1(R1) RPE3.2(R2) RPE5.3(R3) RPE5.4(R4) RRE21.1 RRE22.1 RRE23.1 RRE24.1 RRE25.2 U1.1(VDD) U3.5(IN) U4.5(IN) U5.1(VDD1) U5.13(VDD2) U6.1(VDD1) U6.13(VDD2) U16.1(VDD1) U16.13(VDD2) UE1.11(VCC) URE1.11(VDD33_1) URE1.37(VDD33_2) USROM1.8(VCC) UTPM1.8(VDD1) UV4.5(VCC)
+3VS_CMOS: C11.1 C176.1 C177.1 JLCD.6 R17.2 U4.1(OUT)
+3VS_DP: CM9.1 CM10.1 RM14.2 RM20.1 RM21.1 RM22.1 RM23.1 RM28.1 RM32.1 RM34.1 UM1.1(V3P31) UM1.6(VCORE2) UM1.12(VCORE3) UM1.25(VCORE6) UM1.32(VCORE7) UM1.36(V3P32)
+3VS_DVDD: CA14.1 RA4.1 UA1.18(DVDD_3.3)
+3VS_FP: JFPB.6 R70.2
+3VS_LS: J6.1 U11.8(VOUT2_1) U11.9(VOUT2_2)
+3VS_VDDIO: CA42.1 RA25.2 RA27.2 UA1.7(VDD_IO)
+3VS_VDDO: RA28.2 RA29.1 UA1.2(VDDO_3.3)
+3VS_VGA: CV10.1 CV149.1 JV3.2 PR604.2 PR612.1 QV2.2(G1) QV2.5(G2) RV43.1 RV50.1 RV52.1 RV61.1 RV63.1 RV64.1 RV65.1 RV66.1 RV70.1 RV71.1 RV72.1 RV73.1 RV76.1 RV80.1 RV91.1 RV92.1 RV95.2 RV111.1 RV115.1 RV118.2 RV119.2 RV120.2 RV138.2 UV3.AA17(VDD_GPIO33_1) UV3.AA18(VDD_GPIO33_2) UV3.AB17(VDD_GPIO33_3) UV3.AB18(VDD_GPIO33_4) UV9.1(VCC(A))
+5V_ALW: JU3AC.11 JU3AC.12 JU3AC.13 JU3AC.14 U14.12(OUT)
+5V_PWRGD: PR211.1 PU202.2(PG)
+5V_VCC: PC218.2 PU202.5(VCC)
+5V_VIN: PC214.1 PC215.1 PC216.1 PC231.1 PJ203.1 PU202.8(IN)
+5VALW: C40.1 C41.1 C68.1 C69.1 C119.1 CV164.1 CV175.1 D15.5(VBUS) F1.2 PC444.1 PC455.1 PC463.1 PC705.2 PJ204.1 PJ801.2 PR306.1 PR402.1 PR601.2 PR602.2 PR706.1 PU401.9(CSP2_2PH) PU402.4(VCC) PU403.4(VCC) PU404.4(VCC) PU701.18(V5) R88.1 R156.1 R9448.1 R9450.1 RE2.2 RL22.1 RV134.1 RV143.1 U11.1(VIN1_1) U11.2(VIN1_2) U11.4(VBIAS) U14.1(IN) U14.4(ILIM_SEL) U14.7(CLT2) U15.5(IN) UV11.4(VBIAS) UV12.4(VBIAS)
+5VALW_OUT: PR213.1 PU202.4(OUT)
+5VALW_P: PC219.1 PC220.1 PC221.1 PC222.1 PC223.1 PC224.1 PC227.1 PC228.1 PJ204.2 PL202.2 PR213.2 PR215.2
+5VBS: PR212.1 PU202.6(BS)
+5VFB: PC229.1 PU202.3(FB)
+5VLP: PC8.1 PC225.1 PR9.2 PU1.1(VCC) PU202.7(LDO) R157.1
+5VLX: PC217.2 PL202.1 PR214.2 PU202.10(LX)
+5VS: C19.1 C20.1 C21.1 C22.1 C23.1 C70.1 C202.1 C203.1 D24.2 J5.2 JHDD.14(VCC5_1) JHDD.15(VCC5_2) JHDD.16(VCC5_3) JTP.8 Q4.2(G) Q22.1(D) R58.1 R59.1 R63.1 R65.1 R68.1 R9446.1 RA1.1 RA6.2 RE5.2 RE6.2 RV129.1
+5VS_AVDD: CA15.1 RA6.1 UA1.28(AVDD_5V)
+5VS_CLASSD: CA2.1 CA3.1 CA4.1 CA5.1 CA16.1 RA1.2 UA1.13(LPWR_5.0) UA1.16(RPWR_5.0)
+5VS_HDMI: D2.1(IN1) D2.9(OUT4) F2.2 JHDMI.18(+5V) R4.1 R5.1
+5VS_HDMI_F: D24.1 F2.1 Q22.3(S)
+5VS_LS: J5.1 U11.13(VOUT1_1) U11.14(VOUT1_2)
+AVEE: CA18.1 UA1.21(AVEE)
+V1.00AP: PC711.1 PC712.1 PC713.1 PC715.1 PC716.1 PC717.1 PJ702.2 PJ703.2 PL701.2 PU701.22(VSNS)
+VCC_AMPHYPLL: CC46.1 LC1.2 UC1.K15(VCCAMPHYPLL_1P0_K15) UC1.L15(VCCAMPHYPLL_1P0_L15)
+VCC_CORE: CC235.1 CC236.1 CC237.1 CC238.1 CC239.1 CC240.1 CC241.1 CC242.1 CC243.1 CC244.1 CC245.1 CC246.1 CC247.1 CC248.1 CC249.1 CC250.1 CC251.1 CC252.1 CC253.1 CC254.1 CC255.1 CC256.1 CC257.1 CC266.1 CC267.1 CC268.1 CC269.1 CC270.1 CC271.1 CC272.1 CC500.1 CC501.1 CC502.1 CC503.1 CC504.1 CC505.1 CC506.1 CC507.1 CC508.1 CC509.1 CC510.1 CC511.1 CC512.1 CC514.1 CC515.1 CC516.1 CC517.1 CC518.1 CC519.1 PC443.1(P) PC465.2 PC466.2 PC467.2 PC468.2 PC469.2 PC470.2 PC471.2 PC472.2 PC473.2 PC474.2 PC475.2 PC476.2 PC477.2 PC478.2 PC479.2 PC480.2 PC481.2 PC482.2 PC483.2 PC484.2 PC485.2 PC486.2 PC487.2 PL403.2 PR452.1 RC120.1 UC1.A30(VCC_A30) UC1.A34(VCC_A34) UC1.A39(VCC_A39) UC1.A44(VCC_A44) UC1.AK33(VCC_AK33) UC1.AK35(VCC_AK35) UC1.AK37(VCC_AK37) UC1.AK38(VCC_AK38) UC1.AK40(VCC_AK40) UC1.AL33(VCC_AL33) UC1.AL37(VCC_AL37) UC1.AL40(VCC_AL40) UC1.AM32(VCC_AM32) UC1.AM33(VCC_AM33) UC1.AM35(VCC_AM35) UC1.AM37(VCC_AM37) UC1.AM38(VCC_AM38) UC1.G30(VCC_G30) UC1.G32(VCC_G32) UC1.G33(VCC_G33) UC1.G35(VCC_G35) UC1.G37(VCC_G37) UC1.G38(VCC_G38) UC1.G40(VCC_G40) UC1.G42(VCC_G42) UC1.J30(VCC_J30) UC1.J33(VCC_J33) UC1.J37(VCC_J37) UC1.J40(VCC_J40) UC1.K33(VCC_K33) UC1.K35(VCC_K35) UC1.K37(VCC_K37) UC1.K38(VCC_K38) UC1.K40(VCC_K40) UC1.K42(VCC_K42) UC1.K43(VCC_K43)
+VCC_DSW3P3: RC127.2 RC132.2 UC1.AD17(VCCDSW_3P3_AD17) UC1.AD18(VCCDSW_3P3_AD18) UC1.AJ17(VCCDSW_3P3_AJ17)
+VCC_FAN1: JFAN.2 R68.2
+VCC_GT: CC273.1 CC274.1 CC275.1 CC276.1 CC277.1 CC278.1 CC279.1 CC280.1 CC281.1 CC282.1 CC283.1 CC284.1 CC285.1 CC286.1 CC287.1 CC288.1 CC289.1 CC290.1 CC291.1 CC292.1 CC293.1 CC294.1 CC520.1 CC521.1 CC522.1 CC523.1 CC524.1 CC525.1 PC454.1(P) PC488.2 PC489.2 PC490.2 PC491.2 PC492.2 PC493.2 PC494.2 PC495.2 PC496.2 PC497.2 PC498.2 PC499.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PL406.2 PR456.1 RC125.1 UC1.A48(VCCGT_A48) UC1.A53(VCCGT_A53) UC1.A58(VCCGT_A58) UC1.A62(VCCGT_A62) UC1.A66(VCCGT_A66) UC1.AA63(VCCGT_AA63) UC1.AA64(VCCGT_AA64) UC1.AA66(VCCGT_AA66) UC1.AA67(VCCGT_AA67) UC1.AA69(VCCGT_AA69) UC1.AA70(VCCGT_AA70) UC1.AA71(VCCGT_AA71) UC1.AC64(VCCGT_AC64) UC1.AC65(VCCGT_AC65) UC1.AC66(VCCGT_AC66) UC1.AC67(VCCGT_AC67) UC1.AC68(VCCGT_AC68) UC1.AC69(VCCGT_AC69) UC1.AC70(VCCGT_AC70) UC1.AC71(VCCGT_AC71) UC1.J43(VCCGT_J43) UC1.J45(VCCGT_J45) UC1.J46(VCCGT_J46) UC1.J48(VCCGT_J48) UC1.J50(VCCGT_J50) UC1.J52(VCCGT_J52) UC1.J53(VCCGT_J53) UC1.J55(VCCGT_J55) UC1.J56(VCCGT_J56) UC1.J58(VCCGT_J58) UC1.J60(VCCGT_J60) UC1.K48(VCCGT_K48) UC1.K50(VCCGT_K50) UC1.K52(VCCGT_K52) UC1.K53(VCCGT_K53) UC1.K55(VCCGT_K55) UC1.K56(VCCGT_K56) UC1.K58(VCCGT_K58) UC1.K60(VCCGT_K60) UC1.L62(VCCGT_L62) UC1.L63(VCCGT_L63) UC1.L64(VCCGT_L64) UC1.L65(VCCGT_L65) UC1.L66(VCCGT_L66) UC1.L67(VCCGT_L67) UC1.L68(VCCGT_L68) UC1.L69(VCCGT_L69) UC1.L70(VCCGT_L70) UC1.L71(VCCGT_L71) UC1.M62(VCCGT_M62) UC1.N63(VCCGT_N63) UC1.N64(VCCGT_N64) UC1.N66(VCCGT_N66) UC1.N67(VCCGT_N67) UC1.N69(VCCGT_N69) UC1.N70(VCCGT_N70) UC1.N71(VCCGT_N71) UC1.R63(VCCGT_R63) UC1.R64(VCCGT_R64) UC1.R65(VCCGT_R65) UC1.R66(VCCGT_R66) UC1.R67(VCCGT_R67) UC1.R68(VCCGT_R68) UC1.R69(VCCGT_R69) UC1.R70(VCCGT_R70) UC1.R71(VCCGT_R71) UC1.T62(VCCGT_T62) UC1.U65(VCCGT_U65) UC1.U68(VCCGT_U68) UC1.U71(VCCGT_U71) UC1.W63(VCCGT_W63) UC1.W64(VCCGT_W64) UC1.W65(VCCGT_W65) UC1.W66(VCCGT_W66) UC1.W67(VCCGT_W67) UC1.W68(VCCGT_W68) UC1.W69(VCCGT_W69) UC1.W70(VCCGT_W70) UC1.W71(VCCGT_W71) UC1.Y62(VCCGT_Y62)
+VCC_HDA: CC99.1 CC540.1 RC299.2 RC330.2 UC1.AJ19(VCCHDA)
+VCC_IO: CC211.1 CC212.1 CC336.1 CC337.1 CC338.1 CC339.1 JC1.2 R272.1 RC104.1 RC105.1 RC192.2 RC297.2 RC344.1 UC1.AK28(VCCIO_AK28) UC1.AK30(VCCIO_AK30) UC1.AL30(VCCIO_AL30) UC1.AL42(VCCIO_AL42) UC1.AM28(VCCIO_AM28) UC1.AM30(VCCIO_AM30) UC1.AM42(VCCIO_AM42)
+VCC_IO_AP: C8536.1 C8537.1 JC1.1 Q23.1(S1) Q23.2(S2) Q23.3(S3)
+VCC_IO_AP_GATE: Q24.3(D2) R9446.2 R9447.1
+VCC_MPHYGT: C194.1 CC47.1 CC50.1 CC52.1 JC2.2 LC1.1 UC1.AF20(VCCSRAM_1P0_AF20) UC1.AF21(VCCSRAM_1P0_AF21) UC1.N15(VCCMPHYGT_1P0_N15) UC1.N16(VCCMPHYGT_1P0_N16) UC1.N17(VCCMPHYGT_1P0_N17) UC1.N18(VCCAPLLEBB) UC1.P15(VCCMPHYGT_1P0_P15) UC1.P16(VCCMPHYGT_1P0_P16) UC1.T19(VCCSRAM_1P0_T19) UC1.T20(VCCSRAM_1P0_T20)
+VCC_SA: CC213.1 CC214.1 CC215.1 CC216.1 CC217.1 CC218.1 CC219.1 CC220.1 CC221.1 CC222.1 CC223.1 CC224.1 CC225.1 CC329.1 CC330.1 CC331.1 CC332.1 CC333.1 CC334.1 CC335.1 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PL408.2 PR460.1 RC370.1 UC1.AK23(VCCSA_AK23) UC1.AK25(VCCSA_AK25) UC1.G23(VCCSA_G23) UC1.G25(VCCSA_G25) UC1.G27(VCCSA_G27) UC1.G28(VCCSA_G28) UC1.J22(VCCSA_J22) UC1.J23(VCCSA_J23) UC1.J27(VCCSA_J27) UC1.K23(VCCSA_K23) UC1.K25(VCCSA_K25) UC1.K27(VCCSA_K27) UC1.K28(VCCSA_K28) UC1.K30(VCCSA_K30)
+VCC_ST: C8535.2 CC69.1 CC70.1 PC403.1 PR403.1 PR404.1 RC3.2 RC20.1 RC31.2 RC34.2 RC53.1 RC355.1 RC356.1 RC358.1 U148.A2(OUT) UC1.A18(VCCST) UC1.K20(VCCPLL_K20) UC1.K21(VCCPLL_K21)
+VCC_STG: CC68.1 R272.2 RC123.1 RC294.1 RC383.2 RC404.2 U149.4(S) UC1.A22(VCCSTG_A22) UC1.G20(VCCSTG_G20)
GND: C1.2 C8.2 C9.2 C10.2 C11.2 C12.2 C19.2 C20.2 C21.2 C22.2 C23.2 C28.2 C29.2 C34.2 C35.2 C40.2 C41.2 C44.2 C45.2 C50.2 C51.2 C52.2 C53.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C115.2 C116.2 C118.2 C119.2 C120.2 C123.2 C127.2 C128.2 C129.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C189.2 C194.2 C197.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C747.1 C748.2 C749.1 C750.2 C751.2 C8496.2 C8497.2 C8498.2 C8499.2 C8527.2 C8534.1 C8535.1 C8536.2 C8537.2 C8538.2 C8542.2 CA1.2 CA2.2 CA3.2 CA4.2 CA5.2 CA6.1 CA7.2 CA12.2 CA13.2 CA14.2 CA15.2 CA18.2 CA19.1 CA25.1 CA26.1 CA27.1 CA28.1 CA40.2 CA42.2 CA43.2 CC1.2 CC2.2 CC3.2 CC4.2 CC5.2 CC6.2 CC7.2 CC9.2 CC22.2 CC25.2 CC26.2 CC46.2 CC47.2 CC49.2 CC50.2 CC52.2 CC58.2 CC59.2 CC60.2 CC61.2 CC68.2 CC69.2 CC70.2 CC94.2 CC95.2 CC96.2 CC97.2 CC99.2 CC101.2 CC102.2 CC205.2 CC206.2 CC207.2 CC208.2 CC209.2 CC210.2 CC211.2 CC212.2 CC213.2 CC214.2 CC215.2 CC216.2 CC217.2 CC218.2 CC219.2 CC220.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC235.2 CC236.2 CC237.2 CC238.2 CC239.2 CC240.2 CC241.2 CC242.2 CC243.2 CC244.2 CC245.2 CC246.2 CC247.2 CC248.2 CC249.2 CC250.2 CC251.2 CC252.2 CC253.2 CC254.2 CC255.2 CC256.2 CC257.2 CC266.2 CC267.2 CC268.2 CC269.2 CC270.2 CC271.2 CC272.2 CC273.2 CC274.2 CC275.2 CC276.2 CC277.2 CC278.2 CC279.2 CC280.2 CC281.2 CC282.2 CC283.2 CC284.2 CC285.2 CC286.2 CC287.2 CC288.2 CC289.2 CC290.2 CC291.2 CC292.2 CC293.2 CC294.2 CC329.2 CC330.2 CC331.2 CC332.2 CC333.2 CC334.2 CC335.2 CC336.2 CC337.2 CC338.2 CC339.2 CC340.2 CC341.2 CC342.2 CC343.2 CC344.2 CC500.2 CC501.2 CC502.2 CC503.2 CC504.2 CC505.2 CC506.2 CC507.2 CC508.2 CC509.2 CC510.2 CC511.2 CC512.2 CC514.2 CC515.2 CC516.2 CC517.2 CC518.2 CC519.2 CC520.2 CC521.2 CC522.2 CC523.2 CC524.2 CC525.2 CC526.2 CC527.1 CC528.1 CC529.1 CC530.2 CC531.2 CC532.2 CC535.1 CC536.1 CC537.2 CC538.2 CC539.2 CC540.2 CD1.2 CD3.2 CD8.2 CD9.2 CD10.2 CD11.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD29.2 CD30.2 CD32.2 CD33.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CE1.2 CE4.2 CE5.2 CE6.2 CE7.1 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.1 CE14.2 CE16.2 CE17.2 CG3.2 CG4.2 CL3.2 CL4.2 CL5.2 CL6.1 CL7.2 CL8.2 CL9.2 CL11.2 CL12.2 CL13.2 CL17.2 CM9.2 CM10.2 CM11.2 CM12.2 CRE17.2 CRE18.2 CRE19.2 CRE20.2 CRE21.2 CRE22.2 CRE23.2 CRE24.2 CRF1.2 CRF2.2 CRF3.2 CRF4.2 CV1.2 CV2.2 CV3.2 CV4.2 CV5.2 CV6.2 CV7.2 CV8.2 CV9.2 CV10.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV24.2 CV25.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.2 CV33.2 CV34.2 CV35.2 CV36.2 CV37.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV110.2 CV111.2 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV130.2 CV131.2 CV140.2 CV141.2 CV142.2 CV143.2 CV144.2 CV145.2 CV148.2 CV149.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV160.2 CV161.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV169.2 CV175.2 CV176.2 CV177.2 CV178.2 CV179.2 D1.1 D2.3(GND) D3.3(GND) D4.1 D5.1 D7.3(GND) D8.2(GROUND) D9.2(GROUND) D10.3(GND) D11.3(GND) D15.2(GROUND) D16.3(GND) D17.3(GND) D18.3(GND) DL1.3(GND) DL2.3(GND) H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H10.1 H11.1 H12.1 H14.1 H15.1 H17.1 H18.1 H19.1 H20.1 H21.1 H24.1 H27.1 H28.1 IT3.1 IT4.1 IT5.1 J1.1 JBATT1.1 JBATT1.2 JBATT1.8(PTH1) JBATT1.9(PTH2) JCMOS1.2 JCP.12 JCP.13(GND1) JCP.14(GND2) JCR.3 JCR.6 JCR.15(GND1) JCR.16(GND2) JDIMM1.2(VSS1) JDIMM1.3(VSS2) JDIMM1.8(VSS3) JDIMM1.9(VSS4) JDIMM1.11(DM0) JDIMM1.13(VSS5) JDIMM1.14(VSS6) JDIMM1.19(VSS7) JDIMM1.20(VSS8) JDIMM1.25(VSS9) JDIMM1.26(VSS10) JDIMM1.28(DM1) JDIMM1.31(VSS11) JDIMM1.32(VSS12) JDIMM1.37(VSS13) JDIMM1.38(VSS14) JDIMM1.43(VSS15) JDIMM1.44(VSS16) JDIMM1.46(DM2) JDIMM1.48(VSS17) JDIMM1.49(VSS18) JDIMM1.54(VSS19) JDIMM1.55(VSS20) JDIMM1.60(VSS21) JDIMM1.61(VSS22) JDIMM1.63(DM3) JDIMM1.65(VSS23) JDIMM1.66(VSS24) JDIMM1.71(VSS25) JDIMM1.72(VSS26) JDIMM1.127(VSS27) JDIMM1.128(VSS28) JDIMM1.133(VSS29) JDIMM1.134(VSS30) JDIMM1.136(DM4) JDIMM1.138(VSS31) JDIMM1.139(VSS32) JDIMM1.144(VSS33) JDIMM1.145(VSS34) JDIMM1.150(VSS35) JDIMM1.151(VSS36) JDIMM1.153(DM5) JDIMM1.155(VSS37) JDIMM1.156(VSS38) JDIMM1.161(VSS39) JDIMM1.162(VSS40) JDIMM1.167(VSS41) JDIMM1.168(VSS42) JDIMM1.170(DM6) JDIMM1.172(VSS43) JDIMM1.173(VSS44) JDIMM1.178(VSS45) JDIMM1.179(VSS46) JDIMM1.184(VSS47) JDIMM1.185(VSS48) JDIMM1.187(DM7) JDIMM1.189(VSS49) JDIMM1.190(VSS50) JDIMM1.195(VSS51) JDIMM1.196(VSS52) JDIMM1.205(G1) JDIMM1.206(G2) JDIMM2.2(VSS_2) JDIMM2.3(VSS_1) JDIMM2.8(VSS_4) JDIMM2.9(VSS_3) JDIMM2.11(DM0) JDIMM2.13(VSS_5) JDIMM2.14(VSS_6) JDIMM2.19(VSS_7) JDIMM2.20(VSS_8) JDIMM2.25(VSS_9) JDIMM2.26(VSS_10) JDIMM2.28(DM1) JDIMM2.31(VSS_11) JDIMM2.32(VSS_12) JDIMM2.37(VSS_13) JDIMM2.38(VSS_14) JDIMM2.43(VSS_15) JDIMM2.44(VSS_16) JDIMM2.46(DM2) JDIMM2.48(VSS_18) JDIMM2.49(VSS_17) JDIMM2.54(VSS_20) JDIMM2.55(VSS_19) JDIMM2.60(VSS_22) JDIMM2.61(VSS_21) JDIMM2.63(DM3) JDIMM2.65(VSS_23) JDIMM2.66(VSS_24) JDIMM2.71(VSS_25) JDIMM2.72(VSS_26) JDIMM2.127(VSS_27) JDIMM2.128(VSS_28) JDIMM2.133(VSS_29) JDIMM2.134(VSS_30) JDIMM2.136(DM4) JDIMM2.138(VSS_32) JDIMM2.139(VSS_31) JDIMM2.144(VSS_34) JDIMM2.145(VSS_33) JDIMM2.150(VSS_35) JDIMM2.151(VSS_36) JDIMM2.153(DM5) JDIMM2.155(VSS_37) JDIMM2.156(VSS_38) JDIMM2.161(VSS_39) JDIMM2.162(VSS_40) JDIMM2.167(VSS_41) JDIMM2.168(VSS_42) JDIMM2.170(DM6) JDIMM2.172(VSS_44) JDIMM2.173(VSS_43) JDIMM2.178(VSS_46) JDIMM2.179(VSS_45) JDIMM2.184(VSS_48) JDIMM2.185(VSS_47) JDIMM2.187(DM7) JDIMM2.189(VSS_49) JDIMM2.190(VSS_50) JDIMM2.195(VSS_51) JDIMM2.196(VSS_52) JDIMM2.205(GND1) JDIMM2.206(GND2) JFAN.4 JFAN.6(G1) JFAN.7(G2) JFPB.2 JFPB.3 JFPB.7(GND1) JFPB.8(GND2) JHDD.1(GND1) JHDD.4(GND2) JHDD.7(GND3) JHDD.11(GND4) JHDD.13(GND6) JHDD.17(GND7) JHDD.18(RESERVED) JHDD.19(GND8) JHDD.23(GND9) JHDD.24(GND10) JHDMI.2(D2_SHIELD) JHDMI.5(D1_SHIELD) JHDMI.8(D0_SHIELD) JHDMI.11(CK_SHIELD) JHDMI.17(DDC/CEC_GND) JHDMI.20(GND1) JHDMI.21(GND2) JHDMI.22(GND3) JHDMI.23(GND4) JKB.30 JKB.33(GND1) JKB.34(GND2) JLCD.13 JLCD.16 JLCD.19 JLCD.24 JLCD.27 JLCD.30 JLCD.31(GND1) JLCD.32(GND2) JLCD.33(GND3) JLCD.34(GND4) JLCD.35(GND5) JLCD.36(GND6) JLCD.37(GND7) JLCD.38(GND8) JLCD.39(GND9) JLCD.40(GND10) JLCD.41(GND11) JLINK.1(GND1) JLINK.7(GND2) JLINK.12(GND3) JLINK.13(GND4) JLINK.18(GND5) JLINK.24(GND6) JLINK.25(GND7) JLINK.29(GND8) JLINK.30(GND9) JLINK.31(GND10) JLINK.32(GND11) JLINK.33(GND12) JLINK.34(GND13) JLOGO.3(GND1) JLOGO.4(GND2) JME1.2 JRTC.2 JRTC.3(GND1) JRTC.4(GND2) JSPK.5(GND1) JSPK.6(GND2) JTOUCH1.3 JTOUCH1.6 JTOUCH1.10 JTOUCH1.11(GND1) JTOUCH1.12(GND2) JTP.7 JTP.13(GND1) JTP.14(GND2) JU3AC.1 JU3AC.4 JU3AC.7 JU3AC.10 JU3AC.16 JU3AC.17 JU3AC.27(GND1) JU3AC.28(GND2) JUSB1.4(GND) JUSB1.7(GND_DRAIN) JUSB1.10(GND2) JUSB1.11(GND3) JUSB1.12(GND4) JUSB1.13(GND5) JUSB2.4(GND) JUSB2.7(GND_DRAIN) JUSB2.10(GND2) JUSB2.11(GND3) JUSB2.12(GND4) JUSB2.13(GND5) JWLBT.1(GND1) JWLBT.7(GND2) JWLBT.18(GND16) JWLBT.23(GND3) JWLBT.24(GND13) JWLBT.29(GND4) JWLBT.30(GND14) JWLBT.33(GND5) JWLBT.36(GND15) JWLBT.39(GND6) JWLBT.45(GND7) JWLBT.51(GND8) JWLBT.57(GND9) JWLBT.63(GND10) JWLBT.69(GND11) JWLBT.75(GND12) JWLBT.76(PEG1) JWLBT.77(PEG2) LE2.2 PC1.1 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.1 PC103.1 PC104.1 PC106.2 PC107.2 PC109.2 PC110.1 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.1 PC119.1 PC120.1 PC121.2 PC122.2 PC123.2 PC125.1 PC126.1 PC127.1 PC128.2 PC201.2 PC202.2 PC204.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.1 PC210.2 PC211.2 PC213.1 PC214.2 PC215.2 PC216.2 PC218.1 PC219.2 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.1 PC227.2 PC228.2 PC230.2 PC231.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC311.2(G) PC312.2 PC313.2 PC315.2 PC316.2 PC317.1 PC318.2 PC319.2 PC401.2 PC402.2 PC403.2 PC408.2 PC409.1 PC411.1 PC412.1 PC416.1 PC417.2 PC424.2 PC427.1 PC430.1 PC431.1 PC432.2 PC433.2 PC434.2 PC435.2 PC436.2 PC437.2 PC438.2 PC441.2 PC443.2(G) PC444.2 PC445.2 PC446.2 PC447.2 PC448.2 PC449.2 PC450.2 PC451.2 PC452.2 PC454.2(G) PC455.2 PC456.1 PC457.2 PC458.2 PC459.2 PC460.2 PC461.2 PC463.2 PC464.2 PC465.1 PC466.1 PC467.1 PC468.1 PC469.1 PC470.1 PC471.1 PC472.1 PC473.1 PC474.1 PC475.1 PC476.1 PC477.1 PC478.1 PC479.1 PC480.1 PC481.1 PC482.1 PC483.1 PC484.1 PC485.1 PC486.1 PC487.1 PC488.1 PC489.1 PC490.1 PC491.1 PC492.1 PC493.1 PC494.1 PC495.1 PC496.1 PC497.1 PC498.1 PC499.1 PC500.1 PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PC508.1 PC509.1 PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC517.1 PC518.1 PC519.1 PC520.1 PC521.1 PC522.1 PC523.1 PC524.1 PC525.2(G) PC526.2(G) PC527.2(G) PC528.2(G) PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC606.2 PC607.2 PC611.2 PC613.2(G) PC614.2(G) PC615.2 PC616.2 PC619.1 PC620.2 PC622.2 PC623.2 PC624.2 PC625.2 PC626.2 PC627.2 PC629.2(G) PC630.2(G) PC631.2 PC632.2 PC636.1 PC637.1 PC701.2 PC702.1 PC703.2 PC705.1 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.2 PC712.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC718.2 PC801.2 PC802.2 PC803.2 PC804.1 PC806.2 PC807.2 PC808.2 PD5.2 PD7.1 PQ2.3(E) PQ3.3(S) PQ4.4(S2) PQ105.3(S) PQ107.1(S1) PQ107.2(S2) PQ107.3(S3) PQ201.1(S1) PQ201.4(S2) PQ302.1(S1) PQ302.2(S2) PQ302.3(S3) PQ402.1(S1) PQ402.2(S2) PQ402.3(S3) PQ403.1(S1) PQ403.2(S2) PQ403.3(S3) PQ405.1(S1) PQ405.2(S2) PQ405.3(S3) PQ406.1(S1) PQ406.2(S2) PQ406.3(S3) PQ408.1(S1) PQ408.2(S2) PQ408.3(S3) PQ602.1(S1) PQ602.2(S2) PQ602.3(S3) PQ603.1(S1) PQ603.2(S2) PQ603.3(S3) PQ605.1(S1) PQ605.2(S2) PQ605.3(S3) PQ606.1(S1) PQ606.2(S2) PQ606.3(S3) PR8.2 PR19.1 PR105.1 PR110.1 PR115.1 PR132.2 PR201.2 PR208.2 PR301.1 PR302.1 PR307.2 PR313.1 PR413.1 PR418.1 PR419.1 PR420.1 PR421.2 PR425.1 PR436.1 PR440.1 PR441.1 PR442.1 PR443.1 PR444.1 PR445.1 PR446.1 PR447.1 PR448.1 PR619.1 PR626.2 PR627.1 PR628.2 PR629.2 PR637.1 PR638.2 PR640.2 PR642.2 PR643.2 PR703.1 PR705.2 PR802.1 PR805.2 PRT6.2 PRT7.2 PRT402.2 PRT404.2 PU1.2(GND) PU101.22(GND) PU101.29(PAD) PU201.9(GND) PU202.9(GND) PU301.1(VTTGND) PU301.3(GND) PU301.14(PGND) PU301.21(PAD) PU401.49(TAB) PU402.6(GND) PU402.9(FLAG) PU403.6(GND) PU403.9(FLAG) PU404.6(GND) PU404.9(FLAG) PU601.41(TP) PU701.10(PGND1) PU701.11(PGND2) PU701.12(PGND3) PU701.13(PGND4) PU701.14(PGND5) PU701.19(GND1) PU701.23(GSNS) PU701.24(REFIN2) PU701.29(GND2) PU801.11(GND) Q24.1(S1) Q24.4(S2) Q26.3(S) Q28.1(S1) Q28.4(S2) QC3.1(S1) QC3.4(S2) QE1.3(S) QL3.3(S) QV3.3(EMITTER) QV8.1(S1) QV8.4(S2) QV10.1(S1) QV10.4(S2) QV11.3(S) R18.2 R21.1 R26.2 R30.1 R45.1 R61.1 R67.1 R69.2 R83.2 R91.2 R98.1 R105.2 R107.1 R118.2 R120.2 R267.1 R273.1 R9455.1 R9457.1 R9458.1 R9459.1 R9460.1 R9461.1 R9462.1 R9463.1 R9464.1 R9465.1 R9466.1 R9467.1 R9468.1 R9494.2 RA13.2 RC4.2 RC6.2 RC8.2 RC9.2 RC10.2 RC26.2 RC27.1 RC32.1 RC55.1 RC56.1 RC71.2 RC74.2 RC84.1 RC98.2 RC100.2 RC143.2 RC144.1 RC151.1 RC152.2 RC159.2 RC166.1 RC184.2 RC189.2 RC200.1 RC201.1 RC209.2 RC292.1 RC295.2 RC296.2 RC300.2 RC301.2 RC302.2 RC307.2 RC315.1 RC316.1 RC317.1 RC359.2 RC361.2 RC363.2 RC366.1 RC369.2 RC372.2 RC380.2 RC385.2 RC386.2 RC403.1 RC410.2 RD3.2 RD4.2 RD11.2 RD12.2 RD16.2 RD18.2 RD24.2 RE7.1 RE32.2 RL7.2 RL8.2 RL23.2 RM18.2 RM19.1 RM24.2 RM25.2 RM26.2 RM27.2 RM31.2 RM33.2 RPE4.1(R1) RPE4.4(R4) RRE20.2 RRE26.2 RRE27.2 RRE28.2 RRE29.2 RRE30.2 RV2.2 RV6.2 RV8.2 RV11.2 RV12.2 RV13.2 RV14.1 RV15.2 RV16.2 RV17.2 RV19.2 RV25.2 RV28.2 RV29.2 RV31.2 RV37.2 RV40.1 RV44.2 RV53.1 RV67.2 RV74.1 RV75.1 RV77.1 RV79.1 RV81.1 RV82.1 RV83.1 RV84.1 RV88.2 RV93.2 RV94.2 RV99.1 RV101.2 RV103.2 RV105.2 RV106.1 RV122.1 RV124.1 RV126.1 RV137.2 RV152.2 SW1.1 SW1.2 U1.6(GND) U3.2(GND) U4.2(GND) U5.10(GND1) U5.21(GND2) U5.25(GPAD) U6.10(GND1) U6.21(GND2) U6.25(GPAD) U8.1(GND) U11.11(GND) U11.15(GPAD) U14.14(GND) U14.17(GND_PAD) U15.2(GND) U16.10(GND1) U16.21(GND2) U16.25(GPAD) U17.2(GND) U148.B2(GND) U149.6(GND) UA1.41(GND) UC1.A5(VSS_A5) UC1.A67(VSS_A67) UC1.A70(VSS_A70) UC1.AA2(VSS_AA2) UC1.AA4(VSS_AA4) UC1.AA65(VSS_AA65) UC1.AA68(VSS_AA68) UC1.AB8(VSS_AB8) UC1.AB15(VSS_AB15) UC1.AB16(VSS_AB16) UC1.AB18(VSS_AB18) UC1.AB21(VSS_AB21) UC1.AD8(VSS_AD8) UC1.AD13(VSS_AD13) UC1.AD16(VSS_AD16) UC1.AD19(VSS_AD19) UC1.AD20(VSS_AD20) UC1.AD21(VSS_AD21) UC1.AD62(VSS_AD62) UC1.AE64(VSS_AE64) UC1.AE65(VSS_AE65) UC1.AE66(VSS_AE66) UC1.AE67(VSS_AE67) UC1.AE68(VSS_AE68) UC1.AE69(VSS_AE69) UC1.AF1(VSS_AF1) UC1.AF2(VSS_AF2) UC1.AF4(VSS_AF4) UC1.AF10(VSS_AF10) UC1.AF15(VSS_AF15) UC1.AF17(VSS_AF17) UC1.AF63(VSS_AF63) UC1.AG16(VSS_AG16) UC1.AG17(VSS_AG17) UC1.AG18(VSS_AG18) UC1.AG19(VSS_AG19) UC1.AG20(VSS_AG20) UC1.AG21(VSS_AG21) UC1.AG71(VSS_AG71) UC1.AH6(VSS_AH6) UC1.AH13(VSS_AH13) UC1.AH63(VSS_AH63) UC1.AH64(VSS_AH64) UC1.AH67(VSS_AH67) UC1.AJ4(VSS_AJ4) UC1.AJ15(VSS_AJ15) UC1.AJ18(VSS_AJ18) UC1.AJ20(VSS_AJ20) UC1.AK8(VSS_AK8) UC1.AK11(VSS_AK11) UC1.AK16(VSS_AK16) UC1.AK18(VSS_AK18) UC1.AK21(VSS_AK21) UC1.AK22(VSS_AK22) UC1.AK27(VSS_AK27) UC1.AK63(VSS_AK63) UC1.AK68(VSS_AK68) UC1.AK69(VSS_AK69) UC1.AL2(VSS_AL2) UC1.AL4(VSS_AL4) UC1.AL28(VSS_AL28) UC1.AL32(VSS_AL32) UC1.AL35(VSS_AL35) UC1.AL38(VSS_AL38) UC1.AL45(VSS_AL45) UC1.AL48(VSS_AL48) UC1.AL52(VSS_AL52) UC1.AL55(VSS_AL55) UC1.AL58(VSS_AL58) UC1.AL64(VSS_AL64) UC1.AL65(VSS_AL65) UC1.AL66(VSS_AL66) UC1.AM8(VSS_AM8) UC1.AM13(VSS_AM13) UC1.AM21(VSS_AM21) UC1.AM25(VSS_AM25) UC1.AM27(VSS_AM27) UC1.AM43(VSS_AM43) UC1.AM45(VSS_AM45) UC1.AM46(VSS_AM46) UC1.AM55(VSS_AM55) UC1.AM60(VSS_AM60) UC1.AM61(VSS_AM61) UC1.AM68(VSS_AM68) UC1.AM71(VSS_AM71) UC1.AN20(VSS_AN20) UC1.AN23(VSS_AN23) UC1.AN28(VSS_AN28) UC1.AN30(VSS_AN30) UC1.AN32(VSS_AN32) UC1.AN33(VSS_AN33) UC1.AN35(VSS_AN35) UC1.AN37(VSS_AN37) UC1.AN38(VSS_AN38) UC1.AN40(VSS_AN40) UC1.AN42(VSS_AN42) UC1.AN43(DDR1_ALERT#) UC1.AN58(VSS_AN58) UC1.AN63(VSS_AN63) UC1.AP10(VSS_AP10) UC1.AP18(VSS_AP18) UC1.AP20(VSS_AP20) UC1.AP23(VSS_AP23) UC1.AP28(VSS_AP28) UC1.AP32(VSS_AP32) UC1.AP35(VSS_AP35) UC1.AP38(VSS_AP38) UC1.AP42(VSS_AP42) UC1.AP58(VSS_AP58) UC1.AP63(VSS_AP63) UC1.AP68(VSS_AP68) UC1.AP70(VSS_AP70) UC1.AR5(VSS_AR5) UC1.AR8(VSS_AR8) UC1.AR11(VSS_AR11) UC1.AR15(VSS_AR15) UC1.AR16(VSS_AR16) UC1.AR20(VSS_AR20) UC1.AR23(VSS_AR23) UC1.AR28(VSS_AR28) UC1.AR35(VSS_AR35) UC1.AR42(VSS_AR42) UC1.AR43(VSS_AR43) UC1.AR45(VSS_AR45) UC1.AR46(VSS_AR46) UC1.AR48(VSS_AR48) UC1.AR50(VSS_AR50) UC1.AR52(VSS_AR52) UC1.AR53(VSS_AR53) UC1.AR55(VSS_AR55) UC1.AR58(VSS_AR58) UC1.AR63(VSS_AR63) UC1.AT2(VSS_AT2) UC1.AT4(VSS_AT4) UC1.AT20(VSS_AT20) UC1.AT23(VSS_AT23) UC1.AT28(VSS_AT28) UC1.AT35(VSS_AT35) UC1.AT42(VSS_AT42) UC1.AT56(VSS_AT56) UC1.AT58(VSS_AT58) UC1.AT63(VSS_AT63) UC1.AT68(VSS_AT68) UC1.AT71(VSS_AT71) UC1.AU10(VSS_AU10) UC1.AU15(VSS_AU15) UC1.AU20(VSS_AU20) UC1.AU32(VSS_AU32) UC1.AU38(VSS_AU38) UC1.AV1(VSS_AV1) UC1.AV68(VSS_AV68) UC1.AV69(VSS_AV69) UC1.AV70(VSS_AV70) UC1.AV71(VSS_AV71) UC1.AW6(VSS_AW6) UC1.AW8(VSS_AW8) UC1.AW10(VSS_AW10) UC1.AW12(VSS_AW12) UC1.AW14(VSS_AW14) UC1.AW16(VSS_AW16) UC1.AW18(VSS_AW18) UC1.AW21(VSS_AW21) UC1.AW23(VSS_AW23) UC1.AW26(VSS_AW26) UC1.AW28(VSS_AW28) UC1.AW30(VSS_AW30) UC1.AW32(VSS_AW32) UC1.AW34(VSS_AW34) UC1.AW36(VSS_AW36) UC1.AW38(VSS_AW38) UC1.AW41(VSS_AW41) UC1.AW43(VSS_AW43) UC1.AW45(VSS_AW45) UC1.AW47(VSS_AW47) UC1.AW49(VSS_AW49) UC1.AW50(DDR0_ALERT#) UC1.AW51(VSS_AW51) UC1.AW53(VSS_AW53) UC1.AW55(VSS_AW55) UC1.AW57(VSS_AW57) UC1.AW60(VSS_AW60) UC1.AW62(VSS_AW62) UC1.AW64(VSS_AW64) UC1.AW66(VSS_AW66) UC1.AY66(VSS_AY66) UC1.B10(VSS_B10) UC1.B14(VSS_B14) UC1.B18(VSS_B18) UC1.B22(VSS_B22) UC1.B30(VSS_B30) UC1.B34(VSS_B34) UC1.B39(VSS_B39) UC1.B44(VSS_B44) UC1.B48(VSS_B48) UC1.B53(VSS_B53) UC1.B58(VSS_B58) UC1.B62(VSS_B62) UC1.B66(VSS_B66) UC1.B71(VSS_B71) UC1.BA1(VSS_BA1) UC1.BA2(VSS_BA2) UC1.BA6(VSS_BA6) UC1.BA10(VSS_BA10) UC1.BA14(VSS_BA14) UC1.BA18(VSS_BA18) UC1.BA23(VSS_BA23) UC1.BA28(VSS_BA28) UC1.BA32(VSS_BA32) UC1.BA36(VSS_BA36) UC1.BA41(VSS_BA41) UC1.BA45(VSS_BA45) UC1.BA49(VSS_BA49) UC1.BA53(VSS_BA53) UC1.BA57(VSS_BA57) UC1.BA62(VSS_BA62) UC1.BA66(VSS_BA66) UC1.BA71(VSS_BA71) UC1.BB6(VSS_BB6) UC1.BB18(VSS_BB18) UC1.BB26(VSS_BB26) UC1.BB30(VSS_BB30) UC1.BB34(VSS_BB34) UC1.BB38(VSS_BB38) UC1.BB43(VSS_BB43) UC1.BB55(VSS_BB55) UC1.BB60(VSS_BB60) UC1.BB64(VSS_BB64) UC1.BB67(VSS_BB67) UC1.BB70(VSS_BB70) UC1.C1(VSS_C1) UC1.C5(VSS_C5) UC1.C25(VSS_C25) UC1.D6(VSS_D6) UC1.D10(VSS_D10) UC1.D11(VSS_D11) UC1.D14(VSS_D14) UC1.D18(VSS_D18) UC1.D22(VSS_D22) UC1.D25(VSS_D25) UC1.D26(VSS_D26) UC1.D30(VSS_D30) UC1.D34(VSS_D34) UC1.D39(VSS_D39) UC1.D44(VSS_D44) UC1.D45(VSS_D45) UC1.D47(VSS_D47) UC1.D48(VSS_D48) UC1.D53(VSS_D53) UC1.D58(VSS_D58) UC1.D62(VSS_D62) UC1.D66(VSS_D66) UC1.D69(VSS_D69) UC1.E6(VSS_E6) UC1.E11(VSS_E11) UC1.E15(VSS_E15) UC1.E18(VSS_E18) UC1.E21(VSS_E21) UC1.E46(VSS_E46) UC1.E50(VSS_E50) UC1.E53(VSS_E53) UC1.E56(VSS_E56) UC1.E65(VSS_E65) UC1.E71(VSS_E71) UC1.F1(VSS_F1) UC1.F2(VSS_F2) UC1.F4(VSS_F4) UC1.F8(VSS_F8) UC1.F13(VSS_F13) UC1.F22(VSS_F22) UC1.F23(VSS_F23) UC1.F27(VSS_F27) UC1.F28(VSS_F28) UC1.F32(VSS_F32) UC1.F33(VSS_F33) UC1.F35(VSS_F35) UC1.F37(VSS_F37) UC1.F38(VSS_F38) UC1.F40(VSS_F40) UC1.F42(VSS_F42) UC1.F65(VSS_F65) UC1.F68(VSS_F68) UC1.G5(VSS_G5) UC1.G6(VSS_G6) UC1.G10(VSS_G10) UC1.G22(VSS_G22) UC1.G43(VSS_G43) UC1.G45(VSS_G45) UC1.G48(VSS_G48) UC1.G52(VSS_G52) UC1.G55(VSS_G55) UC1.G58(VSS_G58) UC1.G60(VSS_G60) UC1.G63(VSS_G63) UC1.G65(VSS_G65) UC1.G66(VSS_G66) UC1.H15(VSS_H15) UC1.H18(VSS_H18) UC1.H71(VSS_H71) UC1.J8(VSS_J8) UC1.J11(VSS_J11) UC1.J13(VSS_J13) UC1.J25(VSS_J25) UC1.J28(VSS_J28) UC1.J32(VSS_J32) UC1.J35(VSS_J35) UC1.J38(VSS_J38) UC1.J42(VSS_J42) UC1.K16(VSS_K16) UC1.K18(VSS_K18) UC1.K22(VSS_K22) UC1.K61(VSS_K61) UC1.K63(VSS_K63) UC1.K64(VSS_K64) UC1.K65(VSS_K65) UC1.K66(VSS_K66) UC1.K67(VSS_K67) UC1.K68(VSS_K68) UC1.K70(VSS_K70) UC1.K71(VSS_K71) UC1.L2(VSS_L2) UC1.L4(VSS_L4) UC1.L8(VSS_L8) UC1.L11(VSS_L11) UC1.L16(VSS_L16) UC1.L17(VSS_L17) UC1.L18(VSS_L18) UC1.L20(VSS_L20) UC1.N6(VSS_N6) UC1.N10(VSS_N10) UC1.N13(VSS_N13) UC1.N19(VSS_N19) UC1.N21(VSS_N21) UC1.N65(VSS_N65) UC1.N68(VSS_N68) UC1.P17(VSS_P17) UC1.P19(VSS_P19) UC1.P20(VSS_P20) UC1.P21(VSS_P21) UC1.R6(VSS_R6) UC1.R13(VSS_R13) UC1.T2(VSS_T2) UC1.T4(VSS_T4) UC1.T15(VSS_T15) UC1.T17(VSS_T17) UC1.T18(VSS_T18) UC1.T21(VSS_T21) UC1.U10(VSS_U10) UC1.U63(VSS_U63) UC1.U64(VSS_U64) UC1.U66(VSS_U66) UC1.U67(VSS_U67) UC1.U69(VSS_U69) UC1.U70(VSS_U70) UC1.V16(VSS_V16) UC1.V17(VSS_V17) UC1.V18(VSS_V18) UC1.W6(VSS_W6) UC1.W9(VSS_W9) UC1.W13(VSS_W13) UC1.Y17(VSS_Y17) UC1.Y19(VSS_Y19) UC1.Y20(VSS_Y20) UC1.Y21(VSS_Y21) UC3.3(GND) UC4M1.4(GND) UC8M1.4(GND) UE1.1(VSS1) UE1.3(VBAT) UE1.27(VSS2) UE1.49(VSS3) UE1.91(VSS4) UE1.113(VSS5) UE1.122(VSS6) UGSEN1.5(GND_1) UGSEN1.10(RES) UGSEN1.12(GND_2) UGSEN1.13(ADC3) UGSEN1.15(ADC2) UGSEN1.16(ADC1) UL1.6(SVR_EN_N) UL1.49(GND) UM1.18(GND1) UM1.24(GND2) UM1.31(GND3) UM1.49(PAD) URE1.8(I2C_CTL_EN) URE1.15(GND1) URE1.35(GND2) URE1.41(GND_PAD) USROM1.4(GND) USROM1.7(WP) UTPM1.2(NC1) UTPM1.9(GND1) UTPM1.16(GND2) UTPM1.23(GND3) UTPM1.32(GND4) UTPM1.33(EX-PAD) UV3.A3(GND_65) UV3.A30(GND_66) UV3.AA11(GND_61) UV3.AA13(GND_67) UV3.AA16(GND_68) UV3.AA27(GND_1) UV3.AB6(GND_71) UV3.AB10(GND_69) UV3.AB15(GND_70) UV3.AB24(GND_2) UV3.AB32(GND_3) UV3.AC9(GND_72) UV3.AC17(TSVSS) UV3.AC24(GND_4) UV3.AC26(GND_5) UV3.AC27(GND_6) UV3.AD6(GND_73) UV3.AD8(GND_74) UV3.AD25(GND_7) UV3.AD32(GND_8) UV3.AE7(GND_75) UV3.AE14(DP_VSSR) UV3.AE27(GND_9) UV3.AF32(GND_10) UV3.AG12(GND_76) UV3.AG27(GND_11) UV3.AH10(GND_77) UV3.AH28(GND_78) UV3.AH32(GND_12) UV3.B6(GND_88) UV3.B8(GND_89) UV3.B10(GND_79) UV3.B12(GND_80) UV3.B14(GND_81) UV3.B16(GND_82) UV3.B18(GND_83) UV3.B20(GND_84) UV3.B22(GND_85) UV3.B24(GND_86) UV3.B26(GND_87) UV3.C1(GND_90) UV3.C32(GND_91) UV3.E28(GND_92) UV3.F2(GND_98) UV3.F6(GND_103) UV3.F8(GND_104) UV3.F10(GND_93) UV3.F12(GND_94) UV3.F14(GND_95) UV3.F16(GND_96) UV3.F18(GND_97) UV3.F20(GND_99) UV3.F22(GND_100) UV3.F24(GND_101) UV3.F26(GND_102) UV3.G8(GND_108) UV3.G10(GND_105) UV3.G27(GND_106) UV3.G31(GND_107) UV3.H2(GND_111) UV3.H6(GND_113) UV3.H14(GND_109) UV3.H17(GND_110) UV3.H20(GND_112) UV3.J7(SPLL_PVSS) UV3.J27(GND_114) UV3.J31(GND_115) UV3.K2(GND_117) UV3.K6(GND_119) UV3.K11(GND_116) UV3.K22(GND_118) UV3.K28(GND_13) UV3.K32(GND_14) UV3.L27(GND_15) UV3.M6(GND_32) UV3.M12(GND_62) UV3.M32(GND_16) UV3.N11(GND_63) UV3.N13(GND_33) UV3.N16(GND_34) UV3.N18(GND_35) UV3.N21(GND_36) UV3.N25(GND_17) UV3.N27(GND_18) UV3.P6(GND_37) UV3.P9(GND_38) UV3.P25(GND_19) UV3.P32(GND_20) UV3.R11(GND_59) UV3.R12(GND_39) UV3.R15(GND_40) UV3.R17(GND_41) UV3.R20(GND_42) UV3.R27(GND_21) UV3.T6(GND_47) UV3.T11(GND_60) UV3.T13(GND_43) UV3.T16(GND_44) UV3.T18(GND_45) UV3.T21(GND_46) UV3.T25(GND_22) UV3.T32(GND_23) UV3.U9(GND_51) UV3.U15(GND_48) UV3.U17(GND_49) UV3.U20(GND_50) UV3.U25(GND_24) UV3.U27(GND_25) UV3.V11(GND_64) UV3.V13(GND_52) UV3.V16(GND_53) UV3.V18(GND_54) UV3.V32(GND_26) UV3.W25(GND_27) UV3.W26(GND_28) UV3.W27(GND_29) UV3.Y10(GND_55) UV3.Y15(GND_56) UV3.Y17(GND_57) UV3.Y20(GND_58) UV3.Y25(GND_30) UV3.Y32(GND_31) UV4.3(GND) UV5.A9(VSS_1) UV5.B1(VSSQ_1) UV5.B3(VSS_2) UV5.B9(VSSQ_2) UV5.D1(VSSQ_3) UV5.D8(VSSQ_4) UV5.E1(VSS_3) UV5.E2(VSSQ_5) UV5.E8(VSSQ_6) UV5.F9(VSSQ_7) UV5.G1(VSSQ_8) UV5.G8(VSS_4) UV5.G9(VSSQ_9) UV5.J2(VSS_5) UV5.J8(VSS_6) UV5.M1(VSS_7) UV5.M9(VSS_8) UV5.P1(VSS_9) UV5.P9(VSS_10) UV5.T1(VSS_11) UV5.T9(VSS_12) UV6.A9(VSS_1) UV6.B1(VSSQ_1) UV6.B3(VSS_2) UV6.B9(VSSQ_2) UV6.D1(VSSQ_3) UV6.D8(VSSQ_4) UV6.E1(VSS_3) UV6.E2(VSSQ_5) UV6.E8(VSSQ_6) UV6.F9(VSSQ_7) UV6.G1(VSSQ_8) UV6.G8(VSS_4) UV6.G9(VSSQ_9) UV6.J2(VSS_5) UV6.J8(VSS_6) UV6.M1(VSS_7) UV6.M9(VSS_8) UV6.P1(VSS_9) UV6.P9(VSS_10) UV6.T1(VSS_11) UV6.T9(VSS_12) UV7.A9(VSS_1) UV7.B1(VSSQ_1) UV7.B3(VSS_2) UV7.B9(VSSQ_2) UV7.D1(VSSQ_3) UV7.D8(VSSQ_4) UV7.E1(VSS_3) UV7.E2(VSSQ_5) UV7.E8(VSSQ_6) UV7.F9(VSSQ_7) UV7.G1(VSSQ_8) UV7.G8(VSS_4) UV7.G9(VSSQ_9) UV7.J2(VSS_5) UV7.J8(VSS_6) UV7.M1(VSS_7) UV7.M9(VSS_8) UV7.P1(VSS_9) UV7.P9(VSS_10) UV7.T1(VSS_11) UV7.T9(VSS_12) UV8.A9(VSS_1) UV8.B1(VSSQ_1) UV8.B3(VSS_2) UV8.B9(VSSQ_2) UV8.D1(VSSQ_3) UV8.D8(VSSQ_4) UV8.E1(VSS_3) UV8.E2(VSSQ_5) UV8.E8(VSSQ_6) UV8.F9(VSSQ_7) UV8.G1(VSSQ_8) UV8.G8(VSS_4) UV8.G9(VSSQ_9) UV8.J2(VSS_5) UV8.J8(VSS_6) UV8.M1(VSS_7) UV8.M9(VSS_8) UV8.P1(VSS_9) UV8.P9(VSS_10) UV8.T1(VSS_11) UV8.T9(VSS_12) UV9.4(GND) UV11.5(GND) UV11.9(THERMALPAD) UV12.5(GND) UV12.9(THERMALPAD) YC2.2(GND1) YC2.4(GND2) YL1.2(GND1) YL1.4(GND2)
GNDA: CA8.2 CA9.2 CA10.2 CA11.2 CA19.2 JU3AC.18 JU3AC.19
VCC0R9GBE: CL4.1 CL5.1 CL6.2 LL1.2 UL1.8(VDD0P9_8) UL1.11(VDD0P9_11) UL1.16(VDD0P9_16) UL1.22(VDD0P9_22) UL1.37(VDD0P9_37) UL1.40(VDD0P9_40) UL1.43(VDD0P9_43) UL1.46(VDD0P9_46) UL1.47(VDD0P9_47)
VCC0R9GBE_L: LL1.1 UL1.7(CTRL0P9)
VCC_SENSE: PC404.1 PC406.2 PR415.1 RC120.2 RC121.2
VCCGT_SENSE: PC413.2 PU401.47(VSP_2PH) RC124.1 RC125.2
VCCIO_SENSE: RC192.1 UC1.AM23(VCCIO_SENSE)
VCCSA_SENSE: PC423.1 PC425.2 PR434.1 RC185.2 RC370.2
VCCST_PG_EC: DC23.1 UE1.34(PWM7/RIG1#/GPA7)
VCCST_PWRGD: DC23.2 QC3.3(D2) RC123.2 RC383.1 RC387.1
VCCST_PWRGD_R: RC387.2 UC1.B65(VCCST_PWRGD)
VDD_62771: PC604.1 PR601.1 PU601.25(VDD) PU601.31(BOOT_NB)
VDDC_RTN: PR625.1 RV2.1 RV4.1
VDDC_SEN: PR621.2 RV1.1 RV3.1
VDDPALW_PWRGD: PR704.1 PU701.1(PGOOD)
VIN_1.00VS: PC706.1 PC707.1 PC708.1 PC709.1 PC710.1 PC714.1 PJ701.1 PU701.15(VIN1) PU701.16(VIN2) PU701.17(VIN3)
VIN_+1.8VSP: PC801.1 PC802.1 PJ801.1 PU801.8(SVIN1) PU801.9(PVIN1) PU801.10(PVIN2)
VSS_SENSE: PC406.1 PC407.1 PR416.1 RC142.2 RC143.1
VSSGT_SENSE: PC413.1 PC415.1 PR424.1 RC183.1 RC184.1
VSSIO_SENSE: RC189.1 UC1.AM22(VSSIO_SENSE)
VSSSA_SENSE: PC425.1 PC426.1 PR437.1 RC126.2 RC369.1
18PWRON_R: CV179.1 DV6.2 RV153.2 UV12.3(ON)
+DCPDSW: CC60.1 UC1.AL1(DCPDSW_1P0)
+DCPRTC: C197.1 UC1.BB10(DCPRTC)
+FBA_VREFC0_U: CV100.1 RV18.2 RV19.1 UV5.H1(VREFDQ) UV5.M8(VREFCA)
+FBA_VREFC1_U: CV127.1 RV30.2 RV31.1 UV7.H1(VREFDQ) UV7.M8(VREFCA)
+FBA_VREFD0_L: CV103.1 RV24.2 RV25.1 UV6.H1(VREFDQ) UV6.M8(VREFCA)
+FBA_VREFD1_L: CV130.1 RV36.2 RV37.1 UV8.H1(VREFDQ) UV8.M8(VREFCA)
+LCDVDD_CON: C9.1 C178.1 C179.1 C207.1 JLCD.7 JLCD.8 U3.1(OUT)
+LEDVDD: C12.1 C174.1 C175.1 C206.1 JLCD.1 JLCD.2 JLCD.3 R24.2
+MICBIASB: DA3.2 DA4.2 UA1.34(MICBIASB)
+PCH_CORE: CC96.1 CC536.2 RC304.2 UC1.AF18(VCCPRIM_CORE_AF18) UC1.AF19(VCCPRIM_CORE_AF19) UC1.V20(VCCPRIM_CORE_V20) UC1.V21(VCCPRIM_CORE_V21)
+RTCBATT: D6.1 PD6.1 RC11.1
+RTCVCC: C8542.1 CC2.1 CC59.1 RC11.2 RC12.1 RC14.1 RC16.1 UC1.AK19(VCCRTC_AK19) UC1.BB14(VCCRTC_BB14)
+USB_VCCA: C118.1 C123.1 C127.1 C128.1 C129.1 D8.5(VBUS) D9.5(VBUS) JUSB1.1(VBUS) JUSB2.1(VBUS) U15.1(OUT)
+V_DDR_REFA: CD1.1 CD3.1 JDIMM1.1(VREF_DQ) RD1.2 RD2.2 RD3.1
+V_DDR_REFB: CD32.1 CD33.1 JDIMM2.1(VREF_DQ) RD15.2 RD16.1 RD17.2
+VCOREVCC: CE7.2 UE1.12(VCORE)
+VGA_B+: PC602.1 PC603.1 PC606.1 PC607.1 PC611.1 PC623.1 PC624.1 PC625.1 PC626.1 PC627.1 PL601.1 PL602.1 PQ601.5(D) PQ604.5(D)
+VGA_CORE: CV37.1 CV38.1 CV39.1 CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV46.1 CV47.1 CV48.1 CV49.1 CV50.1 CV51.1 CV52.1 CV53.1 CV54.1 CV55.1 CV56.1 CV57.1 CV58.1 CV59.1 CV60.1 CV61.1 CV62.1 CV63.1 CV64.1 CV65.1 PC613.1(P) PC614.1(P) PC615.1 PC629.1(P) PC630.1(P) PC631.1 PL603.2 PL604.2 PR618.2 PR622.1 PR636.2 RV1.2 UV3.AA12(VDDC_22) UV3.AA15(VDDC_1) UV3.AB11(VDDC_34) UV3.AB12(VDDC_33) UV3.AB13(VDDC_26) UV3.AC11(VDDC_35) UV3.AC13(VDDC_36) UV3.AC14(VDDC_32) UV3.M11(VDDC_23) UV3.M13(VDDCI_1) UV3.M15(VDDCI_2) UV3.M16(VDDCI_3) UV3.M17(VDDCI_4) UV3.M18(VDDCI_5) UV3.M20(VDDCI_6) UV3.M21(VDDCI_7) UV3.N12(VDDC_24) UV3.N15(VDDC_2) UV3.N17(VDDC_3) UV3.N20(VDDCI_8) UV3.R13(VDDC_4) UV3.R16(VDDC_5) UV3.R18(VDDC_6) UV3.T10(VDDC_31) UV3.T12(VDDC_8) UV3.T15(VDDC_9) UV3.T17(VDDC_10) UV3.T20(VDDC_11) UV3.U10(VDDC_27) UV3.U11(VDDC_25) UV3.U13(VDDC_12) UV3.U16(VDDC_13) UV3.U18(VDDC_14) UV3.V15(VDDC_16) UV3.V17(VDDC_17) UV3.V20(VDDC_18) UV3.V21(VDDC_15) UV3.W9(VDDC_28) UV3.W10(VDDC_30) UV3.Y9(VDDC_29) UV3.Y13(VDDC_19) UV3.Y16(VDDC_20) UV3.Y18(VDDC_21) UV3.Y21(VDDC_7)
+VREF_CA: CD17.1 CD18.1 CD49.1 JDIMM1.126(VREF_CA) JDIMM2.126(VREF_CA) RD9.2 RD10.1 RD11.1
A_DE0: R49.1 R9468.2 U6.16(A_DE0_SCL_CTL)
A_DE1: R52.1 U6.18(A_DE1_NC)
A_EQ0: R50.1 R9467.2 U6.17(A_EQ0_NC)
A_EQ1: R53.1 U6.15(A_EQ1_SDA_CTL)
AA_DE0: R35.1 R9462.2 U5.16(A_DE0_SCL_CTL)
AA_DE1: R37.1 U5.18(A_DE1_NC)
AA_EQ0: R36.1 R9461.2 U5.17(A_EQ0_NC)
AA_EQ1: R39.1 U5.15(A_EQ1_SDA_CTL)
AAA_DE0: R249.1 R9458.2 U16.16(A_DE0_SCL_CTL)
AAA_DE1: R250.1 U16.18(A_DE1_NC)
AAA_EQ0: R245.1 R9457.2 U16.17(A_EQ0_NC)
AAA_EQ1: R246.1 U16.15(A_EQ1_SDA_CTL)
AC_PRESENT: RPC18.8(R8) UC1.AY15(GPD1/ACPRESENT) UE1.128(CK32K/GPJ6)
ACIN: CE12.1 DEV1.2 RE33.1 RE34.1 UE1.108(AC_IN#)
ACN: PC109.1 PR106.2 PR108.1 PU101.1(ACN)
ACOFF: PR109.1 UE1.98(GPH5/ID5)
ACP: PR107.2 PU101.2(ACP)
ACPRN: DEV1.1 PR118.1 RE34.2
ADAPTER_ID_ON: PQ4.2(G1) PQ4.3(D2) PR5.2 PR8.1
ADAPTER_ID_ON#: PQ4.5(G2) UE1.118(SMDAT2/PECIRQT#/GPF7)
ADDR_SEL: RC292.2 RC347.1 UGSEN1.7(SDO/SA0)
ADP_I: PC125.2 PR122.1 UE1.71(ADC5/DCD1#/GPI5)
ADP_ID: PD4.2 PD5.1 PR7.2 UE1.73(ADC7/CTS1#/GPI7)
ALL_PWRGD: RE41.2 UE1.29(PWM3/GPA3)
AOU_CTL1: U14.6(CLT1) UE1.84(EGCLK/GPE3)
AOU_CTL3: U14.8(CLT3) UE1.48(TACH1A/TMA1/GPD7)
AOU_EN: U14.5(EN) UE1.85(PS2CLK0/TMB0/CEC/GPF0)
AOU_IFG#: RPE1.7(R7) U14.9(STATUS#) UE1.25(PWM1/GPA1)
APDIN: JLINK.26(POWER1) JLINK.28(POWER2) PF1.2
B+: PC105.1 PC106.1 PC110.2 PC111.1 PC112.1 PC113.1 PC114.1 PC525.1(P) PC526.1(P) PC527.1(P) PC528.1(P) PD3.2 PD103.2 PJ201.2 PJ203.2 PJ304.2 PJ701.2 PL401.2 PL402.2 PL404.2 PL405.2 PL407.2 PL601.2 PL602.2 PQ104.5(D) PQ106.5(D) PR101.2 PR106.1 PR401.1 R24.1
B+_1.35V: PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PJ304.1 PQ301.5(D) PR309.1
B_DE0: R54.1 R9466.2 U6.3(B_DE0_I2C_ADDR0)
B_DE1: R56.1 U6.6(B_DE1_NC)
