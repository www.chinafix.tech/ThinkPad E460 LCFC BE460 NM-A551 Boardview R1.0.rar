# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N63300161:
  vias: v4(196.33,167.43)
N63300165:
  vias: v4(198.05,167.23)
N64422010: length 8.1
  TOP w0.114: RG4.2 CG4.1 173.89,113.33 173.88,113.34 173.51,113.34 CG1.2 173.41,112.43 QG1.2 175.3,111.63 CG2.2 176.83,111.02 176.83,110.23 v4(176.85,110.21)
N64422483: length 5.1
  TOP w0.203: UGSEN1.8 179.64,108.56 179.43,108.76 177.69,108.76 v4(177.39,108.45) 176.79,107.86 176.79,107.4 RC350.1
N64484679: length 5.5
  TOP w0.508: v4(265.8,129.42) 267.65,131.27 Q27.2 268.23,129.88 C75.1 R9451.2
N64485478: length 8.5
  BOTTOM w0.114: v4(249.42,94.15) 249.13,93.86 QL2.2 246.89,93.86 245.4,95.36 CL17.1 RL24.2
N64611066: length 4
  TOP w0.114: UTPM1.27 129.38,162.38 R267.2 130.65,163.53 v4(132.09,164.96)
N64646019: length 2.9
  TOP w0.254: v4(176.89,145.92) R159.2 178.06,144.18 Q28.3
N64756017: length 1.9
  BOTTOM w0.254: UV11.6 60,174.15 59.56,173.71 59.56,172.92 CV165.1
N64756162: length 2.4
  TOP w0.254: UV12.6 62.61,174.15 v4(63.1,173.67) 63.1,173.18 CV178.1
N65172917: length 7
  TOP w0.114: v4(273.32,116.63) 272.1,117.85 R9455.2 271.24,118.64 269.92,118.64 268.3,120.26 U16.7
N65173045: length 6.4
  TOP w0.114: TP941.1 270.12,117.39 269.59,117.93 269.59,118.25 268.62,119.22 267.38,119.22 267.06,119.53 U16.5
N65755761: length 3.7
  BOTTOM w0.254: PQ201.2 221.1,163.11 220.92,162.93 220.92,162.58 221.13,162.36 PQ201.3 222.31,162.36 v4(222.4,162.45) 222.6,162.66 PR216.2
N65782228: length 4.3
  TOP w0.114: TP69.1 266.67,140.01 266.21,140.47 266.21,141.43 265.33,142.31 UM1.26
N65787567: length 1.7
  TOP w0.114: CM11.1 256.69,146.9 256.78,146.81 UM1.2
N65865635: length 2.4
  TOP w0.114: v2(116.71,129.38) 116.71,129.39 117.16,129.84 117.59,129.84 TC118.1
  BOTTOM w0.076: UC1.AP13 116.35,129.74 v2(116.71,129.38)
N66358052: length 6.7
  BOTTOM w0.076: 96.16,102.28 96.92,102.28 97.45,101.75 98.93,101.75 99.02,101.71 99.18,101.71 99.33,101.75 99.55,101.75 99.85,101.65 100.24,101.65 100.56,101.33 UC1.D63
  BOTTOM w0.114: 96.16,102.28 T60.1
N66397047: length 4.4
  BOTTOM w0.076: UC1.AD1 111.58,137.25 111.53,137.3 111.53,137.55 111.48,137.6 111.48,138.9 111.19,139.19 111.19,140.25
  BOTTOM w0.114: 111.19,140.25 111.19,140.58 TC119.1
N66397050: length 3.6
  BOTTOM w0.076: UC1.AD2 111.58,136.56 111.72,136.71 111.85,136.96 111.85,137.22 111.7,137.37 111.7,137.66 111.66,137.7 111.66,138.38 111.75,138.47
  BOTTOM w0.114: 111.75,138.47 111.75,139.52 TC120.1
N66563319:
  vias: v4(147.29,163.32)
N66641811: length 11.2
  TOP w0.114: R273.2 117.29,158.87 Q29.1 121.4,159.3 v4(122.01,159.91) 122.65,160.55 123.18,160.55 R268.1 123.41,160.78 125.6,160.78 125.83,160.54 UTPM1.3
N66644838: length 2.7
  TOP w0.114: QC3.5 84.26,98.56 84.14,98.45 84.14,98.05 84.28,97.91 QC3.6 84.65,96.77 RC382.2
N67109924:
  vias: v3(219.91,169.54)
N67222149: length 3.4
  TOP w0.114: RC385.1 114.7,134.16 114.22,134.16 v2(113.66,134.72)
  BOTTOM w0.114: v2(113.66,134.72) 113.66,134.87 112.91,135.62 UC1.AG3
N67222152: length 9.2
  TOP w0.114: v2(112.57,134.72) 112.57,134.84 111.68,135.73 111.68,140.61 112.36,141.3 112.36,142.23 112.41,142.28 RC386.1
  BOTTOM w0.114: v2(112.57,134.72) 112.57,134.77 UC1.AG4
N67239370: length 2.4
  TOP w0.114: U148.B1 76.3,120.78 R9494.1 75.56,120.04 R9492.2
N67267230: length 10.3
  TOP w0.114: v2(109.58,139.25) 109.73,139.25 111.93,141.45 111.93,144.47 RC389.1
  BOTTOM w0.076: UC1.AB3 110.25,135.97 109.99,136.23 109.99,136.52 109.82,136.93 109.82,137.32 109.95,137.45 109.95,138.65 109.58,139.02 v2(109.58,139.25)
N67782265: length 1.2
  TOP w0.114: v2(110.43,133.96) 110.59,134.12 RC363.1
  BOTTOM w0.114: v2(110.43,133.96) 110.15,133.69 UC1.AB7
N67912715: length 3.8
  TOP w0.254: RC361.1 115.51,135.98 v2(117.09,137.56)
  BOTTOM w0.203: UC1.AT1 117.55,137.11 v2(117.09,137.56)
N67976050: length 4.6
  TOP w0.114: D23.2 78.14,112.47 v4(77.35,113.27) 76.55,114.07 R722.1 76.87,115 U149.2
N67979431: length 3.2
  TOP w0.114: v4(79.11,118.28) 78.85,118.02 C747.2 76.87,117.49 U149.5
N68137601: length 20.4
  BOTTOM w0.076: 121.4,137.82 121.4,137.05 121.16,136.81 121.13,136.77 121.1,136.66 121.1,136.3 120.88,136.08 120.43,136.08 UC1.AY3
  BOTTOM w0.114: 121.4,137.82 121.4,137.95 122.02,138.57 122.02,143.18 122.18,143.34 122.18,146.79 119.05,149.91 117.38,149.91 v4(117.11,150.19) 116.62,150.68 RC296.1
N68137603: length 11.2
  TOP w0.114: v1(125.71,89.77) 125.84,89.9 RC295.1
  BOTTOM w0.076: 121.39,94.96 120.3,96.04 UC1.AY71
  BOTTOM w0.114: 121.39,94.96 121.61,94.96 124.13,92.45 124.13,91.34 125.7,89.77 v1(125.71,89.77) 125.37,89.43 v4(125.37,88.92)
N68137613: length 9.4
  TOP w0.114: v1(94.01,99.8) 92.47,101.34 RC358.2
  BOTTOM w0.076: UC1.C64 99.58,100.76 99.49,100.67 97.72,100.67 97.16,100.11
  BOTTOM w0.114: 97.16,100.11 96.85,99.8 v4(96.39,99.8) 94.02,99.8 v1(94.01,99.8)
N68137683: length 10.5
  BOTTOM w0.114: TP927.1 90.15,93.88 90.74,94.47 92.1,94.47 94.11,96.48 97.49,96.48 98.45,97.44 98.68,97.44 UC1.A69
N68137699: length 12.8
  BOTTOM w0.076: 98.48,97.67 98.66,97.85 99.13,97.85 99.13,97.85 99.28,97.85 UC1.B69
  BOTTOM w0.114: 98.48,97.67 98.29,97.67 97.35,96.72 94.01,96.72 92,94.72 90.47,94.72 90.22,94.46 88.96,94.46 TP928.1
N68137715: length 11.3
  TOP w0.114: TP929.1 91.99,92.5 94.52,95.03 95.97,95.03 v2(96.35,95.41)
  BOTTOM w0.101: UC1.D71 100.38,96.27 100.38,95.94 99.22,94.77 96.98,94.77 v2(96.35,95.41)
N68137731: length 14
  TOP w0.114: TP930.1 90.16,91.82 91.73,91.82 94.56,94.65 96.22,94.65 v2(96.98,95.41)
  BOTTOM w0.076: UC1.C70 100.07,96.7 100.2,96.56 100.2,96.19 99.42,95.41
  BOTTOM w0.114: 99.42,95.41 99.02,95.01 97.38,95.01 v2(96.98,95.41)
N68137747: length 16
  TOP w0.114: TP931.1 85.06,106.8 95.54,106.8 v2(95.66,106.92)
  BOTTOM w0.076: v2(95.66,106.92) 96.2,106.38 98.46,106.38 98.63,106.55 98.9,106.55 99.01,106.49 99.16,106.49 99.35,106.55 99.53,106.55 99.78,106.47 UC1.C54
N68137763: length 16.4
  TOP w0.114: TP932.1 86.63,106.52 88.61,106.52 88.77,106.37 95.72,106.37 v2(96.27,106.92)
  BOTTOM w0.076: UC1.D54 100.41,106.5 100.15,106.58 100.03,106.58 99.55,106.72 99.3,106.72 99.21,106.68 99.02,106.68 98.92,106.72 98.56,106.72 98.38,106.54 96.75,106.54 96.36,106.92 v2(96.27,106.92)
N68137779: length 26.7
  BOTTOM w0.076: UC1.AY4 120.5,135.38 121.07,135.38 121.33,135.65 121.54,135.65 122.26,136.37 122.26,136.79
  BOTTOM w0.114: 122.26,136.79 122.26,137.23 122.98,137.94 122.98,142.78 123.14,142.94 123.14,147.19 119.6,150.73 119.6,152.32 117.71,154.21 115.58,154.21 TP933.1
N68137795: length 20.9
  BOTTOM w0.076: 122.07,137.02 122.07,136.57 121.45,135.95 UC1.BB3
  BOTTOM w0.114: TP934.1 118.05,153.49 119.36,152.18 119.36,150.63 122.9,147.09 122.9,143.04 122.74,142.88 122.74,138.04 122.07,137.37 122.07,137.02
N68137811: length 12.6
  TOP w0.114: v2(117.36,104.69) 117.74,105.06 119.87,105.06 121.27,103.66 121.27,103.16 121.94,102.48 122.66,102.48 125.08,100.07 125.08,100 125.37,99.7 126.21,99.7 TP935.1
  BOTTOM w0.076: UC1.AR56 v2(117.36,104.69)
N68137827: length 13
  TOP w0.114: v1(124.42,89.8) 124.42,91.7 125.57,92.86 TP936.1
  BOTTOM w0.076: UC1.AW71 119.65,96.16 122.23,93.58
  BOTTOM w0.114: 122.23,93.58 122.23,92.82 v4(122.42,92.63) 122.42,90.85 123.48,89.8 v1(124.42,89.8)
N68137843: length 13.6
  TOP w0.114: v1(125.05,89.8) 126.15,88.69 128.04,88.69 TP937.1
  BOTTOM w0.076: UC1.AW70 120,96.93 120,96.86 120,96.86 120,96.09 121.54,94.56
  BOTTOM w0.114: 121.54,94.56 121.58,94.56 123.31,92.82 v4(123.31,91.11) 123.78,90.64 124.21,90.64 v1(125.05,89.8)
N68139906: length 9.1
  TOP w0.114: v2(116.73,104.69) 117.24,104.17 118.47,104.17 120.38,102.27 120.38,101.76 122.3,99.84 TP938.1
  BOTTOM w0.076: UC1.AP56 v2(116.73,104.69)
N68275593:
  vias: v4(144.01,160.42)
N68447222: length 0.9
  TOP w0.114: RC47.2 131.41,133.73 T18.1
N68576329: length 4.1
  TOP w0.114: UC3.4 73.64,119.74 74.03,119.35 74.44,119.35 74.91,118.88 RC348.1 RC48.1 72.95,118.73 v4(72.76,118.54)

## Copper pours and planes (outline as drawn)
1.8VSP_LX on BOTTOM (solid shape): 188.23,173.12 188.23,171.8 188.52,171.51 190.41,171.51 191.32,170.6 191.32,168.36 191.13,168.17 186.89,168.17 186.66,168.4 186.66,170.84 186.66,170.84 186.66,171.11 186.23,171.55 186.23,173.02 186.39,173.18 188.16,173.18
+0.95VS_VGA on TOP: 51.81,147.35 55.92,147.35 55.92,147.32 56.63,146.6 58.15,146.6 58.27,146.48 58.27,134.78 53.32,129.83 50.4,129.83 49.38,130.84 48.22,130.84 47.61,131.45 47.61,133.83 50.15,136.37 50.15,146.73 50.27,146.86 51.55,146.86 51.68,146.99 51.68,147.23
+0.95VS_VGA on BOTTOM: 50.88,126.19 50.81,126.27 50.81,127.97 50.53,128.25 50.53,128.78 50.6,128.86 53.24,128.86 53.41,128.7 53.41,126.63 52.96,126.19
+0.95VS_VGA on IN1: 60.54,153.83 61.46,153.83 61.9,153.39 61.9,152.64 60.11,150.85 58.72,150.85 58.16,150.29 58.16,148.89 58.67,148.38 58.67,143.94 57.71,142.98 51.44,142.98 50.43,144 50.43,146.21 52.38,146.21 52.84,146.67 52.84,147.25 53.04,147.45 53.75,147.45 53.78,147.43 54.22,147.43 55.11,148.32 55.11,152.07 55.49,152.45 55.87,152.45 55.87,152.44 56,152.44 56.04,152.48 59.18,152.48 59.78,153.08 60.33,153.08 60.33,153.63
+0.95VS_VGA on VCC: 54.53,107.01 48.09,115.76 39.36,122.24 42.39,125.27 44.7,125.27 52.19,132.76 52.19,137.31 50.79,138.83 50.79,140.11 50.03,140.87 50.03,144.78 51.61,146.35 52.29,146.35 52.82,146.88 52.82,147.26 52.93,147.37 53.56,147.37 53.69,147.49 56.01,147.48 56.12,147.37 56.12,146.74 56.63,146.22 58.26,146.22 58.39,146.35 58.82,146.35 58.94,146.22 60.21,146.22 60.97,145.46 65.51,145.46 65.51,140.39 66.28,139.62 66.29,139.36 66.29,135.91 64.64,134.26 64.62,124.51 65.01,124.13 65.01,123.33 64.12,122.44 64.12,118.16 64.88,117.4 64.88,117.37
+0.675VS on TOP: 149.46,153.96 149.21,154.21 149.21,155.86 149.46,156.12 154.42,156.12 154.88,155.66 154.88,154.41 154.42,153.96
+0.675VS on TOP: 174.8,143.45 174.47,143.78 174.47,151.66 172.55,153.58 168.38,153.58 168,153.96 164.08,153.96 163.82,154.21 163.82,155.86 164.08,156.12 172.57,156.12 172.59,156.1 172.99,156.1 175.69,158.81 175.69,164.27 176.9,165.48 177.18,165.48 177.18,164.93 177.16,164.92 177.67,164.92 177.7,164.95 177.7,165.49 178.25,165.49 178.4,165.33 178.4,164.03 178.4,164.02 178.4,156.71 176,154.31 176,143.8 175.65,143.45
+0.675VS on BOTTOM: 149.33,153.19 156.7,153.19 156.98,153.47 162.14,153.47 162.44,153.17 170.34,153.17 170.67,153.5 171.03,153.5 171.05,153.47 173.69,153.47 173.92,153.7 173.92,156.29 173.59,156.62 153.79,156.62 152.91,155.75 149.98,155.75 149.97,155.75 149.21,155.75 149.08,155.62 149.08,153.45
+0.675VSP on TOP (solid shape): 179.56,169.5 179.56,169.35 179.41,169.2 179.41,168.35 179.2,168.13 179.2,167.79 179.44,167.55 179.78,167.55 179.95,167.38 179.95,166.39 179.66,166.1 178.57,166.1 178.4,165.92 178.4,165.76 178.28,165.64 176.73,165.64 175.98,164.89 175.61,164.89 175.48,165.02 175.48,165.53 176.34,166.39 176.87,166.39 177.1,166.62 177.1,167.19 177.21,167.3 178.04,167.3 178.22,167.49 178.22,168.47 178.58,168.83 178.58,169.44 178.72,169.58 179.48,169.58
+1.8VALW on TOP (solid shape): 186.22,164.29 186.22,163.31 186.07,163.16 185.03,163.16 184.7,163.48 184.7,164.04 185.16,164.5 186.01,164.5
+1.8VALW on BOTTOM (solid shape): 186.82,164.28 186.84,164.26 186.84,164.08 186.31,164.08 186.27,164.04 186.27,163.54 186.28,163.53 186.83,163.53 186.84,163.53 186.84,163.02 186.67,162.85 184.95,162.85 184.86,162.95 184.86,164.71 184.98,164.83 186.27,164.83
+1.8VALW on TOP: 60.51,175.24 60.51,174.56 60.46,174.5 59.77,174.5 59.6,174.68 58.73,174.68 58.63,174.78 58.63,176.18 58.64,176.19 58.64,176.42 58.78,176.56 60.71,176.56 60.95,176.32 60.95,175.69
+1.8VALW on IN1: 183.25,162.73 180.84,165.15 167.76,165.15 157.6,175.31 90.29,175.31 87.75,172.77 71.87,172.77 69.08,175.56 58.84,175.56 58.59,175.81 58.59,176.32 58.82,176.55 61.56,176.55 61.59,176.58 69.72,176.58 72.13,174.16 87.24,174.16 89.53,176.45 158.49,176.45 166.87,168.07 173.09,168.07 174.87,169.85 178.66,169.85 179.7,168.8 180.49,168.8 184.65,164.64 185.79,164.64 186.17,164.26 186.17,162.99 185.92,162.73
+1.8VS_VGA on TOP: 63.48,170.62 63.35,170.75 63.35,173.53 62.98,173.9 62.98,174.05 62.95,174.05 62.54,174.45 61.96,174.45 61.86,174.56 61.86,176.23 62.06,176.44 65.82,176.44 65.95,176.31 65.95,174.2 65.91,174.16 65.91,174.04 65.62,173.75 65.62,172.65 65.21,172.24 65.21,170.82 65.01,170.62
+1.8VS_VGA on TOP: 61.11,147.6 61.26,147.45 61.26,144.1 61.21,144.05 60.47,144.05 60.35,144.17 60.35,145.77 60.02,146.1 59.38,146.1 58.44,147.04 58.44,149.07 59.37,149.99 60.83,149.99 61.84,151.01 61.84,154.22 61.97,154.35 62.6,154.35 63.62,153.34 63.62,150.67 63.11,150.16 62.6,150.16 61.84,149.4 61.73,149.4 61.73,148.6 61.11,147.98
+1.8VS_VGA on BOTTOM: 70.68,155.11 73.27,155.11 73.65,154.73 73.65,154.48 73.91,154.22 75.43,154.22 75.81,153.84 75.81,153.08 75.18,152.45 73.14,152.45 72.26,151.56 72.26,150.41 72.13,150.29 70.1,150.29 69.84,150.54 69.84,152.19 70.1,152.45 70.73,152.45 70.73,154.1 70.5,154.33 70.5,154.94
+1.8VS_VGA on IN1: 64.38,154.48 62.73,152.83 62.22,152.83 62.1,152.95 62.1,158.21 62.45,158.57 64.18,158.57 64.38,158.36
+1.8VS_VGA on IN2: 63.49,171.24 64.89,171.24 65.65,170.48 65.65,169.85 64.64,168.83 64.64,166.16 65.02,165.78 65.02,159.18 69.46,154.73 71.8,154.73 72.03,154.5 72.03,153.51 71.85,153.34 68.83,153.34 66.54,155.62 64.38,155.62 63.11,156.89 63.11,170.86
+1.8VSP on BOTTOM (solid shape): 193.94,174.47 193.94,174.09 193.73,173.88 193.59,173.88 193.31,173.6 193.31,173.1 193.29,173.07 192.8,173.07 192.74,173.14 192.74,174.49 192.82,174.57 193.83,174.57
+1.8VSP on BOTTOM (solid shape): 191.88,166.95 191.88,165.12 192.25,164.75 192.25,163.53 191.92,163.2 187.11,163.2 187,163.3 187,164.24 187.02,164.25 187.02,164.45 186.69,164.78 186.69,167.21 187.08,167.6 191.23,167.6
+1.35V on TOP (solid shape): 70.22,176.07 70.22,173.78 69.72,173.27 66.79,173.27 66.41,173.66 66.41,176.2 66.67,176.45 69.84,176.45
+1.35V on IN3 (solid shape): 155.44,167.05 155.44,163.62 154.79,162.97 151.4,162.97 151.25,163.13 151.25,165.4 152.76,166.91 152.77,166.91 153.17,167.31 155.19,167.31
+1.35V on TOP: 115.32,109.43 115.59,109.16 115.59,107.23 114.9,106.55 114.9,101.72 114.8,101.62 113.3,101.62 113.18,101.75 113.18,102.51 113.25,102.59 113.66,102.59 113.73,102.66 113.73,103.73 113.58,103.88 112.72,103.88 112.51,104.08 112.51,105.96 112.62,106.07 113.43,106.07 113.58,106.22 113.58,107.74 113.61,107.77 113.61,109.49 114.11,110 114.11,110.99 114.27,111.15 115.21,111.15 115.32,111.03
+1.35V on TOP: 125.29,114.08 122.79,114.08 122.41,114.46 122.41,117.51 120.12,119.79 119.23,119.79 118.98,120.05 117.84,120.05 117.71,120.17 117.71,120.43 117.96,120.68 117.96,121.19 117.71,121.44 114.92,121.44 114.15,122.21 114.15,123.55 114.15,123.55 114.15,124.43 114.36,124.63 114.9,124.63 115.17,124.37 115.64,123.9 115.64,123.87 118.65,123.87 119.3,123.22 119.63,123.22 121.22,124.81 122.42,124.81 122.6,124.63 122.6,121.64 125.79,118.45 125.79,114.57
+1.35V on TOP: 155.68,100.11 153.4,102.39 150.73,102.39 150.1,103.03 150.1,113.45 151.38,114.73 151.38,131.24 152.14,132 152.14,148.76 155.19,151.81 155.19,155.11 151.88,158.42 149.98,158.42 148.96,159.43 148.96,164 151.5,166.54 151.71,166.54 152.72,167.56 154.93,167.56 155.19,167.31 155.19,163.4 155.71,163.4 156.12,162.99 160.39,162.99 163.31,160.07 163.31,151.81 172.45,142.68 172.45,133.76 172.83,133.38 172.83,132.11 171.56,130.84 171.56,115.35 170.42,114.21 162.68,114.21 158.73,110.26 158.73,100.49 158.35,100.11 ; 1 cut-out
+1.35V on BOTTOM: 151.16,163.37 151.16,165.16 151.61,165.6 151.83,165.6 152.6,166.37 152.6,166.64 152.88,166.92 152.9,166.92 153.59,167.61 154.55,167.61 154.73,167.43 155.44,167.43 155.69,167.18 155.69,162.99 155.31,162.61 151.93,162.61
+1.35V on BOTTOM: 248.9,91.73 249.54,91.73 249.66,91.85 249.66,92.88 249.54,93.01 247.01,93.01 246.88,92.88 246.88,91.74 247.01,91.61 248.79,91.61
+1.35V on BOTTOM: 61.97,176.58 70.48,176.58 70.73,176.32 70.73,173.27 70.1,172.64 66.16,172.64 65.52,173.27 63.37,173.27 63.24,173.4 63.24,173.78 62.6,174.42 61.97,174.42 61.84,174.54 61.84,176.45
+1.35V on IN1: 68.83,175.31 72.64,171.5 86.99,171.5 90.42,174.93 152.65,174.93 156.08,171.5 156.08,164.64 155.44,164 151.63,164 150.68,164.96 128.83,164.96 126.48,167.31 112.9,167.31 102.74,157.15 78.35,157.15 66.16,169.34 66.16,172.77 65.52,173.4 62.1,173.4 61.84,173.66 61.84,175.05 62.1,175.31 ; 3 cut-outs
+1.35V on IN1: 121.15,124.76 122.67,124.76 122.93,124.51 122.93,116.51 122.42,116 121.53,116 117.98,112.44 117.85,112.44 117.47,112.06 117.47,104.39 117.19,104.11 113.02,104.11 112.82,104.31 112.82,109.44 115.94,112.57 115.94,113.97 115.56,114.35 115.31,114.35 115.18,114.47 115.18,114.73 117.59,117.14 117.59,121.2
+1.35V on IN2: 122.93,124.68 122.93,123.01 121.68,121.76 121.68,120.29 122.29,119.68 122.29,119.02 122.01,118.74 122.01,116.73 117.39,112.11 117.39,104.59 117.04,104.24 113.25,104.24 113.1,104.39 113.1,109.06 113.66,109.62 113.66,120.01 114.06,120.42 114.06,124.13 114.04,124.15 114.04,124.96 114.6,125.52 122.09,125.52
+1.35V on IN2: 219.7,84.76 213.86,90.6 194.81,90.6 184.97,100.44 184.9,100.44 183.44,101.9 172.84,101.9 172.46,102.28 172.46,105.46 173.09,106.09 183.89,106.09 197.48,92.5 215.77,92.5 217.42,90.85 222.12,90.85 223.89,89.07 240.91,89.07 241.29,89.45 245.74,89.45 245.99,89.71 245.99,92.38 246.25,92.63 249.42,92.63 250.06,91.99 250.06,87.04 247.77,84.76
+1.35V on IN2: outline of 246 points within 61.84,154.99 155.57,176.58 ; 4 cut-outs
+1.35V on VCC: 130.91,100.45 130.45,100.91 130.32,100.91 130.32,101.04 129.86,101.49 124.33,101.49 123.01,102.81 122.02,102.81 120.8,104.03 119.25,104.03 118.92,104.36 113.93,104.36 113.93,104.41 113.92,104.42 113.92,104.43 113.86,104.5 113.8,104.57 113.78,104.59 113.77,104.59 113.27,105.09 113.27,108.98 112.63,109.61 112.63,111.79 113.01,112.17 114.64,112.17 115.01,112.54 115.18,112.37 120.24,112.37 121.15,113.28 123.36,113.28 124.73,114.65 130.02,114.65 130.57,115.21 130.57,115.54 131.08,116.05 131.56,116.05 131.61,116 134.31,116 135.05,116.73 135.68,116.73 138.93,119.98 142.95,123.99 143.18,124.22 143.17,124.66 144.14,125.62 144.14,125.82 147.19,128.88 148.79,128.88 150.52,130.6 150.69,130.6 151.2,131.11 156.28,131.11 156.94,131.77 157.63,131.77 158.11,132.25 158.11,134.21 161.82,137.92 162.65,137.92 163.34,137.23 168.91,137.23 169.57,137.89 170.88,137.89 171.32,137.46 171.32,125.37 170.8,124.85 170.8,113.29 170.2,112.7 154.32,112.7 154.07,112.44 151.98,112.44 139.99,100.45
+1.35V on IN3: 160.01,127.68 168.27,127.68 168.65,128.06 172.33,128.06 172.84,127.55 172.84,122.6 172.71,122.47 172.71,108.25 174.11,106.85 174.11,100.25 173.47,99.61 160.65,99.61 159.89,100.38 159.89,123.87 160.14,124.13 160.14,126.54 159.76,126.92 159.76,127.43
+1.35VP on TOP (solid shape): 178.68,169.98 179.45,169.98 179.5,169.93 179.5,169.78 179.47,169.75 178.64,169.75 178.4,169.5 178.4,168.87 178.19,168.65 175.49,168.65 175.28,168.44 175.22,168.44 174.33,169.32 174.33,169.61 174.72,170 178.67,170
+1.35VP on BOTTOM (solid shape): 161.82,175.65 161.82,163.65 161.35,163.18 160.7,163.18 160.27,163.62 159.63,163.62 159.63,163.57 159.25,163.18 156.08,163.18 155.95,163.31 155.95,163.88 156.08,164 156.33,164 156.46,164.13 156.46,165.91 156.33,166.04 156.08,166.04 155.95,166.16 155.95,167.94 156.99,168.98 156.99,172.87 157.2,173.08 157.2,175.1 158.24,176.15 161.32,176.15
+1.35VP on IN3 (solid shape): 159.23,167.1 159.23,166.41 159.22,166.41 159.22,164.38 159.12,164.38 158.69,163.95 157.5,163.95 157.42,164.03 157.42,164.64 157.29,164.77 156.7,164.77 156.52,164.94 156.52,167.11 156.66,167.25 159.07,167.25
+1.35VP on TOP: 155.94,163.49 156.08,163.35 158.98,163.35 159.49,163.86 159.49,167.34 159.3,167.53 156.28,167.53 156.19,167.44 155.7,167.44 155.44,167.18 155.44,166.42 155.57,166.29 155.9,166.29 155.9,166.17 155.95,166.12 155.95,164.38 155.82,164.26 155.57,164.26 155.44,164.13 155.44,163.62 155.58,163.49
+1.35VS_VGA on BOTTOM: 48.75,170.85 48.49,171.1 47.86,171.74 47.86,173.77 47.87,173.78 47.87,175.69 48.75,176.56 57.64,176.56 58.27,175.93 60.43,175.93 60.56,175.8 60.56,174.54 60.32,174.3 60.32,174.29 60.19,174.16 59.81,174.16 59.3,173.66 59.3,172.76 59.18,172.64 53.46,172.64 51.67,170.85
+1.35VS_VGA on IN2: 48.76,176.58 60.32,176.58 60.57,176.32 60.57,174.04 60.51,173.97 60.51,173.34 58.67,171.5 52.57,171.5 51.94,170.86 48.76,170.86 48.51,171.12 48.38,171.12 47.74,171.75 47.74,175.56
+1.35VS_VGA on VCC: 38.89,122.48 30.79,125.49 22.22,126.51 13.2,126.51 12.34,126.78 11.79,127.5 11.74,127.63 11.68,127.75 11.13,128.31 10.37,128.51 5.21,128.51 4.91,129.22 4.2,129.51 2,129.51 0.95,129.95 0.51,131 0.51,164 0.95,165.05 2,165.49 14.7,165.49 15.77,165.93 16.21,167 16.21,172 16.65,173.05 17.7,173.49 22.2,173.49 22.91,173.79 23.21,174.5 23.21,177 23.35,177.35 23.7,177.49 29.19,177.49 29.19,177.4 29.36,176.83 29.83,176.46 29.83,170.49 30.61,169.7 38.82,169.7 39.61,170.49 39.61,176.48 40.04,176.85 40.21,177.4 40.21,177.49 52.19,177.49 52.19,174.95 53.59,173.55 53.59,172.87 51.81,171.09 51.81,166.9 51.8,166.89 51.8,166.68 51.81,166.67 51.81,166.26 51.8,166.25 51.8,166.04 51.81,166.03 51.81,163.22 51.3,162.71 51.3,158.6 50.53,157.83 50.53,155.46 50.4,155.33 50.4,155.12 50.54,154.98 50.54,149.73 50.82,149.45 50.82,146.25 50.28,145.72 50.26,145.72 49.52,144.98 49.52,140.66 50.28,139.9 50.28,138.63 51.68,137.11 51.68,133.02 44.44,125.78 42.18,125.78
+1VALW on TOP (solid shape): 138.21,167.1 138.21,163.75 138.23,163.73 138.23,163.68 138.24,163.68 138.28,163.68 138.28,163.67 138.28,157.26 138.16,157.13 135.36,157.13 135.11,157.39 135.11,163.48 135.07,163.48 134.66,163.89 134.66,166.32 134.83,166.48 134.85,166.48 136.16,166.7 137.38,167.26 137.39,167.26 138.04,167.26
+1VALW on BOTTOM (solid shape): 138.2,166.93 138.2,166.79 138.2,166.79 138.2,163.59 138.14,163.52 135.09,163.52 134.8,163.81 134.8,166.48 136.04,166.66 137.19,167.15 137.2,167.15 137.98,167.15
+1VALW on TOP: 44.81,129.06 48.11,129.06 48.62,128.56 73.27,128.56 73.92,129.21 74.8,129.21 75.3,128.7 75.3,128.19 75.29,128.18 75.29,125.97 73.96,124.63 55.86,124.63 55,125.5 51.66,125.5 51.26,125.89 48.33,125.89 47.59,126.63 45.05,126.63 44.69,126.27 44.69,123.48 44.56,123.35 42.65,123.35 42.4,123.6 42.4,126.65
+1VALW on TOP: 76.97,123.02 77.55,123.02 77.82,122.75 77.82,121.33 77.89,121.26 78.22,121.26 78.45,121.48 78.45,123.49 77.49,124.46 76.9,124.46 76.83,124.38 76.83,123.67 76.62,123.46 76.4,123.46 76.01,123.08 76.01,122.58 76.07,122.53 76.47,122.53
+1VALW on TOP: 89.25,149.25 89.71,149.25 89.71,148.71 89.73,148.69 90.52,148.69 90.77,148.94 90.77,153.11 91.46,153.79 93.97,153.79 94.23,153.54 94.23,147.49 92.69,145.96 87.33,145.96 87.18,146.11 87.18,148.6 87.24,148.66 88.03,148.66 88.05,148.69 88.05,149.17 88.11,149.22 88.46,149.22 88.49,149.2 88.49,148.69 88.51,148.66 89.25,148.66
+1VALW on BOTTOM: 40.47,123.98 40.47,130.13 40.65,130.31 43.22,130.31 43.25,130.28 43.25,126.45 43.32,126.21 43.51,126.04 43.54,126.03 44.93,126.03 45.7,125.25 45.7,123.98 45.32,123.6 40.85,123.6
+1VALW on IN1: 85.26,139.03 76.44,130.21 76.44,128.94 73.9,126.4 73.21,125.71 73.27,125.65 73.27,120.32 72.26,119.3 46.22,119.3 41.52,124 41.52,126.28 41.9,126.67 43.3,126.67 45.71,129.08 68.95,129.08 68.95,129.46 80.63,141.13 80.63,142.27 83.8,145.45 85.12,146.77 85.12,149.01 86.76,150.64 93.57,150.64 94.71,149.5 94.71,148.97 91.94,146.2 91.94,145.59 91.97,145.56 91.97,143.05 87.95,139.03
+1VALW on VCC: 83.16,146.22 82.42,146.96 82.42,148.28 83.3,149.17 83.29,154.85 83.29,174.49 85.75,174.49 86.82,174.93 87.26,176 87.26,177 87.4,177.35 87.75,177.49 138.04,177.49 138.04,164.11 137.68,163.75 115.16,163.75 114.52,164.38 108.09,164.38 107.31,163.6 107.31,162.73 107.3,159.27 106.31,158.29 102.25,158.29 90.18,146.22 ; 1 cut-out
+1VALW_CLK2 on BOTTOM: 83.93,132.37 84.18,132.11 84.18,129.83 83.93,129.57 82.48,129.57 82.29,129.76 82.29,132.23 82.43,132.37
+1VALW_CLK4 on TOP: 83.23,125.38 83.1,125.25 81.39,125.25 81.13,125.51 81.13,126.7 81.3,126.87 83.15,126.87 83.23,126.79
+1VALW_CLK4 on IN2: 106.41,125.64 106.53,125.51 106.53,125 105.51,123.97 101.21,123.97 100.98,123.74 99.84,123.74 98.94,122.84 89.9,122.84 89.22,123.52 87.81,123.52 86.33,125 81.52,125 81.13,125.38 81.13,126.4 81.39,126.65 89.11,126.65 91.53,124.23 94.02,124.23 94.35,123.9 97.62,123.9 97.69,123.83 98.5,123.83 99.8,125.13 100.53,125.13 100.92,124.73 102.93,124.73 103.69,125.5 104.95,125.5 105.08,125.64
+1VALW_PCH on TOP: 90.53,145.7 90.66,145.57 90.66,143.3 90.4,143.04 90.39,143.04 89.99,142.64 89.05,142.64 88.26,143.43 88.26,145.51 88.45,145.7
+1VALW_PCH on TOP: 107.13,126.94 106.88,127.2 106.88,127.5 107.06,127.68 107.06,128.06 107.05,128.07 107.05,128.57 107.63,129.14 108.39,129.14 108.53,129.28 109.47,129.28 109.59,129.15 109.59,128.57 109.76,128.41 110.39,128.41 110.99,127.81 110.99,126 110.74,125.75 109.59,125.75 109.39,125.95 109.39,126.16 109.01,126.54 108.37,126.54 107.97,126.94
+1VALW_PCH on TOP: 86.09,125.05 86.09,125.89 90.17,129.97 95.55,129.97 95.74,129.78 95.74,128.3 95.87,128.18 96.37,128.18 96.45,128.25 97.46,128.25 98.42,129.21 98.42,132 97.86,132.56 97.3,132.56 95.06,134.79 83.41,134.79 83.23,134.62 83.23,133.83 83.41,133.65 85.31,133.65 85.67,133.29 85.67,129.69 85.24,129.26 84.3,129.26 84.28,129.24 83.9,129.24 83.63,128.98 83.63,125.04 83.94,124.73 85.77,124.73
+1VALW_PCH on BOTTOM: 90.66,143.42 90.28,143.42 86.98,140.11 86.98,138.26 87.44,137.79 87.44,133.85 86.99,133.4 86.99,131.25 86.72,130.98 86.72,129.95 86.47,129.7 84.94,129.7 84.56,130.08 84.56,132.3 84.22,132.65 81.82,132.65 81.48,132.99 81.48,141.66 85.22,145.41 90.62,145.41 90.87,145.16 90.87,143.63
+1VALW_PCH on IN2: 98.49,137.92 95.43,137.92 93.83,139.52 93.83,141.51 91.28,144.06 90.77,144.57 89.3,144.57 89.14,144.41 89.14,144 88.79,143.66 88.79,140.93 94.55,135.17 100.96,135.17 101.21,135.43 108.07,135.43 109.09,134.41 109.09,133.78 109.11,133.78 109.11,129.81 110.1,128.82 110.1,128.29 109.33,127.52 109.33,127.43 109.33,127.43 109.33,127.16 110.61,125.88 111.4,125.88 111.82,126.3 112.88,126.3 113.47,125.71 113.47,125.17 113.56,125.07 113.96,125.07 114.22,125.33 114.22,127.12 113.91,127.43 112.36,127.43 112.02,127.77 112,127.79 112,130.87 113.92,132.79 113.92,140.01 112.52,141.41 101.98,141.41
+1VS_VGA on BOTTOM (solid shape): 47.43,130.03 47.43,129.32 47.78,128.96 48.07,128.96 48.18,128.85 48.18,128.83 48.51,128.49 48.88,128.49 49.17,128.77 49.25,128.81 49.28,128.78 49.28,128.77 49.37,128.64 49.5,128.56 49.53,128.55 49.64,128.53 49.75,128.55 49.78,128.56 50.02,128.89 49.82,129.25 49.82,129.85 49.92,129.95 50.6,129.95 50.65,129.9 50.65,129.27 50.35,128.96 50.35,128.58 49.99,128.23 49.99,125.97 49.89,125.86 48.95,125.86 48.83,125.99 48.83,126.22 48.65,126.4 47.68,126.4 47.17,126.91 45.37,126.91 45.27,127.01 45.27,129.98 45.6,130.31 47.15,130.31
+3V_SPI on TOP: 141.14,137.33 143.43,137.33 143.53,137.23 143.53,135.76 143.45,135.68 141.17,135.68 140.99,135.86 140.99,137.18
+3V_SPI on TOP: 137.69,129.76 139.18,129.76 140.33,128.62 140.33,128.01 140.86,127.48 140.86,126.34 140.68,126.16 138.98,126.16 134.1,121.28 131.49,121.28 128.49,124.28 128.49,128.57 128.92,129 130.19,129 130.37,128.82 130.37,128.24 130.93,127.68 130.93,126.28 130.8,126.16 129.96,126.16 129.74,126.39 129.74,127.55 129.58,127.71 129.46,127.71 129.35,127.61 129.35,125.93 129.91,125.37 129.91,124 131.72,122.19 133.85,122.19 138.32,126.67 138.32,128.75 138.17,128.9 137.81,128.9 137.46,129.26 137.46,129.54
+3V_SPI on BOTTOM: 132.95,158.66 130.99,156.7 130.99,154.54 130.72,154.26 128.68,154.26 127.21,155.73 124.95,155.73 124.57,156.12 124.57,160.29 126.08,161.8 126.08,164.26 126.21,164.38 130.78,164.38 132.95,162.21
+3V_SPI on BOTTOM: 143.66,136.32 140.61,136.32 139.39,137.54 139.39,142.34 139.97,142.92 139.97,146.6 139.34,147.24 139.34,150.06 139.39,150.11 139.82,150.11 139.95,149.98 139.95,147.67 140.73,146.88 140.73,142.03 140.2,141.5 140.2,138.2 140.85,137.55 144.46,137.55 145.36,136.65 145.36,132.43 141.42,128.49 137.76,128.49 137.25,129 137.25,129.74 137.51,129.99 138.27,129.99 138.32,129.94 140.63,129.94 144.06,133.37 144.06,135.91
+3V_SPI on IN1: 130.65,155.14 137.48,155.14 140.89,151.74 140.89,150.47 139.74,149.32 138.75,149.32 135.73,152.34 132.83,152.34 131.77,153.41 129.08,153.41 128.92,153.56 128.92,154.3 129.05,154.43 129.94,154.43
+3V_SPI on IN2: 113.99,128.85 114.57,128.27 119.63,128.27 120.54,129.18 120.54,136.22 124.33,140 133.6,140 139.18,145.59 139.18,150.01 139.41,150.24 140.12,150.24 140.45,149.91 140.45,145.13 134.08,138.76 125.16,138.76 121.63,135.23 121.63,128.54 120.46,127.38 118.97,127.38 118.64,127.71 114.06,127.71 113.45,128.32 113.45,128.77 113.53,128.85
+3V_VIN on BOTTOM (solid shape): 211.44,171.02 214.11,171.02 214.49,170.64 214.49,169.02 213.98,168.51 213.98,167.31 213.92,167.25 210.29,167.25 210.02,167.52 210.02,169.29 209.86,169.45 209.74,169.45 209.6,169.59 209.6,170.85 209.9,171.14 211.31,171.14
+3V_WLAN on TOP: 267.7,153.58 269.48,153.58 269.86,153.96 269.86,154.97 269.73,155.1 267.32,155.1 267.19,154.97 267.19,154.08
+3V_WLAN on TOP: 249.97,153.37 250.43,153.83 251.7,153.83 251.81,153.72 251.81,151.28 251.19,150.65 251.19,148.76 251.71,148.24 251.71,138.48 254.63,135.56 259.96,135.56 260.72,134.79 265.4,134.79 266.94,133.26 266.94,131.86 266.55,131.48 263.76,131.48 263.76,131.48 262.31,131.48 260.72,133.06 252.93,133.06 248.79,137.21 248.79,146.22 248.33,146.68 248.33,151.15 248.79,151.61 248.79,153.03 249.13,153.37
+3V_WLAN on BOTTOM: 249.4,156.08 251.27,156.08 251.4,155.95 251.4,153.82 251.53,153.69 251.53,152.17 251.35,151.99 249.88,151.99 249.24,152.62 249.24,155.93
+3V_WLAN on BOTTOM: 269.22,153.58 268.15,153.58 267.93,153.8 267.93,154.24 267.98,154.29 267.98,156.09 268.05,156.17 268.84,156.17 269.35,155.66 269.35,153.7
+3V_WLAN on IN1: 269.09,153.58 269.35,153.83 269.35,155.99 269.35,155.99 269.35,158.1 268.95,158.49 258.95,158.49 257.92,157.46 249.33,157.46 248.43,156.56 248.43,152.47 248.96,151.94 251.45,151.94 252.01,152.5 252.01,153.22 253.26,154.46 259.82,154.46 260.29,154.94 265.45,154.94 266.81,153.58
+3VALW on TOP (solid shape): 217.4,150.81 217.4,148.77 217.06,148.43 212.88,148.43 212.41,148.9 212.41,150.65 212.84,151.09 217.12,151.09
+3VALW on BOTTOM (solid shape): 217.34,150.86 217.34,149.17 217.01,148.83 212.5,148.83 212.12,149.22 212.12,150.77 212.42,151.07 217.13,151.07
+3VALW on TOP: 131.55,152.94 133.08,152.94 133.2,152.81 133.2,149.89 132.95,149.64 131.68,149.64 131.43,149.89 131.43,152.81
+3VALW on TOP: 142.56,137.61 143.5,137.61 143.55,137.66 143.55,138.91 143.43,139.04 142.74,139.04 142.51,138.81 142.51,137.66
+3VALW on TOP: 86.93,148.75 87,148.67 87,146.11 86.85,145.96 84.94,145.96 84.82,146.08 84.82,148.65 84.92,148.75
+3VALW on TOP: 245.47,149.26 247.58,149.26 247.72,149.4 247.72,151.01 247.57,151.16 245.47,151.16 245.22,150.91 245.22,149.51
+3VALW on TOP: 267.32,133.38 267.32,132.62 267.57,132.37 268.97,132.37 269.35,132.75 269.35,135.03 269.09,135.29 266.55,135.29 266.3,135.03 266.3,134.4
+3VALW on TOP: 216.78,138.32 217.62,138.32 217.72,138.22 217.72,136.37 217.67,136.32 214.65,136.32 214.64,136.33 213.85,136.33 213.61,136.57 213.61,139.11 213.86,139.37 216.4,139.37 216.53,139.24 216.53,138.58
+3VALW on TOP: 247.87,98.22 247.87,99.41 247.44,99.84 247.41,99.84 247.01,100.25 244.67,100.25 244.24,100.68 244.24,115.44 235.78,123.9 225.65,123.9 223.72,121.97 223.72,117.29 223.82,117.19 225.09,117.19 225.39,117.5 225.39,121.64 226.15,122.4 235.25,122.4 242.56,115.08 242.56,99 242.77,98.8 244.42,98.8 245.23,97.99 247.64,97.99
+3VALW on TOP: 173.84,123.1 174.48,123.1 174.61,122.97 174.61,122.65 175.15,122.11 175.15,121.81 175.11,121.81 174.61,121.31 174.61,119.16 174.48,119.03 173.72,119.03 173.59,119.16 173.59,122.84
+3VALW on BOTTOM: 223.59,118.94 225.14,118.94 225.32,118.77 225.32,117.37 225.19,117.24 223.59,117.24 223.44,117.39 223.44,118.79
+3VALW on BOTTOM: 142.94,138.35 143.53,138.35 143.88,138.7 143.88,148.69 146.33,151.14 146.33,151.15 147.1,151.91 147.1,152.33 148.84,154.07 148.84,154.83 148.53,155.14 148.1,155.14 146.11,153.14 146.11,152.76 142.84,149.5 142.84,138.45
+3VALW on IN1: 132.07,151.94 135.5,151.94 137.15,150.29 137.15,148.59 137.31,148.43 139.97,148.43 146.7,155.16 148.61,155.16 148.84,154.94 148.84,154.53 142.64,148.33 141.8,148.33 140.07,146.6 137.15,146.6 134.1,149.65 132.07,149.65 131.82,149.91 131.82,151.68
+3VALW on IN1: 249.31,133 249.17,133.14 227.96,133.14 226.18,134.92 215,134.92 214.75,135.17 214.75,138.98 215.13,139.37 227.07,139.37 227.96,138.48 239.9,138.48 242.31,140.89 242.31,150.54 243.07,151.3 247.77,151.3 248.02,151.05 248.02,149.4 245.61,146.99 245.61,142.16 252.99,134.78 268.97,134.78 269.22,134.53 269.22,133.38 268.84,133
+3VALW on IN2: 224.45,139.72 225.75,138.43 225.75,117.47 225.65,117.37 224.68,117.37 224.48,117.57 224.48,132.41 222.9,133.98 215.08,133.98 214.01,135.05 214.01,139.37 214.37,139.72
+3VALW on IN2: 138.42,150.8 138.42,148.38 138.04,148 133.22,148 126.23,154.99 119.82,154.99 116.07,151.24 99.69,151.24 98.61,150.16 89.65,150.16 86.35,146.86 83.18,146.86 82.8,147.24 82.8,148.38 87.56,153.14 98.1,153.14 100.32,155.37 113.53,155.37 117.72,159.56 127.25,159.56 134.1,152.7 135.25,152.7 135.37,152.57 135.76,152.57 142.99,159.81 182.87,159.81 190.75,151.94 216.78,151.94 217.16,151.56 217.16,149.02 216.65,148.51 188.08,148.51 180.46,156.13 173.83,156.13 172.84,157.12 147.39,157.12 146.4,156.13 143.76,156.13 ; 1 cut-out
+3VALW on IN3: 212.84,150.8 218.18,150.8 220.85,148.13 220.85,140.89 217.8,137.84 217.8,135.94 217.54,135.68 214.88,135.68 214.62,135.94 214.62,146.22 212.59,148.26 212.59,150.54
+3VALW_LAN on TOP: 248.27,99.35 248.39,99.47 253.09,99.47 253.22,99.35 253.22,98.2 253.09,98.08 250.3,98.08 250.17,97.95 250.17,97.19 250.43,96.93 250.43,96.3 250.3,96.17 248.39,96.17 248.27,96.3
+3VALW_LAN on BOTTOM: 246.11,97.06 250.68,97.06 250.93,96.81 250.93,96.3 250.81,96.17 248.01,96.17 247,95.16 246.11,95.16 245.85,95.41 245.85,96.81
+3VALW_LAN on IN1: 249.41,97.19 255,97.19 259.06,93.12 259.06,90.33 257.41,88.68 252.58,88.68 249.03,92.23 249.03,96.81
+3VALW_P on BOTTOM (solid shape): 217.87,159.08 217.87,153.73 217.46,153.32 217.46,151.51 217.23,151.27 215.91,151.27 215.37,151.81 213.52,151.81 212.95,151.24 211.02,151.24 210.81,151.45 210.81,154.79 209.31,156.29 209.31,158.9 209.75,159.34 217.61,159.34
+3VALW_PCH on TOP: 125.71,152.81 125.46,152.56 124.31,152.56 123.93,152.18 123.93,151.67 123.68,151.42 122.66,151.42 122.41,151.67 122.41,151.92 122.66,152.18 123.04,152.18 123.3,152.43 123.3,154.98 123.56,155.24 125.6,155.24 125.71,155.12
+3VALW_PCH on TOP: 113.53,135.45 114.8,136.72 114.8,146.07 115.16,146.43 115.16,146.91 115.08,146.99 113.53,146.99 113.15,146.6 113.15,141.4 112.39,140.64 112.39,131.75 111.24,130.6 111.24,129.97 111.63,129.59 112.39,129.59 112.57,129.76 113.25,129.76 113.33,129.84 113.33,131.06 113.73,131.47 113.73,133.12 113.53,133.32
+3VALW_PCH on TOP: 85.07,145.7 87.94,145.7 88.11,145.54 88.11,144.34 87.74,143.98 86.42,143.98 86.09,144.3 85.07,144.3 84.94,144.43 84.94,145.57
+3VALW_PCH on TOP: 103.74,145.45 106.15,145.45 106.28,145.32 106.28,144.94 105.77,144.43 105.77,143.42 105.65,143.29 104.12,143.29 103.99,143.42 103.99,143.8 103.32,144.47 102.53,144.47 102.35,144.65 102.35,145.33 102.45,145.43 103.73,145.43
+3VALW_PCH on BOTTOM: 96,151.56 97.91,151.56 98.16,151.3 98.16,149.4 98.04,149.27 96.39,149.27 95.88,149.78 95.88,151.43
+3VALW_PCH on BOTTOM: 89.38,133.7 89.38,133.03 89.26,132.9 87.35,132.9 87.22,133.03 87.22,133.4 87.6,133.78 89.31,133.78
+3VALW_PCH on BOTTOM: 191.89,57.7 194.68,57.7 194.94,57.96 194.94,63.42 191.13,67.23 168.14,67.23 164.97,70.4 149.73,70.4 146.42,67.1 131.95,67.1 131.56,66.72 131.56,65.32 132.71,64.18 147.82,64.18 151.76,68.12 163.82,68.12 167.25,64.69 189.98,64.69 191.38,63.29 191.38,58.21
+3VALW_PCH on BOTTOM: 87.87,131.86 89.26,131.86 89.39,131.73 89.39,129.06 89.01,128.68 88.5,128.68 88.37,128.81 88.37,129.45 88.25,129.57 87.36,129.57 87.23,129.7 87.23,130.97 87.74,131.48 87.74,131.73
+3VALW_PCH on BOTTOM: 77.92,113.91 79.39,112.44 79.39,93.11 80.51,91.99 80.51,87.17 85.46,82.22 85.46,81.33 84.96,80.82 84.32,80.82 78.99,86.15 78.99,90.98 77.84,92.12 77.84,111.68 76.83,112.7 74.67,112.7 74.41,112.95 74.41,113.74 74.59,113.91
+3VALW_PCH on IN2: 74.54,112.7 74.29,112.95 74.29,118.92 70.35,122.86 70.35,132.89 71.62,134.16 74.16,134.16 77.2,137.2 77.2,137.83 85.84,146.48 86.86,146.48 90.16,149.78 98.8,149.78 99.56,150.54 115.94,150.54 119.88,154.48 126.1,154.48 133.09,147.49 137.03,147.49 137.79,146.73 137.79,144.19 133.47,139.87 132.33,139.87 126.1,146.1 114.29,146.1 111.5,143.3 100.45,143.3 99.31,144.45 89.27,144.45 88.51,143.68 88.51,140.64 94.21,134.94 101.08,134.94 101.32,135.17 108.07,135.17 108.96,134.29 108.96,129.59 109.47,129.08 109.59,129.08 109.85,128.82 109.85,128.42 109.1,127.67 108.57,127.67 108.55,127.68 107.31,127.68 106.8,128.19 106.8,128.55 106.79,128.56 106.79,129.46 106.53,129.71 105.91,129.71 105.4,130.22 105.4,133.27 105.15,133.52 92.78,133.52 89.22,137.08 80.12,137.08 78.98,135.94 78.98,134.4 79.36,134.02 87.17,134.02 89.14,132.05 89.14,130.46 88.88,130.21 87.61,130.21 87.61,130.21 87.34,130.21 86.9,129.76 75.62,129.76 73.65,127.8 73.65,122.86 76.7,119.81 76.7,113.71 75.68,112.7
+3VALW_PCH on IN3: 86.1,146.1 90.92,146.1 91.31,145.72 91.31,143.81 90.8,143.3 86.35,143.3 85.72,143.94 85.72,145.72
+3VALW_PCH on IN3: 83.69,81.83 84.96,83.1 85.21,83.1 93.21,75.1 100.83,75.1 108.45,67.48 132.96,67.48 133.34,67.1 133.34,65.45 132.96,65.07 108.07,65.07 99.69,73.45 91.69,73.45 83.69,81.45
+3VALW_PCH on IN3: 109.72,130.98 114.55,130.98 115.18,130.35 115.18,128.32 113.91,127.05 111.93,127.05 110.91,128.06 109.85,128.06 109.34,128.57 109.34,130.6
+3VALW_PRIM on BOTTOM: 86.98,129.32 87.99,129.32 88.12,129.19 88.12,128.3 87.48,127.67 86.47,127.67 86.34,127.79 86.34,128.68
+3VALW_PRIM on IN2: 112.63,126.14 113.27,125.51 113.27,125.25 113.01,125 112.88,125 112.63,125.25 112.63,125.38 112.38,125.64 112.07,125.64 110.94,124.51 108.81,124.51 108.5,124.81 108.5,126.18 108.29,126.4 105.14,126.4 104.63,126.91 98.79,126.91 98.15,127.54 96.76,127.54 96.5,127.79 94.72,127.79 94.46,128.06 91.15,128.06 90.91,128.3 87.1,128.3 86.85,128.56 86.85,128.81 86.98,128.94 96.12,128.94 96.14,128.91 96.53,128.91 97.12,128.32 98.53,128.32 98.8,128.05 100.5,128.05 101.01,127.54 103.5,127.54 104.02,128.06 105.15,128.06 106.18,127.03 107.68,127.03 107.69,127.02 108.93,127.02 110.2,125.75 111.55,125.75 111.94,126.14
+3VALW_RTCPRIM on TOP: 129.76,143.2 130.4,143.2 130.47,143.12 131.21,143.12 131.23,143.15 135.37,143.15 136.01,142.51 136.95,142.51 137.05,142.41 137.05,141.65 136.85,141.45 133.16,141.45 132.38,142.24 129.84,142.24 129.69,142.39 129.69,143.12
+3VALW_RTCPRIM on TOP: 114.75,128.32 114.98,128.54 115.54,128.54 115.61,128.47 115.61,127.4 115.28,127.07 113.58,127.07 113.35,127.3 113.35,128.21 113.45,128.32
+3VL on BOTTOM (solid shape): 218.99,170.89 218.99,168.63 218.89,168.54 218.57,168.54 218.55,168.52 218.28,168.52 218.28,168.52 217.49,168.52 217.49,168.52 217.44,168.58 217.44,169.26 217.23,169.47 216.42,169.47 216.31,169.58 216.31,170.86 216.54,171.09 218.78,171.09
+3VL on IN2: 196.46,139.11 204.46,147.11 217.04,147.11 218.56,148.64 218.56,168.58 217.67,169.46 217.67,171.24 218.31,171.88 226.18,171.88 226.43,171.62 226.43,144.7 221.73,140 209.67,140 201.03,131.36 201.03,119.05 197.48,115.49 197.48,114.85 198.49,113.84 199.64,113.84 200.27,113.2 200.27,111.93 198.11,109.77 180.84,109.77 177.28,113.33 177.28,114.09 173.22,118.16 173.22,129.08 183.25,139.11
+3VLX on BOTTOM (solid shape): 213.49,166.14 213.49,165.04 213.7,164.84 214.79,164.84 215.19,164.44 215.19,164.11 216.5,162.8 216.5,160.26 216.17,159.93 209.9,159.93 209.84,159.99 208.35,159.99 208.02,160.32 208.02,162.73 208.15,162.86 209.56,162.86 211.53,164.83 212.01,164.83 212.27,165.09 212.27,166.13 212.33,166.19 213.44,166.19
+3VS on TOP: 141.93,137.56 142,137.64 142,138.3 141.09,139.21 140.33,139.21 140.15,139.04 140.15,138.02 140.61,137.56
+3VS on TOP: 40.63,126.03 42.16,126.03 42.28,126.16 42.28,126.79 42.66,127.17 42.66,127.94 42.54,128.06 41.9,128.06 41.78,127.94 41.78,127.3 41.14,126.67 40.63,126.67 40.51,126.54 40.51,126.16
+3VS on TOP: 125.98,152.19 126.74,152.19 127.63,151.3 128.14,151.3 128.26,151.18 128.26,150.29 128.14,150.16 126.1,150.16 125.85,150.41 125.85,152.07
+3VS on TOP: 148.33,153.72 150.11,153.72 150.23,153.59 150.23,152.07 151.63,150.67 151.63,149.27 151.38,149.02 150.87,149.02 150.74,149.14 150.74,150.16 149.34,151.56 148.46,151.56 147.69,152.32 147.69,152.57 147.95,152.83 147.95,153.34
+3VS on TOP: 74.66,161.07 75.8,162.21 79.1,162.21 79.61,161.7 79.61,157.89 79.23,157.51 75.55,157.51 73.9,159.16 73.9,160.94 74.02,161.07
+3VS on TOP: 125.24,148.13 128.52,148.13 128.64,148 128.64,147.49 128.52,147.37 124.45,147.37 124.2,147.62 124.2,148.15 124.3,148.26 125.11,148.26
+3VS on TOP: 112.77,152.11 112.31,152.11 112.25,152.05 110.6,152.05 110.47,152.18 110.47,153.45 110.6,153.58 111.36,153.58 111.49,153.7 111.49,155.35 111.61,155.48 112.88,155.48 113.01,155.35 113.01,152.36
+3VS on TOP: 229.1,148.64 222.75,142.29 199.89,142.29 194.43,147.75 191.64,147.75 188.84,150.54 188.84,156 189.48,156.64 191,156.64 191.06,156.57 192.59,156.57 194.94,154.22 197.35,154.22 199.89,151.68 204.72,151.68 208.53,147.87 218.43,147.87 226.43,155.88 234.69,155.88 242.05,148.51 247.49,148.51 247.85,148.15 247.85,146.66 248,146.5 248.02,146.5 248.53,145.99 248.53,143.3 248.4,143.18 235.83,143.18 230.37,148.64
+3VS on TOP: 216.36,132.67 217.2,132.67 217.3,132.57 217.3,130.61 217.29,130.6 217.29,129.84 217.16,129.71 213.73,129.71 213.57,129.88 213.57,132.62 213.65,132.7 214.38,132.7 214.38,132.14 215.14,132.14 215.14,132.7 215.6,132.7 215.6,132.14 216.36,132.14
+3VS on TOP: 251.31,156.12 251.31,154.72 252.33,153.7 252.33,151.92 252.58,151.67 253.6,151.67 253.85,151.92 253.85,155.1 252.71,156.24 251.44,156.24
+3VS on TOP: 196.44,72.43 194.39,70.39 187.33,70.39 187.03,70.7 187.03,73.34 187.23,73.54 191.47,73.54 191.75,73.82 191.75,77.25 199.5,85 229.09,85 236.58,77.5 241.03,77.5 241.41,77.12 241.41,74.33 241.15,74.07 233.53,74.07 225.41,82.2 202.04,82.2 196.44,76.6
+3VS on TOP: 254.59,140.19 254.72,140.06 254.72,138.74 254.46,138.49 252.58,138.49 252.2,138.87 252.2,139.94 252.46,140.19
+3VS on TOP: 170.21,60.18 174.58,60.18 175.8,58.96 175.8,58.66 174.16,57.02 172.59,57.02 171.81,56.24 171.81,54.59 171.51,54.29 169.91,54.29 169.73,54.46 169.73,59.7
+3VS on BOTTOM: 100.83,149.14 101.47,149.14 101.59,149.02 108.45,149.02 109.72,147.75 109.72,143.81 109.21,143.3 102.1,143.3 101.08,144.32 101.08,147.24 100.45,147.87 100.45,148.76
+3VS on BOTTOM: 244.91,84.64 245.02,84.54 245.02,84.11 244.91,84 244.38,84 244.18,83.8 244.18,82.58 244.53,82.23 244.53,78.82 241.51,75.8 241.51,74.66 241.05,74.2 236.71,74.2 236.33,74.58 236.33,77.25 236.34,77.26 236.34,83.99 236.99,84.64
+3VS on BOTTOM: 213.34,138.97 213.72,139.35 231.63,139.35 238.12,145.84 240.53,145.84 240.53,145.84 254.36,145.84 255,145.21 255,140.76 255.14,140.76 261.1,134.79 268.34,134.79 272.66,130.48 272.66,116.38 272.15,115.87 266.44,115.87 264.15,118.16 264.15,130.09 261.36,132.89 252.98,132.89 248.79,137.08 241.42,137.08 234.93,130.59 228.08,130.59 227.21,129.71 213.61,129.71 213.34,129.98
+3VS on BOTTOM: 140.4,138.27 140.78,138.27 141.14,138.63 141.14,139.49 141.62,139.97 141.62,148.15 140.66,149.12 140.66,150.19 139.87,150.97 139.57,150.97 139.39,150.8 139.39,150.36 139.57,150.19 139.74,150.19 139.97,149.96 139.97,147.72 140.78,146.91 140.78,141.98 140.23,141.42 140.23,138.45
+3VS on BOTTOM: 112.5,153.83 112.5,152.18 112.38,152.05 110.6,152.05 110.47,152.18 110.47,153.83 110.73,154.08 112.25,154.08
+3VS on BOTTOM: 65.92,124.09 66.68,124.09 71.36,119.41 71.36,118.78 69.32,116.75 68.31,116.75 67.42,117.63 67.42,118.02 68.31,118.9 68.31,119.41 68.05,119.67 67.67,119.67 67.29,119.29 66.96,119.29 64.17,122.08 64.17,122.33
+3VS on IN1: 249.08,80.8 244.47,80.8 244.1,80.44 241.17,80.44 238.75,82.85 238.75,93.9 239.13,94.28 244.98,94.28 245.85,93.4 245.85,90.2 245.73,90.08 245.47,90.08 244.46,91.09 244.08,91.09 243.57,90.58 243.57,89.19 243.95,88.81 243.95,83.22 244.33,82.84 249.04,82.84 251.75,85.54 252.49,85.54 252.88,85.16 252.88,84.6
+3VS on IN1: 254.96,153.79 255.03,153.72 255.03,151.83 252.58,149.38 252.58,146.84 253.09,146.34 253.09,141.28 253.85,140.52 253.85,138.72 253.6,138.46 250.17,138.46 246.25,142.39 246.25,146.35 252.21,152.32 252.21,153.16 252.85,153.79
+3VS on IN2: 245.73,96.3 245.73,89.82 245.6,89.69 224.15,89.69 222.48,91.36 217.42,91.36 215.89,92.88 202.94,92.88 202.05,93.77 202.05,106.09 201.92,106.22 201.91,106.22 201.15,106.98 201.15,112.71 199.76,114.09 198.61,114.09 197.83,114.87 197.83,115.34 201.29,118.79 201.29,119.29 213.73,131.73 218.8,131.73 219.06,131.48 219.06,119.93 216.53,117.41 216.53,109.29 217.14,108.68 219.12,108.68 229.47,98.33 243.69,98.33
+3VS on IN2: 246.63,146.1 248.66,146.1 256.53,138.22 263.01,138.22 278.76,122.47 278.76,111.93 278.25,111.43 268.6,111.43 245.99,134.03 245.99,145.46
+3VS on IN2: 190.56,73.34 190.56,71.03 194.93,66.66 194.93,59.75 194.72,59.54 193.68,59.54 193.35,59.87 193.35,63.1 189.67,66.78 186.39,66.78 177.73,58.12 177.31,58.12 175.65,56.47 174.06,56.47 173.71,56.82 173.71,58.26 189.04,73.59 190.31,73.59
+3VS on VCC: outline of 90 points within 64.62,117.78 192.27,159.69
+3VS_DP on TOP: 255.12,139.73 255.12,137.83 255.25,137.7 257.54,137.7 257.79,137.95 257.79,139.73 257.54,139.99 255.38,139.99
+3VS_DP on IN1: 260.59,154.21 263.76,154.21 270.87,147.1 270.87,144.81 263.89,137.83 255.76,137.83 254.11,139.48 254.11,140.64 253.36,141.39 253.36,142.79 253.35,142.79 253.35,148.11 254.11,148.88 256.79,148.88 259.82,151.91 259.82,153.45
+3VS_LS on TOP (solid shape): 217.67,134.92 217.67,134.16 217.64,134.12 217.64,133.61 216.91,132.89 213.73,132.89 213.61,133.02 213.61,134.92 213.73,135.05 217.54,135.05
+3VS_VGA on TOP (solid shape): 70.31,161.69 70.84,161.69 70.87,161.66 70.87,161.52 70.85,161.5 70.75,161.5 70.74,161.5 70.31,161.5 70.31,160.64 70.11,160.43 69.27,160.43 68.13,159.29 66.71,159.29 66.45,159.54 66.45,160.47 68.08,162.1 70.31,162.1
+3VS_VGA on IN1: 58.67,150.55 60.81,150.55 64.57,154.32 64.57,160.43 65.13,160.99 67.67,160.99 68.59,160.08 69.55,160.08 71.98,157.65 71.98,151.03 69.73,148.78 58.67,148.78 58.41,149.03 58.41,150.3
+5V_ALW on TOP (solid shape): 138.4,66.55 139.23,66.55 139.65,66.13 141.35,66.13 141.51,65.97 141.51,62.52 141.49,62.51 141.49,59.25 141.47,59.23 141.47,58.72 140.57,57.82 137.25,57.82 137.14,57.7 135.76,57.7 135.32,57.27 135.32,55.96 135.25,55.89 133.61,55.89 133.52,55.98 133.52,59.68 134.34,60.5 136.64,60.5 136.71,60.56 137.34,60.56 137.95,61.17 137.97,61.19 137.97,61.49 137.96,61.63 137.91,61.76 137.91,62.37 137.92,62.38 137.94,62.53 137.92,62.68 137.91,62.69 137.91,64.07 137.93,64.15 137.94,64.23 137.94,65.09 137.91,65.11 137.91,65.58 137.64,65.85 137.64,66.79 137.7,66.85 138.11,66.85
+5V_VIN on TOP (solid shape): 199.88,174.52 199.88,173.52 199.38,173.02 197.6,173.02 197.48,173.15 197.48,173.37 197.5,173.38 197.5,174.56 197.81,174.88 199.52,174.88
+5V_VIN on BOTTOM (solid shape): 197.31,175.83 198.25,175.83 199.08,175 201.71,175 201.88,174.82 201.88,172.72 201.84,172.68 199.87,172.68 199.6,172.94 197.48,172.94 197.11,172.58 196.78,172.58 196.64,172.72 196.64,174.79 196.96,175.1 196.96,175.75 197.05,175.84 197.3,175.84
+5VALW on TOP (solid shape): 204.65,154.62 204.65,153.45 204.06,152.85 200.42,152.85 199.84,153.43 199.84,155.03 200.27,155.45 203.82,155.45
+5VALW on TOP (solid shape): 137.89,69.89 142.11,69.89 142.23,69.77 142.23,69.13 142.11,69.01 141.83,69.01 141.76,68.94 139.12,68.94 139.02,69.04 137.7,69.04 137.6,69.15 137.6,69.88 137.62,69.91 137.88,69.91
+5VALW on BOTTOM (solid shape): 203.27,155.32 204.4,155.32 204.56,155.16 204.56,153.21 204.38,153.02 199.81,153.02 199.44,153.39 199.44,155.06 199.71,155.34 203.25,155.34
+5VALW on BOTTOM (solid shape): 194.8,167.54 194.8,166.29 194.15,165.64 192.72,165.64 192.17,166.2 192.17,167.71 192.27,167.82 194.17,167.82 194.19,167.84 194.5,167.84
+5VALW on TOP: 219.19,138.48 219.83,138.48 220.08,138.73 220.08,139.49 220.34,139.75 223.13,139.75 223.64,139.24 223.64,136.57 223.39,136.32 219.07,136.32 218.94,136.44 218.94,138.22
+5VALW on TOP: 84.19,50.59 84.45,50.59 85.08,49.96 85.08,48.69 84.96,48.56 84.07,48.56 83.81,48.81 83.81,49.2 84.07,49.45 84.07,50.47
+5VALW on BOTTOM: 276.84,124.49 276.84,119.36 276.31,118.83 274.38,118.83 274.1,119.11 274.1,124.31 274.11,124.33 274.11,125.45 274.31,125.65 276.6,125.65 276.85,125.4 276.85,124.5
+5VALW on BOTTOM: 280.27,23.53 280.52,23.27 281.41,23.27 282.18,22.51 282.18,20.73 281.92,20.48 280.91,20.48 280.4,20.99 279.25,20.99 278.57,21.67 278.57,25.31 278.75,25.48 279.97,25.48 280.27,25.18
+5VALW on VCC: outline of 163 points within 113.65,24.04 290.34,155.1 ; 4 cut-outs
+5VALW on IN3: 200.27,155.11 205.1,155.11 214.24,145.97 214.24,135.81 214.75,135.3 217.54,135.3 218.05,135.81 218.05,137.59 219.58,139.11 221.86,139.11 222.24,138.73 222.24,132.63 221.73,132.13 210.05,132.13 209.67,132.51 209.67,143.05 200.02,152.7 200.02,154.86
+5VALW_P on TOP (solid shape): 204.11,161.6 204.11,157.17 203.83,156.89 199.3,156.89 198.76,157.44 198.76,159.3 198.75,159.3 197.99,160.07 197.99,161.59 198.3,161.91 203.8,161.91
+5VALW_P on BOTTOM (solid shape): 205.69,164.42 205.69,162.4 204.47,161.18 204.47,156.96 204.73,156.7 204.73,155.81 204.44,155.52 203.33,155.52 202.87,155.99 202.87,156.06 200.95,156.06 200.4,155.51 199.45,155.51 198.48,156.47 198.48,159.7 198.11,160.07 198.11,164.26 198.37,164.51 198.81,164.51 198.97,164.66 205.44,164.66
+5VLP on TOP (solid shape): 223.67,170.07 223.67,169.39 224.15,168.91 224.16,168.91 224.32,168.75 224.32,168.21 224.23,168.12 223.13,168.12 222.98,168.27 222.98,168.54 222.66,168.86 222.06,168.86 221.73,169.19 221.73,170.04 221.87,170.19 223.55,170.19
+5VLX on BOTTOM (solid shape): 201.83,171.5 201.83,170.35 202.2,169.98 204.64,169.98 204.92,169.98 205.62,169.27 205.62,165.59 205.23,165.2 197.17,165.2 196.84,165.53 196.84,166.16 197.06,166.38 198.64,166.38 199.06,166.8 199.06,168.36 199.91,169.21 200.24,169.21 200.61,169.58 200.61,171.46 200.69,171.54 201.78,171.54
