# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCK_AUXN_CONN: length 53.2
  TOP w0.114: RM16.2 267.65,141.91 267.83,142.09 269.06,142.09 v1(269.36,141.79) ; JLINK.17 285.55,115.07 285.63,115.15 285.63,115.4 285.76,115.53 286.2,115.53 286.54,115.18 286.54,114.84 286.32,114.61 286.32,114.38 286.54,114.15 286.54,113.77 286.34,113.57 286.34,113.29 286.54,113.09 286.54,112.66 285.91,112.02 v1(283.16,112.02) 282.84,112.02 282.48,111.67 282.12,111.67 281.86,111.93 D16.2 D16.8 280.53,111.93 280.3,111.69 280.07,111.69 R106.2 279.46,111.89 279.34,111.77 277.43,111.77 277.35,111.84 v1(277.35,112.05)
  IN1 w0.14: v1(277.35,112.05) 277.6,111.79 278.01,111.79 278.72,112.5 278.72,125.88 269.94,134.67 269.94,141.76 269.72,141.98 269.55,141.98 v1(269.36,141.79)
DOCK_AUXN_R: length 14
  TOP w0.114: v1(270.9,142.18) 270.46,142.62 270.18,142.62 270.03,142.47 270.03,141.6 269.69,141.27 268.69,141.27 CM7.1 ; v1(270.92,144.25) 270.77,144.41 270.36,144.41 269.77,143.81 268.73,143.81 RM15.2
  BOTTOM w0.114: v1(270.9,142.18) 270.89,142.19 270.89,142.2 271.13,142.44 271.31,142.44 271.48,142.27 271.48,141.53 270.96,141 270.4,141 270.05,141.35 270.05,144.31 270.4,144.66 270.47,144.66 270.54,144.58 270.54,144.36 270.65,144.25 v1(270.92,144.25)
DOCK_AUXN_RE: length 2.8
  TOP w0.114: CM6.2 266.73,144.38 266.62,144.49 266.35,144.49 265.79,143.94 265.2,143.94 265.07,143.81 UM1.29
DOCK_AUXP: length 231.7
  TOP w0.114: v1(269.37,144.91) 269.21,144.75 267.84,144.75 267.66,144.93 RM13.1
  IN3 w0.076: v2(101.92,108.34) 102.06,108.34 102.17,108.24 102.17,108.06 102.06,107.95 100.71,107.95 100.69,107.97 100.67,107.97
  IN3 w0.114: v1(269.37,144.91) 269.37,144.88 269.6,144.65 269.8,144.65 269.96,144.81 269.96,145.22 269.62,145.56 268.1,145.56 267.01,146.65 258.23,146.65 257.17,145.59 251.07,145.59 250.05,146.6 240.41,146.6 228.8,134.99 228.8,133.75 199.22,104.17 199.22,102.99 181.6,85.38 171.32,85.38 163.27,77.33 112.33,77.33 105.31,84.35 105.31,91.85 101.53,95.63 101.53,96.62 99.63,98.53 99.63,107.36 100.24,107.97 100.67,107.97
  BOTTOM w0.076: UC1.F50 v2(101.92,108.34)
DOCK_AUXP_CONN: length 53.3
  TOP w0.114: v1(269.36,142.42) 269.26,142.32 267.93,142.32 267.65,142.6 CM8.2 ; JLINK.15 285.31,115.87 285.43,115.75 286.29,115.75 286.77,115.27 286.77,112.56 286,111.79 282.93,111.79 282.58,111.44 281.85,111.44 281.84,111.43 D16.1 D16.9 280.53,111.43 280.5,111.46 279.89,111.46 R107.2 278.95,111.54 277.6,111.54 v1(277.35,111.28)
  IN1 w0.14: v1(277.35,111.28) 277.6,111.54 278.12,111.54 278.97,112.39 278.97,125.99 270.19,134.77 270.19,141.87 269.82,142.23 269.55,142.23 v1(269.36,142.42)
DOCK_AUXP_R: length 13.9
  TOP w0.114: v1(270.9,142.82) 270.81,142.91 CM8.1 ; v1(270.92,144.89) 270.67,144.63 270.57,144.63 269.79,145.41 268.68,145.41 RM13.2
  BOTTOM w0.114: v1(270.9,142.82) 271.04,142.67 271.4,142.67 271.71,142.36 271.71,141.43 271.05,140.77 270.3,140.77 269.82,141.26 269.82,144.41 270.3,144.89 v1(270.92,144.89)
DOCK_AUXP_RE: length 2.9
  TOP w0.114: UM1.30 264.92,144.31 265.06,144.17 265.7,144.17 266.25,144.72 266.58,144.72 266.74,144.89 CM5.2
DOCK_CAL: length 3.7
  TOP w0.114: RM18.1 255.5,140.49 256.25,141.24 v4(256.25,141.38) 256.35,141.48 256.35,141.98 257.17,142.81 UM1.10
DOCK_CONSUMP: length 77.6
  IN1 w0.14: v1(222.97,105.49) 223.41,105.05 223.41,103.98 223.79,103.6 227.84,103.6 232.84,98.6 243.2,98.6 244.21,97.58 246.88,97.58 247.26,97.96 258.57,97.96 259.9,99.3 277.87,99.3 281.42,102.85 281.42,109.52 284.6,112.7 284.6,112.95 285.12,113.47 JLINK.21
  BOTTOM w0.114: PR108.2 v1(222.97,105.49)
DOCK_HPD_CONN: length 55.4
  TOP w0.114: UM1.11 257.29,142.31 v1(256.81,141.83) ; v4(273.88,112.83) 275.06,112.83 v1(275.2,112.7) 275.81,112.08 Q4.1 276.28,112.41 R83.1 276.84,113.44 277.1,113.19 279.25,113.19 279.64,113.57 280.02,113.57 280.16,113.43 D16.6 D16.5 282.32,113.43 v1(282.39,113.5)
  IN3 w0.114: v1(275.2,112.7) 275.2,116.25 273.93,117.52 273.93,124 263.77,134.16 260.47,134.16 257.87,136.76 257.87,140.81 256.86,141.83 v1(256.81,141.83)
  IN3 w0.14: v1(282.39,113.5) 281.88,112.99 281.88,112.34 282.25,111.97 284.6,111.97 JLINK.23
DOCK_ID:
  vias: v4(281.55,105.08)
DOCK_TX0+: length 223.8
  TOP w0.114: v1(264.71,153.83) 264.45,153.56 264.45,151.23 264.56,151.11 RM2.1
  IN3 w0.076: 101.09,105.02 101.11,105.02 101.13,105.04 101.46,105.04 101.67,105.25 101.67,105.33 v2(101.95,105.6)
  IN3 w0.114: v1(264.71,153.83) 264.4,154.14 264.4,154.41 264.09,154.72 263.17,154.72 262.59,154.15 262.59,152.91 260.78,151.1 254.2,151.1 253.71,151.58 244.11,151.58 227.89,135.37 227.89,134.18 198.32,104.6 198.32,103.4 181.19,86.28 170.95,86.28 162.9,78.23 112.71,78.23 106.28,84.66 106.28,92.34 103.8,94.82 103.8,96.24 101.63,98.41 101.23,98.41 100.87,98.77 100.87,104.88 101.01,105.02 101.09,105.02
  BOTTOM w0.114: v2(101.95,105.6) 102.16,105.81 UC1.F55
DOCK_TX0+_R: length 20.6
  TOP w0.114: CM14.1 v1(264.4,136.43) ; RM2.2 v1(265.03,152.69)
  BOTTOM w0.114: v1(265.03,152.69) 264.75,152.69 264.5,152.43 264.5,150.09 266.63,147.95 266.63,140.65 263.76,137.78 263.76,136.61 263.94,136.43 v1(264.4,136.43)
DOCK_TX0+_RE: length 3.6
  TOP w0.114: CM1.2 264.56,150.2 264.45,150.08 264.45,149.52 264.08,149.16 263.51,149.16 263.26,148.91 263.26,148.76 263.4,148.63 UM1.38
DOCK_TX0-: length 223.8
  TOP w0.114: v1(263.95,153.83) 264.22,153.56 264.22,151.23 264.1,151.11 CM2.1
  IN3 w0.076: 101.09,105.22 101.11,105.22 101.13,105.21 101.39,105.21 101.51,105.32 101.51,105.33 101.52,105.34 101.52,105.39 v2(101.31,105.6)
  IN3 w0.114: v1(263.95,153.83) 264.2,154.07 264.2,154.33 264.01,154.52 263.25,154.52 262.8,154.06 262.8,152.83 260.87,150.9 254.11,150.9 253.63,151.38 244.19,151.38 228.1,135.28 228.1,134.09 198.52,104.51 198.52,103.32 181.28,86.07 171.03,86.07 162.99,78.03 112.62,78.03 106.08,84.57 106.08,92.26 103.6,94.74 103.6,96.15 101.55,98.2 101.14,98.2 100.66,98.68 100.66,104.96 100.93,105.22 101.09,105.22
  BOTTOM w0.114: UC1.E55 101.51,105.8 v2(101.31,105.6)
DOCK_TX0-_R: length 20.6
  TOP w0.114: CM16.1 v1(263,136.43) ; RM5.2 v1(263.63,152.69)
  BOTTOM w0.114: v1(263.63,152.69) 264.01,152.69 264.27,152.43 264.27,149.99 266.4,147.86 266.4,140.74 263.54,137.88 263.54,136.61 263.35,136.43 v1(263,136.43)
DOCK_TX0-_RE: length 3.6
  TOP w0.114: UM1.39 262.9,148.55 263.04,148.69 263.04,149 263.42,149.38 263.99,149.38 264.22,149.62 264.22,150.08 264.1,150.2 CM2.2
DOCK_TX1+: length 216.8
  TOP w0.114: CM3.1 261.26,151.11 261.14,151.23 261.14,153.6 261.37,153.83 v1(261.41,153.83)
  IN3 w0.076: v2(101.92,103.77) 101.74,103.59 101.74,103.48 101.85,103.37 102.96,103.37 103.27,103.06 103.27,102.66 103.29,102.64 103.29,102.62
  IN3 w0.114: v1(261.41,153.83) 261.06,154.18 261.06,154.49 260.21,155.34 246.88,155.34 227.2,135.66 227.2,134.51 197.5,104.82 197.5,103.58 180.9,86.98 170.66,86.98 163.33,79.65 146.99,79.65 146.27,78.93 112.99,78.93 108.23,83.7 108.23,91.64 105.01,94.86 105.01,98.93 105.21,99.13 105.21,100.32 104.71,100.82 104.36,100.82 103.29,101.89 103.29,102.62
  BOTTOM w0.114: UC1.F58 102.16,104.01 v2(101.92,103.77)
DOCK_TX1+_R: length 20.6
  TOP w0.114: CM18.1 v1(261.98,136.43) ; RM8.2 v1(261.73,152.69)
  BOTTOM w0.114: v1(261.73,152.69) 261.37,152.69 261.17,152.48 261.17,149.79 258.48,147.1 258.48,141.71 261.36,138.83 261.36,137.05 v1(261.98,136.43)
DOCK_TX1+_RE: length 2.9
  TOP w0.114: CM3.2 261.35,150.2 261.14,149.99 261.14,149.78 261.77,149.16 261.77,148.71 261.9,148.58 UM1.41
DOCK_TX1-: length 216.8
  TOP w0.114: v1(260.65,153.83) 260.92,153.56 260.92,151.23 260.8,151.11 CM4.1
  IN3 w0.076: v2(101.29,103.77) 101.39,103.77 101.57,103.59 101.57,103.41 101.78,103.21 102.89,103.21 103.1,103 103.1,102.66 103.08,102.64 103.08,102.62
  IN3 w0.114: 103.08,102.62 103.08,101.81 104.27,100.62 104.63,100.62 105.01,100.24 105.01,99.22 104.8,99.01 104.8,94.77 108.03,91.55 108.03,83.61 112.91,78.73 146.36,78.73 147.07,79.45 163.41,79.45 170.74,86.77 180.99,86.77 197.71,103.49 197.71,104.74 227.4,134.43 227.4,135.57 246.96,155.14 260.12,155.14 260.86,154.4 260.86,154.04 v1(260.65,153.83)
  BOTTOM w0.114: UC1.E58 101.51,104 v2(101.29,103.77)
DOCK_TX1-_R: length 20.6
  TOP w0.114: CM20.1 v1(260.59,136.43) ; RM11.2 v1(260.33,152.69)
  BOTTOM w0.114: v1(260.33,152.69) 260.74,152.69 260.94,152.48 260.94,149.89 258.25,147.19 258.25,141.62 261.13,138.74 261.13,136.98 v1(260.59,136.43)
DOCK_TX1-_RE: length 2.9
  TOP w0.114: CM4.2 260.67,150.2 260.92,149.96 260.92,149.69 261.54,149.07 261.54,148.72 261.39,148.58 261.39,148.03 UM1.42
DOCKDP_HPD: length 335.9
  TOP w0.114: v1(256.77,143.04) 257.04,143.31 UM1.9 ; Q4.3 275.72,111.37 274.48,111.37 272.33,113.51 271.07,113.51 270.36,114.22 267.07,114.22 262.18,119.11 259.52,119.11 257.97,120.66 257.97,121.24 252.95,126.26 252.95,128.6 251.07,130.48 v1(247.26,130.48) ; v1(247.26,133.27) 228.85,133.27 210.43,114.85 v1(210.43,110.66)
  IN1 w0.14: v1(210.43,110.66) 210.14,110.37 210.14,110.37 209.44,109.67 200.42,109.67 198.3,107.54 196.95,107.54 186.08,96.68 v1(186.08,95.84)
  IN3 w0.114: v2(105.22,132.69) 104.83,133.08 104.83,134.12 104.3,134.65 101.84,134.65 101.58,134.4 100.69,134.4 100.18,134.91 99.8,134.91 98.5,136.21 87.45,136.21 86.67,136.99 79.99,136.99 76.93,133.93 76.93,130.26 v1(77.15,130.04) ; v1(256.77,143.04) 255.9,142.17 255.9,140.2 248.96,133.27 v1(247.26,133.27)
  BOTTOM w0.114: v1(77.15,130.04) 77.16,130.03 77.16,129.03 76.86,128.73 76.86,120.83 77.77,119.92 77.77,119.31 81.01,116.08 81.01,114.75 82.44,113.32 82.44,88.64 90.59,80.5 101.61,80.5 102.02,80.91 103.02,80.91 103.56,80.37 104.27,80.37 105.23,81.33 v4(105.91,81.33) 107.31,81.33 108.57,80.06 126.54,80.06 127.79,81.31 160.24,81.31 160.76,81.83 166.88,81.83 175.17,90.11 175.17,92.09 177.04,93.96 181.73,93.96 182.86,92.83 184.63,92.83 185.54,93.74 185.54,95.3 v1(186.08,95.84) ; UC1.L9 104.92,132.39 v2(105.22,132.69) ; v1(247.26,133.27) v1(247.26,130.48)
DP1201_OC: length 3.1
  TOP w0.114: RM32.2 RM33.1 259.4,150.02 UM1.46
DP_DDC_CLK: length 15.5
  TOP w0.076: v2(105.22,130.15) 105.45,130.38 105.6,130.38 105.82,130.61 105.82,131.1 105.77,131.15 105.77,134.94 105.47,135.24 105.47,135.28 105.46,135.29
  TOP w0.114: RC1.2 101.33,142.45 101.33,142.25 103.94,139.63 103.94,137.19 105.24,135.89 105.24,135.51 105.46,135.29
  BOTTOM w0.114: v2(105.22,130.15) 104.86,129.78 UC1.L13
DP_DDC_DAT: length 15.4
  TOP w0.076: 105.3,135.13 105.31,135.12 105.36,135.12 105.61,134.87 105.61,131.08 105.66,131.03 105.66,130.68 105.53,130.55 105.45,130.55 v2(105.22,130.78)
  TOP w0.114: RC2.2 101.02,142.37 101.02,142.08 101.77,141.33 101.86,141.33 103.72,139.48 103.72,137.09 105.01,135.8 105.01,135.42 105.3,135.13
  BOTTOM w0.114: UC1.L12 104.87,130.44 v2(105.22,130.78)
DP_RE_AUXN: length 3.1
  TOP w0.114: RM16.1 266.73,141.89 266.57,142.05 266.32,142.05 265.4,142.97 265.3,142.97 265.14,142.81 UM1.27
DP_RE_AUXP: length 3.1
  TOP w0.114: UM1.28 265.19,143.31 265.3,143.2 265.49,143.2 266.41,142.28 266.58,142.28 266.73,142.43 RM17.1
DP_RE_DP0N: length 2.9
  TOP w0.114: CM15.1 263.41,138.92 263.58,139.08 263.58,139.47 263,140.04 263,140.45 262.9,140.56 UM1.22
DP_RE_DP0P: length 2.9
  TOP w0.114: CM13.1 264.01,138.92 263.8,139.12 263.8,139.56 v1(263.5,139.87) 263.23,140.13 263.23,140.53 263.4,140.69 UM1.23
DP_RE_DP1N: length 2.8
  TOP w0.114: CM19.1 260.93,138.92 261.17,139.16 261.17,139.67 261.53,140.04 261.53,140.54 261.4,140.67 UM1.19
DP_RE_DP1P: length 2.8
  TOP w0.114: CM17.1 261.64,138.92 261.4,139.16 261.4,139.58 v1(261.64,139.82) 261.76,139.94 261.76,140.53 261.9,140.66 UM1.20
DRVON: length 95.7
  TOP w0.254: v1(60,60.23) v4(60,56.47) 60,53.56 v1(64.86,48.7) ; v1(83.4,49.23) 83.79,49.63 PU403.3
  IN1 w0.254: v1(64.86,48.7) 82.86,48.7 v1(83.4,49.23) ; v1(60,60.23) 59.62,60.23 59.17,60.68 59.17,61.61 62.36,64.8 64.12,64.8 65.16,65.84 v1(65.16,69.04)
  IN2 w0.254: v1(65.16,69.04) 61.59,69.04 59.58,71.05 59.58,72 59,72.58 59,77.59 60.17,81.77 60.66,85.43 66.28,91.04 66.28,95.16 69.2,98.08 74.81,98.08 v1(76.61,99.88)
  BOTTOM w0.229: 61.2,59.96 PU401.35
  BOTTOM w0.254: 61.2,59.96 60.27,59.96 v1(60,60.23) ; PU402.3 64.95,69.26 v1(65.16,69.04) ; v1(76.61,99.88) 76.6,99.9 PU404.3
EC_AGND: length 5.5
  TOP w0.203: v4(195.23,121.04) 194.96,120.77 UE1.75
  TOP w0.254: LE2.1 197.64,120.81 CE3.2 CE2.2 195.64,120.63 v4(195.23,121.04)
EC_DPWROK: length 82.8
  TOP w0.114: v1(192.13,129.59) 192.55,129.17 UE1.96 ; RC286.1 132.26,153.93 132.29,153.93 RC353.2 132.7,153.45 133.43,152.71 v4(134.02,152.71) 134.02,151.96 133.46,151.39 133.46,151.37 v1(133.26,151.16)
  IN3 w0.114: v1(133.26,151.16) 136.09,151.16 140.19,155.27 146.74,155.27 147.29,155.82 153.48,155.82 154.08,156.42 170.07,156.42 171.16,155.33 171.16,154.33 172.61,152.88 175,152.88 190.49,137.38 190.49,134.91 192.13,133.27 v1(192.13,129.59)
EC_DPWROK_R: length 64.6
  TOP w0.114: RC352.2 CC529.2 140.15,143.5 141.85,145.2 v4(141.85,145.21) 142.42,145.77 v1(142.42,146.86) ; v1(141.47,149.57) 141.03,149.13 139.55,149.13 139.24,149.45 139.24,149.54 134.61,154.17 132.94,154.17 RC286.2
  BOTTOM w0.076: UC1.BB20 121.66,126.34 122.45,126.34 122.98,126.87 123.93,126.87 124.62,127.57 126.07,127.57
  BOTTOM w0.114: v1(141.47,149.57) 142.42,148.63 v1(142.42,146.86) 142.42,138.52 142.79,138.15 144.77,138.15 145.97,136.95 145.97,132.22 141.31,127.57 126.07,127.57
EC_FAN_PWM: length 196.3
  TOP w0.114: UE1.31 176.93,117.17 176.73,116.96 176.73,115.96 v1(176.59,115.83) 175.85,115.08 RE8.1
  IN1 w0.14: v1(51.2,49.55) 51.31,49.67 62.07,49.67 64.32,51.92 73.46,51.92 75.79,54.24 75.79,58.69 88.13,71.04 88.13,75.14 87.5,75.77 v1(87.5,77.9)
  IN3 w0.114: v1(176.59,115.83) 177.03,115.39 177.03,114.75 176.69,114.42 176.69,112.53 176.18,112.01 176.18,94.96 180.56,90.58 v1(182.44,90.58)
  BOTTOM w0.114: v1(87.5,77.9) 87.72,78.12 v4(89.91,78.12) 94.08,78.12 96.29,75.92 102.03,75.92 103.68,74.26 106.71,74.26 109.41,76.96 127.71,76.96 129.24,78.5 160.71,78.5 161.64,79.43 167.62,79.43 174.18,85.99 181.17,85.99 183.25,88.07 183.25,89.76 v1(182.44,90.58) ; JFAN.5 v1(51.2,49.55)
EC_FAN_SPEED: length 203.8
  TOP w0.114: RPE3.7 179.82,111.79 179.94,111.67 v1(181.25,111.67) 184.4,111.67 184.78,112.05 184.78,113.97 185.06,114.24 UE1.47
  IN1 w0.14: v1(88,77.52) 88,75.64 88.4,75.25 88.4,70.93 76.05,58.58 76.05,54.13 73.57,51.65 64.43,51.65 61.34,48.56 49.69,48.56 v1(48.7,49.55)
  IN3 w0.114: v1(183.18,91.24) 183.18,91.56 183.76,92.14 183.97,92.14 185.19,93.36 185.4,93.58 185.4,95.12 184.93,95.59 179.61,95.59 178.58,96.63 178.58,98.32 179.87,99.61 179.87,101.19 179.67,101.39 179.67,105.58 180.53,106.44 180.53,109.27 181.32,110.05 181.32,111.6 v1(181.25,111.67)
  BOTTOM w0.114: v1(183.18,91.24) 183.49,90.93 183.49,87.97 181.27,85.74 174.28,85.74 167.72,79.19 161.74,79.19 160.81,78.26 129.34,78.26 127.81,76.72 109.51,76.72 106.81,74.02 103.58,74.02 101.93,75.67 96.19,75.67 94.22,77.64 88.13,77.64 v1(88,77.52) ; JFAN.3 v1(48.7,49.55)
EC_GS_ON#: length 26
  TOP w0.114: UE1.106 188.26,129 187.81,128.56 183.19,128.56 v1(183.13,128.5) ; v1(180.46,117.14) 179.57,117.14 177.01,114.57 v4(176.37,114.57) 176.03,114.23 175.71,114.23 175.68,114.21 RG4.1
  BOTTOM w0.114: v1(180.46,117.14) 180.46,118.92 182.33,120.79 182.33,127.06 183.13,127.86 v1(183.13,128.5)
EC_MUTE#: length 89.7
  TOP w0.114: RE31.1 RE32.1 194.55,133.26 193.9,132.61 191.53,132.61 190.66,131.73 UE1.100 190.66,129.39 188.2,126.93 v1(188.2,124.87)
  TOP w0.203: v1(189.08,74.96) 189.08,86.47 192.8,90.18 v4(192.8,98.62) 198.48,104.3 198.48,108.24 v1(198.23,108.49)
  IN1 w0.203: v1(193.02,108.74) 193.28,108.49 v1(198.23,108.49)
  IN3 w0.114: v1(193.02,108.74) 192.54,109.23 192.54,117.67 191.12,119.09 189.05,119.09 188.2,119.95 v1(188.2,124.87)
  BOTTOM w0.203: DA5.1 179.12,71.55 182.54,74.96 v1(189.08,74.96)
EC_ON: length 85.8
  TOP w0.114: UE1.83 194.33,123.97 195.11,124.75 196.12,124.75 RE39.1 197.05,124.58 200.23,124.58 v1(200.27,124.62)
  TOP w0.254: v1(195.27,154.83) 197.64,154.83 200.27,152.19 205.07,152.19 209.26,148 217.77,148 220.13,150.36 v4(220.13,158.54) 220.13,164.3 220.43,164.59 v1(220.43,164.83)
  IN3 w0.114: v1(200.27,124.62) 200.58,124.93 200.58,127.99 199.82,128.75 199.82,136.41 193.41,142.82 193.41,144.4 195.47,146.45 195.47,150.98 195.35,151.1 195.35,154.74 v1(195.27,154.83)
  BOTTOM w0.254: PR206.1 220.33,164.93 v1(220.43,164.83)
EC_ON2: length 153.5
  TOP w0.114: v1(173.68,117.62) 173.91,117.85 RE40.1
  TOP w0.254: v1(185.76,174.36) 186.08,174.05 PD801.1
  IN1 w0.14: v1(203.07,140.06) 199.21,140.06 198.27,139.11 189.1,139.11 185.78,142.43 182.25,142.43 v1(179.93,140.1)
  IN3 w0.114: v1(185.76,174.36) 187.09,175.69 193.67,175.69 194.16,175.2 194.16,159.45 197.22,156.38 197.22,154.57 203.07,148.73 v1(203.07,140.06) ; v1(173.68,117.62) 173.12,118.18 173.12,119.5 173.55,119.93 173.55,122.65 174.16,123.26 174.16,126.72 174.41,126.97 174.41,134.59 v1(179.93,140.1)
  IN3 w0.254: v1(147.77,167.13) 148.53,167.13 150.61,169.21 152.77,169.21 153.66,168.32 163.57,168.32 165.09,166.8 170.05,166.8 171.95,164.89 177.03,164.89 178.3,166.16 178.3,167.94 179.06,168.7 181.81,168.7 182.24,169.13 182.24,173.38 182.9,174.04 182.9,175.41 183.33,175.84 184.9,175.84 185.16,175.59 185.16,174.97 v1(185.76,174.36)
  BOTTOM w0.254: PR801.1 185.09,174.56 185.57,174.56 v1(185.76,174.36) ; PR701.1 147.36,166.72 v1(147.77,167.13)
EC_ON2_R: length 2.8
  TOP w0.114: RE40.2 175.29,117.91 175.98,117.91 v4(176.27,118.21) 176.61,118.21 176.76,118.37 UE1.28
EC_RSMRST#: length 118.8
  TOP w0.114: UE1.93 192.56,127.97 192.27,127.68 190.65,127.68 188.71,125.75 188.71,124.77 188.38,124.44 186.89,124.44 v1(186.16,125.16) ; v4(140.24,140.93) 139.88,140.93 139.24,141.54 RC352.1 138.32,141.91 RC27.2 137.85,141.51 137.11,141.51 v1(137.06,141.55)
  IN1 w0.14: v1(174.94,142.54) 174.94,149.02 170.46,153.5 163.89,153.5 162.17,155.23 157.72,155.23 157.02,154.53 153.49,154.53 152.79,155.23 149.84,155.23 148.33,153.72 148.2,153.72 142.69,148.2 141.86,148.2 140.25,146.58 140.25,145.64 137.01,142.41 137.01,141.6 v1(137.06,141.55)
  IN3 w0.114: v1(186.16,125.16) 186.7,125.69 186.7,126.58 185.95,127.33 185.95,131.45 184,133.39 184,135.67 180.94,138.73 180.94,139.72 178.12,142.54 v1(174.94,142.54)
  BOTTOM w0.076: 125.47,128.56 125,128.56 123.7,127.25 121.76,127.25 121.57,127.06 121.31,127.06 121.19,127.11 121.05,127.11 120.82,127.05 120.7,127.05 120.5,127.12 120.38,127.22 120.27,127.33 UC1.AY17
  BOTTOM w0.114: 125.47,128.56 128.38,128.56 129.76,129.95 131.3,129.95 136.98,135.62 136.98,139.7 137.06,139.79 v1(137.06,141.55)
EC_RX: length 102.5
  TOP w0.114: UE1.16 179.59,123.17 180.72,122.04 181.49,122.04 182.43,121.09 190.35,121.09 v1(190.62,120.82) ; R90.2 v4(257.03,151.23) 257.03,150.58 v1(256.14,149.69)
  BOTTOM w0.114: v1(256.14,149.69) 255.86,149.41 255.86,148.09 255.08,147.31 251.25,147.31 250.22,148.34 236.45,148.34 229.84,141.73 210.81,141.73 207.91,138.83 201.98,138.83 196.8,133.65 193.63,133.65 190.83,130.85 190.83,129.26 189.6,128.04 189.6,126.59 189.89,126.3 189.89,121.93 190.62,121.2 v1(190.62,120.82)
EC_SCI#: length 280.4
  TOP w0.114: v1(105.65,149.89) 106.33,149.89 108.04,151.6 109.14,151.6 109.15,151.6 112.73,151.6 114.69,149.64 122.11,149.64 123.18,148.57 124.66,148.57 125.11,149.02 125.11,149.27 125.32,149.47 126.26,149.47 126.47,149.26 RPC22.2 ; UE1.23 179.06,120.37 v1(179.19,120.5)
  IN3 w0.114: v1(105.56,139.21) 106.28,139.94 106.28,143.16 105.52,143.92 105.52,147.1 105.9,147.48 105.9,149.64 v1(105.65,149.89) ; v1(182.87,93.84) 179.05,93.84 177.47,95.42 177.47,109.75 178.5,110.78 178.5,119.88 179.12,120.5 v1(179.19,120.5)
  BOTTOM w0.114: UC1.M1 104.95,139.1 105.06,139.21 v1(105.56,139.21) ; v1(105.65,149.89) 102.46,153.08 v4(101.72,153.08) 98.8,153.08 96,155.88 83.81,155.88 82.92,154.99 82.92,151.47 76.76,145.31 76.76,131.77 77.83,130.7 77.83,122.86 77.34,122.38 77.34,121.03 78.25,120.12 78.25,119.51 81.49,116.28 81.49,114.95 82.93,113.52 82.93,88.88 90.83,80.98 100.57,80.98 102.23,82.64 106.68,82.64 108.75,80.56 126.35,80.56 127.73,81.94 159.91,81.94 160.29,82.32 166.65,82.32 174.59,90.26 174.59,92.24 176.8,94.44 182.27,94.44 v1(182.87,93.84)
EC_SMB_CK1: length 107
  TOP w0.203: UE1.115 184.66,132
  TOP w0.254: 184.66,132 184.79,132.14 184.79,136.58 RPE5.8 184.75,136.93 185.53,137.7 IT1.1 186.48,137.51 186.48,136.16 v1(186.53,136.11)
  IN1 w0.254: v1(213.07,136.71) 212.86,136.93 202.61,136.93 199.51,133.83 188.05,133.83 187.27,134.62 187.27,135.48 186.68,136.06 186.58,136.06 v1(186.53,136.11)
  IN3 w0.254: v1(247.43,126.27) 247.43,126.37 246.93,126.87 245.61,126.87 244.48,125.74 224.32,125.74 212.64,114.06 212.64,113.1 v1(212.94,112.81)
  BOTTOM w0.254: PR121.1 213.66,112.95 213.54,112.83 212.96,112.83 v1(212.94,112.81) 212.81,112.81 212.45,113.17 212.45,128.91 212.9,129.35 212.9,136.54 v1(213.07,136.71) ; PR15.2 248.14,126.27 v1(247.43,126.27)
EC_SMB_CK3: length 400.3
  TOP w0.114: v1(183.76,108) 183.76,108.82 QV13.6 ; RM29.1 253.48,145.97 v1(252.85,146.6) ; QC2.1 102.5,149.4 102.61,149.51 102.61,150.63 100.92,152.32 v1(100.07,152.32) ; U1.10 47.25,126.15 48.38,125.02 v1(48.38,123.98) ; UE1.94 192.28,128.37 v1(192.13,128.22) ; RPE5.5 182.92,136.62 v1(182.59,136.29)
  IN1 w0.14: v1(183.76,108) 184.71,107.04 184.71,105.41 179.71,100.41 179.71,99.85 178.82,98.96 178.82,93.38 180.35,91.85 180.69,91.85 v1(181.17,91.38) ; v1(100.07,152.32) 99.43,152.95 88.76,152.95 88.26,153.46 86.98,153.46 v1(86.57,153.04) ; v1(182.49,128.5) 182.99,128.99 183.45,128.99 183.91,128.54 191.81,128.54 v1(192.13,128.22)
  IN3 w0.114: v1(72.48,129.88) 72.29,130.08 72.29,133.16 80.6,141.47 80.6,148.98 84.67,153.04 v1(86.57,153.04)
  BOTTOM w0.114: v1(252.85,146.6) 252.34,146.1 251.83,146.1 251.49,146.44 236.04,146.44 230.46,140.86 211.17,140.86 208.27,137.97 202.43,137.97 192.68,128.22 v1(192.13,128.22) 192.05,128.22 191.69,127.86 191.69,121.25 194.32,118.63 194.32,105.02 186.76,97.46 186.76,93.01 185.48,91.72 181.52,91.72 v1(181.17,91.38) 180.66,91.88 177.68,91.88 176.77,90.97 176.77,89.45 167.54,80.23 161.42,80.23 160.86,79.67 128.41,79.67 127.2,78.46 106.3,78.46 105.64,77.8 102.38,77.8 101.75,77.17 96.81,77.17 94.6,79.38 90.09,79.38 81.34,88.13 81.34,112.86 79.9,114.3 79.9,115.62 74.39,121.13 74.39,124.68 75.14,125.43 75.14,128.16 73.42,129.88 v1(72.48,129.88) 71.15,129.88 68.47,127.2 59.79,127.2 57.7,125.11 51.07,125.11 49.94,123.98 v1(48.38,123.98) ; QV2.6 85.84,153.08 85.97,152.95 86.48,152.95 v1(86.57,153.04) ; v1(182.59,136.29) 182.92,136.62 183.54,136.62 184.27,135.89 184.27,134.3 182.69,132.72 182.69,128.94 182.49,128.74 v1(182.49,128.5)
EC_SMB_DA1: length 115.2
  TOP w0.203: 184.26,131.82 UE1.116 ; v1(181.89,136.36) 181.6,136.64 IT2.1 182.39,137.74 182.94,137.19 184.13,137.19 184.25,137.07 RPE5.7
  TOP w0.254: RPE5.7 184.25,135.92 184.39,135.79 184.39,132.44 184.26,132.31 184.26,131.82
  IN1 w0.254: v1(181.89,136.36) 182.61,137.08 186.38,137.08 187.36,136.09 187.36,135.92 187.65,135.64 187.65,134.77 188.21,134.21 199.36,134.21 202.45,137.31 212.92,137.31 v1(213.07,137.46)
  IN3 w0.254: v1(246.73,126.29) 245.64,126.29 244.71,125.36 224.53,125.36 213.1,113.92 213.1,113.43 213.53,113 213.53,112.62 213.08,112.16 v1(212.95,112.16)
  BOTTOM w0.254: PR14.2 247.47,127.03 v1(246.73,126.29) ; v1(213.07,137.46) 212.52,136.91 212.52,129.51 212,129 212,113.01 212.84,112.16 v1(212.95,112.16) 213.05,112.06 PR120.1
EC_SMB_DA3: length 405.6
  TOP w0.114: QV13.3 185.92,107.84 v1(185.92,108) ; QC2.4 103.25,148.1 102.85,148.49 102.85,150.73 100.83,152.76 99.87,152.76 v1(99.43,152.32) ; U1.9 47.24,125.65 47.97,124.92 47.97,124.21 v1(47.75,123.98) ; v1(192.14,128.95) 192.33,128.77 UE1.95 ; v1(182.54,135.56) 183.05,136.06 183.63,136.06 183.75,136.18 RPE5.6 ; v1(252.09,146.6) 253.61,145.08 RM30.1
  IN1 w0.14: v1(181.84,128.5) 181.84,128.55 182.5,129.21 182.5,129.5 182.91,129.91 183.42,129.91 184.38,128.95 v1(192.14,128.95) ; v1(181.22,92.12) 180.46,92.12 179.09,93.49 179.09,98.85 179.98,99.74 179.98,100.3 184.98,105.3 184.98,107.06 v1(185.92,108) ; v1(87.22,153.01) 87.78,152.45 99.3,152.45 v1(99.43,152.32)
  IN3 w0.114: v1(87.22,153.01) 86.59,152.38 84.5,152.38 80.84,148.72 80.84,141.37 72.64,133.17 72.64,130.62 v1(72.88,130.38)
  BOTTOM w0.114: v1(252.09,146.6) 252.01,146.69 250.99,146.69 250.16,147.52 236.77,147.52 230.36,141.1 211.07,141.1 208.17,138.21 202.24,138.21 192.98,128.95 v1(192.14,128.95) 191.45,128.26 191.45,121.15 194.08,118.53 194.08,105.12 186.52,97.56 186.52,93.49 184.99,91.97 181.38,91.97 v1(181.22,92.12) 177.58,92.12 176.52,91.07 176.52,89.55 167.44,80.47 161.32,80.47 160.76,79.91 128.31,79.91 127.1,78.7 106.2,78.7 105.54,78.04 102.28,78.04 101.65,77.41 96.91,77.41 94.7,79.62 90.19,79.62 81.58,88.23 81.58,112.96 80.14,114.4 80.14,115.72 74.63,121.23 74.63,124.58 75.38,125.33 75.38,128.26 73.52,130.12 73.13,130.12 v1(72.88,130.38) 71.26,130.38 68.32,127.44 59.64,127.44 57.61,125.41 50.98,125.41 49.84,124.26 48.98,124.26 48.82,124.42 48.18,124.42 v1(47.75,123.98) ; v1(87.22,153.01) 86.78,152.57 86.28,152.57 86.15,152.7 84.83,152.7 84.54,152.42 QV2.3 ; v1(181.84,128.5) 182.45,129.1 182.45,132.82 184.03,134.4 184.03,135.73 183.8,135.96 183.08,135.96 182.67,135.56 v1(182.54,135.56)
EC_SMCA: length 7.9
  TOP w0.254: PD7.3 251.39,122 251.14,122.26 v1(249.97,122.26) 249.23,122.26 v4(248.89,121.92)
  BOTTOM w0.254: v1(249.97,122.26) 249.97,122.35 249.73,122.59 249.25,122.59 249.25,126.07 PR15.1
EC_SMDA: length 9.2
  TOP w0.254: v4(248.84,123.64) 249.34,123.13 v1(249.98,123.13) 250.25,122.87 250.93,122.87 PD7.2
  BOTTOM w0.254: v1(249.98,123.13) 250.57,122.55 JBATT1.4 250.7,124.42 249.84,125.28 249.84,126.5 249.31,127.03 PR14.1
EC_TX: length 99.5
  TOP w0.114: UE1.17 179.65,122.77 180.62,121.79 181.39,121.79 182.33,120.85 189.96,120.85 v1(190.62,120.19) ; R89.2 254.41,150.2 253.92,149.7 v1(253.92,149.68)
  BOTTOM w0.114: v1(190.62,120.19) 189.65,121.16 189.65,126.18 189.35,126.48 189.35,128.14 190.59,129.38 190.59,130.95 193.53,133.89 196.7,133.89 202.18,139.37 v4(204.84,139.37) 207.69,139.37 210.29,141.97 229.74,141.97 236.5,148.73 250.17,148.73 251.35,147.55 253.17,147.55 253.55,147.93 253.55,149.31 v1(253.92,149.68)
EC_TX_R: length 7.4
  TOP w0.114: v1(253.89,152.12) 254.04,151.96 254.66,151.96 255.05,152.36 R91.1 R151.2 R89.1
  BOTTOM w0.114: v1(253.89,152.12) 253.98,152.21 253.98,153.56 253.2,154.34 JWLBT.64
EC_WAKE#: length 171.5
  TOP w0.114: UE1.2 178.88,128.77 179.05,128.94 179.05,129.45 177.16,131.34 177.16,133.58 175.89,134.84 175.89,138.71 v1(176.17,138.98)
  IN1 w0.14: v1(121.88,154.85) 122.02,154.71 126.18,154.71 126.99,153.89 128.08,153.89 128.73,153.25 131.81,153.25 132.83,152.23 135.65,152.23 138.7,149.19 139.85,149.19 141.85,151.19 141.85,153.72 143.74,155.61 147.89,155.61 148.29,156.01 153.04,156.01 153.61,156.59 170.38,156.59 175.75,151.21 175.75,144.57 176.77,143.56 176.77,142.76 176.17,142.16 v1(176.17,138.98) ; v1(76.18,151.16) 76.69,150.65 83.54,150.65 84.02,150.18 85.36,150.18 86.88,151.7 100.18,151.7 101.34,150.54 101.34,150.07 v1(101.47,149.94) 101.18,149.65 100.86,149.65 99.61,148.4 94.8,148.4 92.25,145.85 92.25,142.29 88.49,138.53 v1(88.49,138.53)
  BOTTOM w0.114: v1(88.49,138.53) 88.19,138.23 88.19,136.28 88.85,135.62 89.39,135.62 89.89,135.12 90.54,135.12 90.92,134.73 90.92,134.14 91.23,133.83 ; RC40.1 91.23,133.83 ; 91.23,133.83 91.04,133.83 90.74,133.53 RPC26.3 ; RV140.1 76,151.16 v1(76.18,151.16) ; v1(121.88,154.85) 119.21,157.51 115.78,157.51 113.19,154.92 109.15,154.92 v4(107.82,153.59) 106.8,152.57 106.8,149.91 106.32,149.43 101.98,149.43 v1(101.47,149.94)
EC_WAKE#_L: length 8.1
  BOTTOM w0.076: 97.38,135.05 98.21,134.22 UC1.A6
  BOTTOM w0.114: 97.38,135.05 92.34,135.05 92.03,134.74 RC40.2
EC_WLAN_WAKE#: length 132.3
  TOP w0.114: v1(189.98,120.19) 189.56,120.61 187.92,120.61 187.12,119.82 182.68,119.82 181.19,121.31 180.42,121.31 179.92,121.81 179.45,121.81 v1(179.18,122.08) 179.07,121.97 UE1.19 ; RPE1.5 v1(176.13,119.93)
  IN1 w0.14: v1(179.18,122.08) 179.07,121.97 176.15,121.97 175.62,121.44 175.62,120.44 v1(176.13,119.93)
  IN3 w0.114: v1(197.17,153.26) 197.6,152.84 197.6,147.12 v1(200.65,144.06)
  BOTTOM w0.114: v1(189.98,120.19) 189.22,120.95 189.22,124.68 188.33,125.57 188.33,130.09 190.3,132.05 190.3,136.76 192.69,139.15 198.05,139.15 200.65,141.75 v1(200.65,144.06) ; JWLBT.55 255.45,161.88 255.39,161.82 255.39,160.94 254.74,160.29 247.67,160.29 v4(247.26,160.7) 243.26,160.7 229.51,146.95 208.02,146.95 203.23,151.74 200.73,151.74 199.51,152.95 197.48,152.95 v1(197.17,153.26)
EDP_COMP: length 1.5
  TOP w0.508: RC344.2 100.94,107.78 v2(101.29,107.43)
  BOTTOM w0.254: UC1.E52 v2(101.29,107.43)
EN_1.8VSP: length 2.3
  TOP w0.254: PR802.2 187.29,174.62 v1(187.23,174.62) 186.81,174.62 PD801.2
  vias: v4(186.52,174.1)
ENBKL: length 153.6
  TOP w0.114: v2(109.62,141.7) 109.62,141.47 108.95,140.8 108.95,138.36 107.56,136.98 107.56,135.22 107.88,134.91 107.88,132.93 107.61,132.66 107.61,131.08 107.31,130.78 v2(107.23,130.78) 106.95,131.06 106.47,131.06 RC209.1 ; UE1.81 194.63,123.17 v1(195.1,123.64)
  IN3 w0.114: v1(195.1,123.64) 195.1,125.21 198.38,128.49 198.38,135.81 191.79,142.4 191.79,150.06 180.67,161.17 161.71,161.17 161.14,160.6 145.93,160.6 144.9,159.58 135.19,159.58 134.42,158.8 131.14,158.8 130.37,159.58 126.77,159.58 125.53,158.34 119.3,158.34 115.09,154.13 109.25,154.13 107.62,152.5 107.62,147.26 108.98,145.89 108.98,142.79 108.83,142.64 107.99,142.64 107.62,142.27 107.62,141.92 108.1,141.45 109.37,141.45 v2(109.62,141.7)
  BOTTOM w0.076: UC1.R12 v2(107.23,130.78)
EXT_MIC_A: length 3.6
  TOP w0.203: UA1.30 183.8,54.48 183.21,54.48 181.92,53.19 RA14.1
EXT_MIC_B: length 2.3
  TOP w0.203: UA1.31 184.78,54.61 183.75,53.57 RA15.1
EXT_PWR_GATE#: length 2.5
  TOP w0.114: v2(115.38,131.2) 115.38,131.5 114.98,131.9 114.98,132.28 T61.1
  BOTTOM w0.076: v2(115.38,131.2) 115.05,131.54 UC1.AM10
F1_LED#: length 207.6
  TOP w0.114: v1(190.44,102.81) 189.47,102.81 188.22,101.56 187.28,101.56 186.42,100.7 v4(186.42,100.5) 186.02,100.1 186.02,97.76 184.58,96.32 182.79,96.32 178.57,92.1 178.57,87.59 167.8,76.82 163.91,76.82 160.2,73.11 JKB.27
  IN3 w0.114: v1(112.08,149.73) 111.66,150.15 111.66,150.56 112.4,151.3 113.98,151.3 119.8,157.13 126.03,157.13 126.59,157.69 130.19,157.69 130.34,157.84 134.82,157.84 135.46,158.48 145.17,158.48 146.33,159.63 161.54,159.63 162.11,160.21 180.27,160.21 189.72,150.76 189.72,143.79 197.89,135.61 197.89,128.69 194.42,125.21 194.42,123.3 195.55,122.16 195.55,112.8 196.34,112.01 196.34,109.35 190.44,103.45 v1(190.44,102.81)
  BOTTOM w0.076: UC1.AC2 110.92,136.28 111.15,136.51 111.21,136.72 111.21,136.8 111.15,136.92 111.15,137.4 111.15,137.41 111.15,139.01 110.91,139.24 110.91,139.97
  BOTTOM w0.114: 110.91,139.97 110.91,141.52 111.63,142.24 111.63,147.11 111.29,147.45 111.29,148.93 v1(112.08,149.73) 111.24,150.57 RPC8.3
F4_LED#: length 206.7
  TOP w0.114: v1(190,102.35) 189.35,102.35 188.32,101.32 187.38,101.32 186.81,100.75 186.81,98.98 v4(186.56,98.73) 186.5,98.67 186.5,97.9 184.68,96.08 182.89,96.08 178.81,92 178.81,87.49 167.9,76.58 164.01,76.58 160.7,73.27 JKB.28
  IN3 w0.114: v1(190,102.35) 190,103.36 196.09,109.45 196.09,111.91 195.31,112.7 195.31,122.06 194.17,123.2 194.17,125.31 196.95,128.09 196.95,129.98 197.65,130.67 197.65,135.51 189.48,143.69 189.48,150.66 180.17,159.96 162.21,159.96 161.64,159.39 146.43,159.39 145.27,158.24 135.56,158.24 134.92,157.6 130.44,157.6 130.29,157.45 126.69,157.45 126.13,156.89 119.91,156.89 114.06,151.05 112.77,151.05 v1(112.1,150.37)
  BOTTOM w0.076: UC1.AD3 111.85,136.03 111.85,136.52 112.01,136.93 112.01,137.36 111.86,137.51 111.86,137.76 111.84,137.79 111.84,138.21 112.22,138.59
  BOTTOM w0.114: RPC8.2 111.74,150.73 v1(112.1,150.37) 112.53,149.94 112.53,149.36 111.53,148.36 111.53,147.72 112.01,147.24 112.72,147.24 112.95,147.01 112.95,141.7 112.64,141.39 112.64,139.01 112.22,138.59
FAN_ID: length 214.4
  TOP w0.114: UE1.70 192.52,118.77 192.2,119.09 183.81,119.09 v1(183.12,118.4) ; RPE2.6 183.24,113.06 v1(184,113.82)
  IN1 w0.14: v1(88.51,77.14) 88.51,75.51 88.66,75.36 88.66,70.82 76.32,58.47 76.32,54.02 73.68,51.38 64.54,51.38 61.33,48.18 47.57,48.18 v1(46.2,49.55)
  IN3 w0.114: v1(184,113.82) 184.64,113.19 184.64,110.1 184.64,110.1 183.01,108.47 183.01,106.79 183.93,105.87 183.93,102.17 182.27,100.5 182.27,96.25 182.69,95.84 185.03,95.84 185.65,95.22 185.65,93.48 183.82,91.65 v1(183.82,91.26)
  BOTTOM w0.114: v1(183.82,91.26) 184,91.07 184,88.14 181.37,85.5 174.38,85.5 167.82,78.94 161.84,78.94 160.91,78.02 129.47,78.02 127.93,76.48 109.61,76.48 106.91,73.78 103.48,73.78 101.83,75.43 96.09,75.43 94.39,77.14 v1(88.51,77.14) ; v1(183.12,118.4) 183.62,117.89 183.62,114.21 v1(184,113.82) ; JFAN.1 v1(46.2,49.55)
FB_1.35V: length 2.8
  TOP w0.254: PR305.2 182.56,166.67 PR307.1 ; PR305.2 183.26,166.66 v4(183.48,166.45) ; PR305.2 181.75,166.66 PC314.2
FBA_BA0: length 81.2
  TOP w0.102: UV6.M2 18.88,139.53 18.88,139 18.83,138.95 18.83,138.72 18.14,138.03 v1(18.14,137.28) ; v1(18.16,157.22) 18.16,158.19 18.9,158.94 18.9,159.49 19.09,159.68 UV7.M2
  IN1 w0.084: 45.51,151.39 45.51,150.88 45.63,150.75 46.34,150.75 46.5,150.9 46.5,151.34 46.64,151.49 48.99,151.49 49.09,151.39 49.09,151.18 48.89,150.98 v5(48.87,150.98)
  IN1 w0.216: 45.51,151.39 45.51,151.81 44.76,152.56 42.58,152.56 42.49,152.47 41.22,152.47 41.05,152.31 40.52,152.31 40.3,152.53 36.42,152.53 36.23,152.34 36.23,151.77 36.02,151.56 35.45,151.56 34.76,150.87 33.54,150.87 32.04,149.37 32.04,148.16 31.65,147.76 31.01,147.76 30.86,147.61 30.86,146.99 30.71,146.84 30.41,146.84 30.25,146.99 30.25,147.61 30.1,147.76 29.77,147.76 29.61,147.61 29.61,146.96 29.46,146.81 29.13,146.81 28.97,146.96 28.97,147.61 28.82,147.76 20.53,147.76 20.1,147.34 19.55,147.34 19.31,147.1 19.31,145.95 19.46,145.8 19.95,145.8 20.1,145.65 20.1,145.33 19.95,145.18 18.67,145.18 18.54,145.3 18.54,145.64 18.77,145.87 18.77,146.06 18.6,146.23 18.6,146.56 18.77,146.74 18.77,147.21 18.65,147.34 18.12,147.34 17.94,147.16 v1(17.94,146.84)
  IN3 w0.114: v1(18.14,137.28) 18.14,137.48 18.13,137.5 18.13,137.99 18.04,138.08 18.04,138.83 16.69,140.18 16.69,141.26 17.85,142.42 17.85,144.96 18.52,145.63 18.52,146.26 v1(17.94,146.84) 17.44,147.34 17.44,151.18 17.25,151.37 17.25,152.11 16.75,152.62 16.75,153.97 16.79,154.02 16.79,155.61 18.16,156.98 v1(18.16,157.22)
  BOTTOM w0.102: v1(18.14,137.28) 18.14,137.05 18.91,136.28 18.91,135.56 UV5.M2 ; UV3.J16 49.13,151.41 49.13,151.22 48.89,150.98 v5(48.87,150.98) ; v1(18.16,157.22) 18.16,156.88 18.92,156.12 18.92,155.49 UV8.M2
FBA_BA1: length 86.6
  TOP w0.102: UV6.N8 18.12,135.55 18.12,136.11 17.34,136.89 17.1,136.89 16.81,137.18 v1(16.81,137.84) ; v1(16.84,157.75) 16.84,157.08 17.09,156.83 17.42,156.83 18.09,156.15 18.09,155.43 18.42,155.1 UV7.N8
  IN1 w0.084: v2(49.83,152.24) 50.26,152.24 50.38,152.35 50.38,153.42 50.27,153.52 49.89,153.52 49.82,153.45 49.82,153.07 49.66,152.91 49.09,152.91 48.94,153.07 48.94,153.91 48.75,154.09 46.77,154.09 46.63,154.24 46.32,154.24 46.06,153.98 45.67,153.98 45.42,154.22 45.42,154.56
  IN1 w0.216: v1(15.75,148.91) 15.32,148.91 14.53,149.69 14.53,149.87 14.77,150.1 15.11,150.1 15.6,149.62 16.84,149.62 17.42,149.03 18.3,149.03 19.26,149.99 27.65,149.99 28.23,150.58 29.53,150.58 32.28,153.33 34.85,153.33 35.72,154.21 38.55,154.21 39.4,155.06 40.87,155.06 40.97,155.15 41.35,155.15 41.45,155.05 44.94,155.05 45.42,154.56
  IN3 w0.114: v1(16.84,157.75) 16.84,157.02 16.63,156.81 16.56,156.81 14.85,155.1 14.85,154.93 14.92,154.85 14.98,154.85 15.1,154.74 15.1,154.57 14.98,154.45 14.92,154.45 14.85,154.38 14.85,153.84 14.96,153.73 15.18,153.73 15.29,153.63 15.29,153.47 15.18,153.37 14.96,153.37 14.85,153.26 14.85,153.1 14.96,153 15.11,153 15.22,152.89 15.22,152.74 15.11,152.63 14.96,152.63 14.85,152.52 14.85,152.37 14.96,152.26 15.62,152.26 15.72,152.16 15.72,152.03 15.62,151.93 15,151.93 14.85,151.78 14.85,151.59 15.57,150.87 15.57,149.97 15.72,149.82 15.93,149.82 16.03,149.72 16.03,149.57 15.93,149.46 15.73,149.46 15.57,149.31 15.57,149.08 v1(15.75,148.91) 15.75,147.17 16.38,146.54 16.38,146.22 16.26,146.11 15.95,146.11 15.82,145.97 15.82,145.59 15.94,145.46 16.38,145.46 16.7,145.14 16.7,142.69 15.13,141.12 15.13,140.56 15.25,140.44 15.59,140.44 15.69,140.35 15.69,139.83 16.51,139.01 16.51,138.58 16.61,138.48 16.84,138.48 16.93,138.39 16.93,137.96 v1(16.81,137.84)
  BOTTOM w0.102: v1(16.84,157.75) 16.84,158.05 17.18,158.4 17.76,158.4 17.98,158.61 18.01,158.61 18.12,158.72 18.12,159.51 UV8.N8 ; v1(16.81,137.84) 16.81,138.1 17.17,138.46 17.6,138.46 18.11,138.96 18.11,139.56 UV5.N8 ; v2(49.83,152.24) 49.91,152.15 50.29,152.15 UV3.L15
FBA_BA2: length 79.2
  TOP w0.102: UV7.M3 19.31,159 18.59,158.29 18.59,157.9 v1(18.59,157.9) ; UV6.M3 19.31,139.11 19.09,138.89 19.09,138.65 19.23,138.51 19.23,138.27 19.15,138.2 18.67,138.2 18.59,138.11 v1(18.59,137.84)
  IN1 w0.102: v5(47.45,154.68) 47.45,154.93 47.38,155 47.12,155 47.01,154.89 47.01,154.6 46.88,154.47 46.61,154.47 46.45,154.63 46.45,155.11 46.27,155.29 45.8,155.29 45.67,155.16 45.48,155.16 45.34,155.3
  IN1 w0.216: 45.34,155.3 45.09,155.54 41.83,155.54 41.61,155.76 40.77,155.76 40.55,155.53 40.27,155.53 40.04,155.76 39.51,155.76 38.38,154.62 35.09,154.62 34.88,154.41 34.88,153.97 34.67,153.75 34.37,153.75 34.15,153.97 34.15,154.41 33.94,154.62 33.62,154.62 33.38,154.39 33.38,153.96 33.18,153.75 33.03,153.75 32.72,154.06 32.41,154.06 29.35,151 28.06,151 27.48,150.41 23.79,150.41 23.2,151 23.04,151 22.89,150.85 22.89,150.57 22.74,150.41 22.45,150.41 22.3,150.57 22.3,151 21.79,151.51 19.69,151.51 19.54,151.36 19.54,151.14 19.69,150.98 21.51,150.98 21.66,150.83 21.66,150.57 21.51,150.41 18.89,150.41 18.62,150.14 17.39,150.14 17.25,150 17.25,149.8 17.52,149.52 v1(18,149.52)
  IN3 w0.114: v1(18.59,137.84) 18.44,137.98 18.44,138.12 18.35,138.22 18.35,139.02 17.81,139.57 17.81,141.71 18.16,142.06 18.16,144.81 18.85,145.49 18.85,146.61 18,147.45 v1(18,149.52) 17.99,149.53 17.99,149.73 18.15,149.89 18.21,149.89 18.32,150 18.32,150.13 18.24,150.21 17.9,150.21 17.8,150.31 17.8,150.46 17.9,150.56 18.25,150.56 18.37,150.68 18.37,150.86 18.25,150.98 18.12,150.98 17.57,151.52 17.57,152.35 17.51,152.41 17.51,152.77 17.36,152.92 17.12,152.92 17.07,152.98 17.07,153.23 17.15,153.31 17.43,153.31 17.83,153.72 17.83,153.84 17.58,154.1 17.58,154.35 17.83,154.6 17.83,155.04 17.71,155.16 17.17,155.16 17.11,155.23 17.11,155.48 17.45,155.82 17.63,155.82 17.95,155.5 18.2,155.5 18.48,155.78 18.48,156.01 18.42,156.08 18.04,156.08 17.93,156.18 17.93,156.31 18.59,156.97 18.59,157.9 v1(18.59,157.9)
  BOTTOM w0.102: v1(18.59,137.84) 18.57,137.82 18.57,137.03 19.31,136.29 UV5.M3 ; v1(18.59,157.9) 18.59,157.9 18.59,157.78 18.62,157.75 18.62,156.78 19.31,156.09 UV8.M3 ; v5(47.45,154.68) 47.49,154.68 47.76,154.95 47.76,155.28 47.68,155.35 47.49,155.35 UV3.G11
FBA_CASA0#: length 64.7
  TOP w0.102: v1(21.05,136.92) 21.29,137.16 21.29,137.59 21.61,137.91 21.61,138.51 21.14,138.98 21.09,138.98 UV6.K3
  IN3 w0.084: 44.94,147.2 45.93,148.19 47.17,148.19 v2(47.5,148.51)
  IN3 w0.102: 20.4,138.41 20.4,137.31 20.78,136.92 v1(21.05,136.92)
  IN3 w0.216: 44.94,147.2 44.41,146.66 44.41,145.85 44.15,145.6 43.8,145.6 43.55,145.85 42.59,145.85 42.34,145.6 41.35,145.6 40.9,146.04 36.57,146.04 36.35,145.83 36.35,145.53 36.57,145.32 40.61,145.32 40.82,145.11 40.82,144.81 40.61,144.6 38.47,144.6 38.25,144.38 38.25,144.2 38.1,144.05 37.68,144.05 37.53,144.2 37.53,144.38 37.32,144.6 37.02,144.6 36.81,144.38 36.81,144.15 36.65,144 36.24,144 36.08,144.15 36.08,144.38 35.87,144.6 35.57,144.6 35.36,144.38 35.36,144.2 35.21,144.05 34.79,144.05 34.64,144.2 34.64,144.38 34.42,144.6 34.12,144.6 33.91,144.38 33.91,144.2 33.76,144.05 33.34,144.05 33.19,144.2 33.19,144.38 32.98,144.6 27.96,144.6 27.74,144.38 27.74,144.08 27.96,143.87 31.95,143.87 32.16,143.66 32.16,143.36 31.95,143.15 27.74,143.15 25.98,144.9 23.07,144.9 20.38,142.21 20.38,139.55 20.53,139.4 20.53,138.54 20.4,138.41
  BOTTOM w0.102: v1(21.05,136.92) 21.36,136.61 21.36,136.04 21.17,135.85 21.02,135.85 UV5.K3
  BOTTOM w0.114: v2(47.5,148.51) 47.66,148.67 47.66,149.13 47.59,149.2 UV3.G19
FBA_CASA1#: length 61.6
  TOP w0.102: v1(20.83,157.42) 20.91,157.5 20.91,159.1 UV7.K3
  IN3 w0.102: v1(20.83,157.42) 20.83,158.39 20.24,158.99 ; v5(47.92,152.22) 47.94,152.23 47.94,152.82 47.62,153.13 47.62,153.71 47.05,154.28 47.05,154.91 47.5,155.36 47.5,156.06 47.32,156.24 47.32,158.04 47.33,158.05 47.33,158.38 47.35,158.39 47.35,160.29
  IN3 w0.216: 47.35,160.29 47.35,160.29 47.35,161.16 47.55,161.36 47.55,162.77 47.35,162.97 46.05,162.97 45.4,163.63 45.4,165.06 42.09,168.36 31.12,168.36 30.19,167.43 28.46,167.43 28.25,167.64 28.25,167.94 28.46,168.15 29.98,168.15 30.19,168.37 30.19,168.67 29.98,168.88 28.21,168.88 25.76,166.43 25.76,165.06 25.03,164.32 20.33,164.32 19.38,163.37 19.38,161.62 19.8,161.2 19.8,159.43 20.24,158.99
  BOTTOM w0.102: UV8.K3 20.97,155.95 20.97,157.29 v1(20.83,157.42)
  BOTTOM w0.114: UV3.G16 47.92,152.18 v5(47.92,152.22)
FBA_CKEA0: length 65.1
  TOP w0.102: UV6.K9 20.86,134.41 20.86,134.66 20.58,134.93 20.58,137.09 20.47,137.21 20.47,137.75 20.9,138.18 v1(20.9,138.19)
  IN3 w0.084: v2(49.2,148.53) 49.2,148.38 48.94,148.12 47.62,148.12 47.44,147.95 46.24,147.95 45.14,146.85 45.14,146.68 44.92,146.46
  IN3 w0.216: 44.92,146.46 44.92,144.94 44.49,144.51 43.76,144.51 43.72,144.55 42.76,144.55 42.54,144.76 41.64,144.76 40.4,143.52 32.83,143.52 32.62,143.31 32.62,143.01 32.83,142.8 40.21,142.8 40.42,142.59 40.42,142.29 40.21,142.07 35.42,142.07 35.2,141.86 35.2,141.32 34.99,141.1 34.69,141.1 34.48,141.32 34.48,141.86 34.27,142.07 33.97,142.07 33.76,141.86 33.76,141.32 33.54,141.1 33.24,141.1 33.03,141.32 33.03,141.86 32.82,142.07 32.23,142.07 31.59,142.71 30.94,142.71 30.94,142.7 27.59,142.7 25.81,144.48 23.25,144.48 20.8,142.03 20.8,139.8 21.02,139.58 21.02,138.31 v1(20.9,138.19)
  BOTTOM w0.102: UV5.K9 20.81,140.66 20.81,140.34 20.46,139.99 20.46,138.63 v1(20.9,138.19) ; v2(49.2,148.53) 49.2,148.54 UV3.K20
FBA_CKEA1: length 64.2
  TOP w0.102: v1(21.46,157.07) 21.46,156.95 20.99,156.47 20.74,156.47 20.48,156.21 20.48,155.05 20.84,154.69 20.84,154.37 UV7.K9
  IN3 w0.084: 44.39,149.5 44.57,149.5 45.58,150.51 46.87,150.51 46.99,150.64 47.77,150.64 v2(48.1,150.98)
  IN3 w0.216: v1(21.46,157.07) 21.46,156.53 21.25,156.32 20.9,156.32 20.68,156.11 20.68,155.81 20.9,155.59 21.27,155.59 21.48,155.38 21.48,155.08 21.27,154.87 20.9,154.87 20.68,154.66 20.68,154.36 20.9,154.15 21.25,154.15 21.46,153.93 21.46,153.36 23.57,151.25 24.82,151.25 25.11,150.97 25.54,150.97 28.37,148.14 35.79,148.14 36,148.35 36,148.65 35.79,148.86 28.77,148.86 27.18,150.46 27.18,150.8 27.42,151.04 27.76,151.04 29.22,149.59 42.24,149.59 42.38,149.45 44.34,149.45 44.39,149.5
  BOTTOM w0.114: UV3.J17 48.73,150.4 48.1,151.02 v2(48.1,150.98) ; v1(21.46,157.07) 21.29,157.25 21.29,158.06 20.44,158.91 20.44,160.49 20.65,160.7 UV8.K9
FBA_CLKA0: length 68
  TOP w0.127: 21.71,135.96 21.52,136.15 21.52,136.19 22.16,136.83 22.16,137.23 v2(22.37,137.44) ; RV26.1 22.91,130.74 22.43,131.22 22.43,131.9 v2(22.71,132.18)
  IN1 w0.14: v2(22.37,137.44) 22.1,137.18 22.1,136.69 20.57,135.16 19.78,135.16 19.64,135.02 19.64,134.65 19.78,134.52 20.55,134.52 21.04,134.03 21.04,133.56 20.69,133.22 19.72,133.22 19.45,132.95 19.45,132.65 19.72,132.38 20.92,132.38 22.57,130.72 29.54,130.72 32.24,128.02 42.46,128.02 49.38,134.95 49.38,138.34 49.12,138.6 48.39,138.6 48,139 48,140.19 48.94,141.14 48.94,142.49 48.04,143.39 47.53,143.39 47.43,143.29 47.43,143.06 47.53,142.96 v5(47.74,142.96)
  IN3 w0.14: v2(22.37,137.44) 22.21,137.28 22.21,136.62 20.71,135.13 20.71,134.39 22.42,132.69 22.42,132.47 v2(22.71,132.18)
  BOTTOM w0.102: v5(47.74,142.96) 47.74,143 UV3.H26
  BOTTOM w0.127: v2(22.37,137.44) 22.37,137.47 21.98,137.85 21.98,138.52 21.71,138.8 21.71,139.16
FBA_CLKA0#: length 68.2
  TOP w0.127: RV27.2 22.2,130.72 v1(22.2,131.55) 22.2,131.9 v2(21.91,132.18) ; v2(21.7,137.39) 21.83,137.26 21.83,136.87 21.26,136.3 21.26,136.14 21.08,135.96 UV6.K7
  IN1 w0.14: v2(47.74,143.82) 47.91,143.64 48.13,143.64 49.19,142.59 49.19,141.04 48.24,140.09 48.24,139.1 48.49,138.85 49.22,138.85 49.63,138.44 49.63,134.85 42.56,127.78 32.14,127.78 29.44,130.48 22.47,130.48 20.82,132.13 19.62,132.13 19.21,132.55 19.21,133.05 19.62,133.46 20.59,133.46 20.8,133.66 20.8,133.93 20.45,134.27 19.68,134.27 19.4,134.55 19.4,135.12 19.68,135.4 20.47,135.4 21.86,136.79 21.86,137.23 v2(21.7,137.39)
  IN3 w0.14: v2(21.91,132.18) 21.92,132.18 22.17,132.44 22.17,132.59 20.47,134.29 20.47,135.23 21.81,136.56 21.81,137.28 v2(21.7,137.39)
  BOTTOM w0.127: v2(47.74,143.82) 47.85,143.93 47.87,143.93 48.13,144.2 UV3.H25 ; UV5.K7 21.03,139.16 21.74,138.44 21.74,137.42 v2(21.7,137.39)
FBA_CLKA1: length 67.1
  TOP w0.127: 21.71,155.9 21.61,156 21.61,156.29 22.21,156.89 22.21,157.62 v2(22.36,157.77)
  IN1 w0.14: v2(22.36,157.77) 22.17,157.95 22.17,158.28 20.85,159.59 20.85,161.45 22.3,162.89 22.3,165.22 24.06,166.99 25.4,166.99 25.93,167.52 25.93,168.07 25.58,168.42 25.58,168.61 25.84,168.88 26.04,168.88 26.61,168.3 27.01,168.3 27.41,168.7 27.41,169.1 26.84,169.67 26.84,169.87 27.1,170.13 27.3,170.13 27.87,169.56 28.27,169.56 29.63,170.93 40.64,170.93 41.03,170.54 43.19,170.54 47.07,166.66 47.33,166.66 49.03,164.95 49.03,161.64 50.42,160.26 50.42,159.43 50.15,159.16 50.15,158.15 49.75,157.76 48.04,157.76 48.01,157.79 47.3,157.79 v5(46.92,157.4)
  IN3 w0.14: v2(22.36,157.77) 22.1,158.02 22.1,158.44 21.9,158.64 21.9,158.65 20.74,159.81 20.74,162.05 20.58,162.21 20.58,162.33 v2(20.88,162.63)
  BOTTOM w0.127: v2(22.36,157.77) 21.88,158.24 21.88,158.26 21.38,158.76 21.38,158.97 21.51,159.1 21.71,159.1 ; UV3.G9 46.93,157.4 v5(46.92,157.4) ; v2(20.88,162.63) 20.63,162.88 20.63,163.93 RV38.1
FBA_CLKA1#: length 67.5
  TOP w0.127: UV7.K7 21.14,155.9 21.3,156.05 21.3,156.3 21.65,156.65 21.65,156.65 21.98,156.99 21.98,157.46 v2(21.71,157.73)
  IN1 w0.14: v2(47.74,157.39) 47.87,157.51 49.85,157.51 50.39,158.05 50.39,159.06 50.66,159.33 50.66,160.36 49.28,161.74 49.28,165.05 47.43,166.9 47.17,166.9 43.29,170.78 41.13,170.78 40.74,171.17 29.53,171.17 28.17,169.8 27.97,169.8 27.4,170.37 27,170.37 26.6,169.97 26.6,169.57 27.17,169 27.17,168.8 26.91,168.54 26.71,168.54 26.14,169.12 25.75,169.12 25.34,168.71 25.34,168.32 25.69,167.97 25.69,167.62 25.3,167.23 23.96,167.23 22.06,165.32 22.06,162.99 20.61,161.55 20.61,159.49 21.71,158.39 v2(21.71,157.73)
  IN3 w0.14: v2(20.09,162.63) 20.34,162.37 20.34,162.11 20.5,161.95 20.5,159.71 21.66,158.55 21.66,158.54 21.86,158.34 21.86,157.87 v2(21.71,157.73)
  BOTTOM w0.127: UV8.K7 21.12,158.89 21.12,158.68 21.7,158.09 21.7,157.74 21.71,157.73 v2(21.71,157.73) ; v2(47.74,157.39) 47.75,157.39 UV3.H9 ; v2(20.09,162.63) 20.4,162.94 20.4,164.02 20.24,164.18 RV39.2
FBA_CSA0#: length 63.4
  TOP w0.102: UV6.L2 20.11,140.13 20.48,140.5 20.48,141 20.35,141.13 19.95,141.13 19.74,140.93 19.74,138.86 v1(19.96,138.64)
  IN3 w0.084: 45.18,148.05 45.64,148.52 46.27,148.52 46.73,148.98 49.93,148.98 50.32,148.58 50.32,147.17 49.94,146.79 48.99,146.79 v2(48.58,147.2)
  IN3 w0.216: 45.18,148.05 44.2,147.08 43.1,147.08 42.05,146.03 41.61,146.03 41.18,146.46 29.61,146.46 29.39,146.25 29.39,145.95 29.61,145.74 35.68,145.74 35.9,145.53 35.9,145.23 35.68,145.02 26.6,145.02 26.29,145.32 22.9,145.32 19.96,142.38 v1(19.96,138.64)
  BOTTOM w0.102: v1(19.96,138.64) 19.94,138.62 19.94,137.67 19.56,137.29 19.56,136.74 19.69,136.62 19.69,135.57 UV5.L2 ; UV3.H22 48.19,146.8 48.59,147.19 48.59,147.2 v2(48.58,147.2)
FBA_CSA1#: length 61.7
  TOP w0.102: v1(19.8,157.59) 19.71,157.59 19.53,157.77 19.53,158.77 19.69,158.93 19.69,159.48 20.11,159.9 UV7.L2
  IN3 w0.084: v2(48.03,154.54) 47.94,154.45 47.94,154.07 48.11,153.9 49.35,153.9 50.43,152.83 50.43,150.56 50.02,150.15 48.55,150.15 48.47,150.07 47.5,150.07 47.29,149.86 45.88,149.86 44.63,148.6
  IN3 w0.216: 44.63,148.6 43.2,148.6 42.84,148.24 42.19,148.24 41.25,147.3 27.85,147.3 27.58,147.58 27.26,147.58 26.98,147.3 25.56,147.3 25.36,147.51 25.36,147.82 25.45,147.92 26.67,147.92 26.78,148.03 26.78,148.35 26.54,148.59 25.51,148.59 25.19,148.9 24.89,148.9 24.58,148.59 24.03,148.59 23.8,148.81 23.54,148.81 23.31,148.59 22.21,148.59 21.15,147.53 20.83,147.53 20.29,148.07 20.29,148.38 20.48,148.56 21.08,148.56 22.07,149.55 22.07,150.46 19.55,152.98 19.55,153.69 19.84,153.98 19.84,154.3 19.4,154.74 19.4,155 19.84,155.45 19.84,155.72 19.51,156.05 19.51,156.36 19.84,156.69 19.84,156.83 20.15,157.14 20.15,157.45 20.01,157.59 v1(19.8,157.59)
  BOTTOM w0.102: UV8.L2 19.69,155.51 19.69,156.09 19.43,156.36 19.43,156.66 19.81,157.04 19.81,157.5 19.8,157.51 v1(19.8,157.59)
  BOTTOM w0.114: v2(48.03,154.54) 48.03,154.54 47.5,154 UV3.G13
FBA_D0: length 48.4
  IN3 w0.14: v2(24.24,133.35) 24.24,132.64 25.58,131.3 25.58,130.57 25.85,130.3 29.09,130.3 30.81,128.58 32.9,128.58 34.01,127.47 45.09,127.47 51.02,133.39 51.02,136.75 50.83,136.94 50.56,136.94 50.37,136.75 50.37,135.73 50.18,135.54 49.92,135.54 49.73,135.73 49.73,137.85 49.45,138.13 v2(48.95,138.13)
  BOTTOM w0.102: v2(48.95,138.13) 49.36,138.54 49.36,142.22 UV3.K27
  BOTTOM w0.14: v2(24.24,133.35) 24.3,133.35 24.48,133.53 24.48,134.59 24.11,134.96 UV5.F2
FBA_D1: length 47.2
  IN3 w0.14: v2(48.93,139.35) 49.09,139.35 51.48,136.96 51.48,133.22 45.28,127.02 33.83,127.02 32.72,128.13 30.57,128.13 28.86,129.85 24.96,129.85 23.45,131.35 23.45,132.83 23.23,133.05 23.23,134.21 22.71,134.73 22.71,135.37 v2(22.9,135.56)
  BOTTOM w0.102: UV3.J29 48.55,141.01 48.55,139.75 48.95,139.35 v2(48.93,139.35)
  BOTTOM w0.14: UV5.H3 22.9,135.57 v2(22.9,135.56)
FBA_D2: length 46.9
  IN3 w0.14: v2(25.06,136.9) 25.2,137.04 26.22,137.04 27.15,136.12 27.15,135.6 26.8,135.26 26.8,134.58 27.15,134.23 27.15,133.71 27.39,133.47 28.84,133.47 31.62,130.69 38.09,130.69 39.31,129.47 44.14,129.47 44.29,129.63 44.29,129.97 44.14,130.12 40.28,130.12 40.13,130.27 40.13,130.62 40.28,130.77 45.47,130.77 47.24,132.53 v5(47.24,138.01)
  BOTTOM w0.102: UV3.H30 47.76,140.62 47.76,138.53 v5(47.24,138.01)
  BOTTOM w0.14: UV5.E3 24.98,136.03 24.98,136.82 v2(25.06,136.9)
FBA_D3: length 46.5
  IN3 w0.14: v1(48.89,137.34) 49.27,136.96 49.27,134.08 49.46,133.89 49.73,133.89 49.92,134.08 49.92,134.87 50.11,135.06 50.38,135.06 50.57,134.87 50.57,133.58 44.91,127.92 34.33,127.92 33.16,129.09 30.93,129.09 29.26,130.77 26.77,130.77 26.68,130.86 26.68,131.05 27.04,131.41 27.04,131.68 26.85,131.87 26.58,131.87 26.22,131.51 26.03,131.51 25.76,131.77 25.76,131.97 26.05,132.26 26.05,132.46 25.79,132.72 25.6,132.72 25.31,132.43 25.11,132.43 24.92,132.61 24.92,133.29 24.68,133.53 24.68,133.53 24.49,133.73 24.49,134.78 v1(23.71,135.56)
  BOTTOM w0.102: UV3.H32 48.14,138.09 v1(48.89,137.34)
  BOTTOM w0.14: UV5.G2 v1(23.71,135.56)
