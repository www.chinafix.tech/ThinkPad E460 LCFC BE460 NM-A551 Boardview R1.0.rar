# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 111.7
  TOP w0.254: 137.4,55.79 137.4,55.69 137.12,55.4 137.12,50.02 138.59,48.55 158.94,48.55 159.22,48.27 183.51,48.27 v1(183.52,48.25) ; 137.4,55.79 137.4,55.91 137.16,56.15 JU3AC.18 137.16,57.18 137.41,57.44 137.52,57.44 ; 137.4,55.79 137.66,56.05 JU3AC.19 137.66,57.3 137.52,57.44 ; v1(177.23,57.22) 177.13,57.33 176.44,57.33 v4(176.4,57.28) ; CA9.2 180.07,51.82 178.81,50.57 v1(177.4,50.57) v1(175.24,50.57) 174.87,50.57 174.23,49.92 159.87,49.92 v1(159.37,50.43) 159.11,50.17 144.32,50.17 142.27,52.22 142.27,56.48 141.31,57.44 137.52,57.44
  TOP w0.508: CA19.2 174.4,55.99 v1(174.48,56.06) ; 178.12,56.24 178.04,56.33 178.04,57.21 CA10.2 177.37,57.36 v1(177.23,57.22) ; 178.12,56.24 CA11.2 ; 178.12,56.24 178.07,56.19 177.73,56.19 v1(177.38,56.55) ; CA8.2 CA9.2
  vias: v1(138.13,47.48) v1(141.94,47.48) v1(145.75,47.48) v1(149.56,47.48) v1(153.37,47.48) v1(157.18,47.48) v1(160.99,47.48) v1(164.8,47.48) v1(168.61,47.48) v1(172.42,47.48) v1(176.23,47.48) v1(180.04,47.48) v1(183.84,47.47) v1(187.66,47.48) v1(191.47,47.48) v1(194.93,47.48) v1(196.7,49.56)
VCC0R9GBE: length 9.2
  TOP w0.305: UL1.40 250.32,93.84 v1(250.3,93.87) ; v1(256.51,88.91) 256.39,88.91 256.04,89.27 UL1.11 ; v1(258.27,91.77) 258.19,91.84 UL1.16 ; UL1.22 258.02,94.24 v1(258.17,94.39) ; UL1.37 250.54,95.04 v1(250.3,95.28) ; UL1.43 250.32,92.64 v1(250.3,92.67) ; UL1.8 v1(254.84,88.9) ; UL1.47 250.6,91.04 v1(250.3,91.35) 250.4,91.44 UL1.46
  vias: v4(254.39,95.68)
VCC0R9GBE_L: length 1.1
  TOP w0.305: UL1.7 254.44,89.23 v1(254.11,88.9)
  vias: v4(254.12,85.01)
VCC_SENSE: length 91.5
  TOP w0.254: v1(80.18,76.88) 80.18,77.44 v4(83.3,80.56) 83.32,80.58 83.32,95.43 81.96,96.79 81.96,101.45 83.32,102.81 83.32,113.27 81.8,114.79 81.8,116.36 82.54,117.1 RC121.2 RC120.2
  IN1 w0.254: v1(80.18,76.88) 80.18,73.93 82.24,71.87 82.24,68.25 79.89,65.91 67.56,65.91 60.95,59.3 60.95,52.9 58.81,50.76 v1(58.73,50.76)
  BOTTOM w0.254: PR415.1 61.14,51.04 PC404.1 60.18,50.93 PC406.2 58.91,50.93 v1(58.73,50.76)
VCCGT_SENSE: length 52.1
  TOP w0.254: RC124.1 RC125.2 102.29,91.04 102.04,90.79 100.79,90.79 100.31,90.31 100.31,86.68 94.45,80.82 93.34,80.82 78.1,65.58 v4(77.84,65.58) 76.31,64.04 v1(69.91,64.04)
  BOTTOM w0.203: PU401.47 66.26,61.4 66.54,61.68 67.29,61.68 68.61,63 PC413.2
  BOTTOM w0.254: PC413.2 68.61,63.18 69.22,63.79 69.65,63.79 v1(69.91,64.04)
VCCIO_SENSE: length 42.7
  TOP w0.114: RC192.1 130.8,147.94 130.94,147.8 132.07,147.8 132.45,147.42 v1(133.14,147.42)
  IN1 w0.076: v2(115.44,122.98) 115.46,123 115.46,123.2 115.59,123.33 118.86,123.33 119.23,123.7 119.23,124.36 119.51,124.64 119.84,124.64
  IN1 w0.14: 119.84,124.64 121.51,124.64 123.41,126.53 123.41,128.36 127.79,132.74 127.79,137.36 129.57,139.15 133.69,139.15 135.47,140.93 135.47,144.51 133.14,146.83 v1(133.14,147.42)
  BOTTOM w0.076: UC1.AM23 v2(115.44,122.98)
VCCSA_SENSE: length 96.4
  TOP w0.254: RC185.2 98.53,126.52 98.25,126.24 98.25,125.83 97.66,125.24 93.67,125.24 93.03,124.61 90.19,124.61 88.66,126.14 87.35,126.14 86.72,125.51 86.72,121.19 86.33,120.8 83.1,120.8 RC370.2 80.53,118.22 80.53,114.22 82.02,112.73 82.02,103.18 80.82,101.98 80.82,96.21 82.02,95.01 82.02,81.95 v4(77.72,77.64) 77.72,77.2 v1(78.35,76.56)
  IN1 w0.254: v1(78.35,76.56) 78.35,74.14 81.09,71.39 81.09,68.73 79.49,67.13 68.7,67.13 v1(68.05,67.77)
  BOTTOM w0.254: PC423.1 68.87,66.15 PR434.1 68.05,66.17 PC425.2 v1(68.05,67.77)
VCCST_PG_EC: length 131.9
  TOP w0.114: v1(176.01,112.81) 176.44,113.24 176.44,113.5 179.18,116.24 179.69,116.24 179.86,116.07 UE1.34
  TOP w0.254: DC23.1 91.66,100.38 v1(92.82,99.22)
  IN3 w0.114: v1(92.82,99.22) 92.63,99.03 92.63,87.22 94.42,85.43 98.06,85.43 v1(99.2,84.28) ; v1(176.01,112.81) 175.69,112.48 175.69,97.44 174.59,96.35 174.59,92.47 168.64,86.52 166.1,86.52 159.74,80.16 146.62,80.16 145.89,79.43 113.31,79.43 109.98,82.76 v1(109.98,82.84)
  BOTTOM w0.114: v1(109.98,82.84) 109.58,82.84 108.13,84.28 v4(100.83,84.28) v1(99.2,84.28)
VCCST_PWRGD: length 9.3
  TOP w0.254: 88.96,100.39 89.05,100.48 90.4,100.48 90.49,100.38 ; 88.96,100.39 88.18,101.16 v4(87.98,101.16) RC383.1 85.87,101.16 85.57,100.86 85.57,99.46 85.81,99.21 QC3.3 ; 88.96,100.39 RC123.2 ; RC387.1 90.49,100.38 ; 90.49,100.38 DC23.2
VCCST_PWRGD_R: length 9.3
  TOP w0.254: RC387.2 91.84,99.44 92.64,98.64 v1(93.35,98.64)
  BOTTOM w0.076: 97.37,99.87 98,100.51 99.13,100.51 UC1.B65
  BOTTOM w0.114: v1(93.35,98.64) 93.95,99.23 v4(94.21,99.23) 96.75,99.23 97.14,99.62 97.14,99.65 97.37,99.87
VDD_62771: length 12
  TOP w0.254: v1(115.2,174.78) 114.99,174.58 114.99,172.25 v4(114.5,171.75) 114.05,171.3 112.61,171.3 112.05,170.75 v1(111.97,170.75) 111.97,170.42 PR601.1
  BOTTOM w0.203: v1(115.2,174.78) 115.2,174.73 115.09,174.62 PU601.31 ; PU601.25 112.36,171.11 112.02,170.77 112,170.77 v1(111.97,170.75)
  BOTTOM w0.254: PC604.1 111.51,170.75 v1(111.97,170.75)
VDDC_RTN: length 48.1
  TOP w0.254: RV4.1 74.85,153.72 RV2.1 75.66,154.02 77.6,154.02 77.86,153.77 81.87,153.77 83.85,155.75 85.72,155.75 v4(85.97,155.49) 86.28,155.49 86.98,154.79 87.59,154.79 87.99,155.2 v1(87.99,155.25) ; v1(114.03,162.19) 114.18,162.34 114.61,162.34 PR625.1
  IN1 w0.254: v1(114.03,162.19) 113.9,162.06 113.9,157.82 112.95,156.87 106.57,156.87 105.07,155.37 99.8,155.37 99.61,155.56 88.3,155.56 v1(87.99,155.25)
VDDC_SEN: length 49
  TOP w0.254: PR621.2 114.08,162.82 v1(114,162.82) ; RV1.1 RV3.1 74.5,154.34 75.35,154.34 75.41,154.4 77.89,154.4 78.09,154.21 81.78,154.21 83.82,156.26 v4(84.19,156.26) 86.25,156.26 v1(87.21,155.3)
  IN1 w0.254: v1(114,162.82) 113.88,162.82 113.52,162.47 113.52,157.98 112.8,157.26 106.42,157.26 104.91,155.75 99.96,155.75 99.77,155.94 87.81,155.94 87.21,155.33 v1(87.21,155.3)
VDDPALW_PWRGD: length 3.2
  BOTTOM w0.229: PU701.1 147.89,168.17
  BOTTOM w0.254: PR704.1 146.47,166.98 v4(146.84,167.34) 147.26,167.76 147.63,167.76 147.89,168.02 147.89,168.17
VIN_1.00VS:
  vias: v1(151.39,173.82) v1(152.05,173.82) v1(152.76,172.17) v4(153.41,174.29)
VIN_+1.8VSP:
  vias: v4(192.53,169.85)
VSS_SENSE: length 92.1
  TOP w0.254: RC143.1 RC142.2 82.17,117.99 81.42,117.23 81.42,114.63 82.94,113.11 82.94,102.96 81.58,101.61 81.58,96.63 82.94,95.27 82.94,81.59 81.97,80.63 81.97,79.99 v4(81.65,79.68) 79.55,77.57 v1(79.55,76.88)
  IN1 w0.254: v1(58.71,51.7) 59.11,51.7 60.55,53.13 60.55,59.43 67.4,66.29 79.73,66.29 81.86,68.41 81.86,71.71 79.55,74.02 v1(79.55,76.88)
  BOTTOM w0.254: PR416.1 61.17,51.87 PC407.1 60.28,51.85 PC406.1 58.86,51.85 v1(58.71,51.7)
VSSGT_SENSE: length 50.9
  TOP w0.254: RC183.1 RC184.1 102.29,90.15 102.04,90.41 100.95,90.41 100.69,90.15 100.69,86.52 94.48,80.31 93.59,80.31 77.21,63.93 v4(76.95,63.93) 76.53,63.51 v1(70.29,63.51) 70.09,63.51 69.53,62.95 69.53,61.96 PR424.1
  BOTTOM w0.254: v1(70.29,63.51) 69.93,63.15 PC413.1 69.53,61.96 PR424.1
VSSIO_SENSE: length 39.9
  TOP w0.114: v1(132.1,146.63) 132.1,146.93 RC189.1
  IN1 w0.076: 119.79,124.94 119.59,124.94 119.06,124.41 119.06,123.76 118.8,123.5 115.83,123.5 v2(115.44,123.89)
  IN1 w0.14: v1(132.1,146.63) 132.94,146.63 135.08,144.48 135.08,141.05 133.45,139.41 129.46,139.41 127.52,137.47 127.52,132.91 123.11,128.5 123.11,126.71 121.34,124.94 119.79,124.94
  BOTTOM w0.076: v2(115.44,123.89) UC1.AM22
VSSSA_SENSE: length 96.8
  TOP w0.254: RC126.2 98.53,125.64 97.76,124.86 93.92,124.86 93.29,124.23 90.04,124.23 88.5,125.76 87.61,125.76 87.1,125.26 87.1,120.94 86.58,120.42 83.71,120.42 RC369.1 82.7,119.78 80.91,118 80.91,114.38 82.4,112.88 82.4,102.97 81.2,101.77 81.2,96.47 82.4,95.27 82.4,81.76 80.42,79.77 80.42,79.45 v4(79.88,78.91) 78.35,77.39 v1(78.35,77.33)
  IN1 w0.254: v1(67.14,67.72) 68.12,66.75 79.65,66.75 81.48,68.57 81.48,71.55 78.91,74.12 78.91,76.77 v1(78.35,77.33)
  BOTTOM w0.254: PR437.1 PC426.1 67.16,67.04 PC425.1 v1(67.14,67.72)
18PWRON_R: length 10.1
  TOP w0.114: UV12.3 60.03,174.15 59.2,173.33 CV179.1 58.59,173.81 57.17,173.81 56.83,174.15 RV153.2 56.83,175.37 DV6.2 57.06,176.18 56.89,176.35 54.37,176.35 v4(53.59,175.56)
+DCPDSW: length 3.9
  TOP w0.254: CC60.1 114.76,136.09 v2(116.07,137.4)
  BOTTOM w0.152: v2(116.07,137.4) 115.44,137.4 114.89,136.85 UC1.AL1
+DCPRTC: length 2.9
  TOP w0.254: C197.1 121.32,132.04 121.76,131.6 v2(121.76,131.54)
  BOTTOM w0.203: v2(121.76,131.54) 121.72,131.5 UC1.BB10
+FBA_VREFC0_U: length 41.1
  IN2 w0.381: v2(19.55,131.62) 19.04,131.62 17.91,132.75 15.56,132.75 v2(15.14,133.17)
  BOTTOM w0.203: 19.69,141.11 19.72,141.09 19.72,140.95 19.74,140.93 19.74,140.92 19.74,140.91 19.74,140.39 19.72,140.37 19.72,140.37 UV5.M8
  BOTTOM w0.305: UV5.H1 22.51,134.35 22.09,133.93
  BOTTOM w0.381: 22.09,133.93 19.77,131.62 v2(19.55,131.62) ; v2(15.14,133.17) 14.1,134.22 13.22,134.22 10.32,137.12 v4(10.32,137.69) 10.32,139.4 14.82,143.9 14.82,145.29 16.11,146.59 16.82,146.59 17.76,147.53 18.19,147.53 19.08,146.64 19.08,146.29 19.17,146.2 19.17,144.67 19.6,144.24 RV19.1 RV18.2 CV100.1 21.62,143.53 19.69,141.61 19.69,141.11
+FBA_VREFC1_U: length 54.4
  TOP w0.203: 19.93,153.79 19.93,153.95 19.74,154.14 19.74,154.67 UV7.M8
  TOP w0.381: v1(22.78,167.25) 22.78,164.33 22.51,164.07 22.51,161.06 22.51,161.05 22.51,160.7 UV7.H1 ; RV31.1 RV30.2 ; RV31.1 20.71,150.86 20.86,150.86 21.62,150.1 21.62,148.95 20.91,148.24 v4(18.78,148.24) 14.33,148.24 13.88,148.7 13.88,152.81 10.17,156.52 10.17,158.91 v1(10.67,159.42) ; RV31.1 21.72,150.88 21.75,150.86 22.37,150.86 CV127.1 22.4,151.13 19.93,153.6 19.93,153.79
  IN3 w0.381: v1(10.67,159.42) 11.94,160.69 11.94,162.57 12.55,163.18 16.09,163.18 17.61,164.7 18.55,164.7 20.12,166.28 21.81,166.28 v1(22.78,167.25)
+FBA_VREFD0_L: length 44
  TOP w0.203: 19.7,134 19.74,134.03 19.74,134.73 UV6.M8
  TOP w0.305: RV24.2 21.01,143.62 22.51,142.12 UV6.H1
  TOP w0.381: RV24.2 RV25.1 CV103.1 23.01,144.24 23.45,144.69 23.45,146.51 22.33,147.63 17.86,147.63 17,146.77 16.36,146.77 14.84,145.24 14.84,143.8 v4(12.31,141.27) 10.15,139.11 10.15,137.1 12.76,134.5 v1(12.76,133.64) ; 19.7,134 19.7,133.34 18.03,131.67 v1(18.03,131.49)
  IN3 w0.381: v1(12.76,133.64) 13.75,133.64 15.87,131.51 18.01,131.51 v1(18.03,131.49)
+FBA_VREFD1_L: length 45.2
  BOTTOM w0.127: UV8.M8 18.91,160.29 18.91,161.09
  BOTTOM w0.381: 21.25,150.87 RV36.2 CV130.1 23.5,151.54 22.53,152.51 22.53,153.36 22.61,153.44 22.61,154.2 UV8.H1 ; 21.25,150.87 21.75,150.37 21.75,148.72 21.11,148.09 v4(19.21,148.09) 14.46,148.09 13.41,149.14 13.41,149.8 12.28,150.93 11.64,150.93 11.61,150.91 10.32,150.91 9.4,151.82 9.4,154.67 10.01,155.28 10.01,162.34 10.62,162.95 16.1,162.95 16.38,162.67 17.37,162.67 18.09,161.95 18.09,161.92 18.91,161.09 ; 21.25,150.87 RV37.1
+LCDVDD_CON:
  vias: v1(55.24,113.43) v1(55.76,113.88) v1(57.39,114.97) v1(57.73,115.51) v1(57.78,116.25) v1(70.54,117.2) v1(70.91,116.56) v1(71.25,117.2) v1(71.54,115.44) v1(71.67,116.61) v1(71.94,117.2) v4(69.94,115.01)
+LEDVDD: length 2.3
  TOP w0.254: JLCD.3 57.44,112.66 57.44,112.61 57.23,112.4 v1(57.23,112.3) ; 57.69,112.33 57.69,112.35 JLCD.2 ; JLCD.1 58.33,112.46 v1(57.79,111.92)
  vias: v1(57.44,111) v1(58.05,111.26) v3(56.95,111.61)
+MICBIASB: length 16.7
  TOP w0.203: UA1.34 186.43,53.95 v1(186.72,53.65) ; v1(194.98,48.62) 195.58,49.23 DA4.2 DA3.2
  IN1 w0.203: v1(186.72,53.65) 186.75,53.65 187.52,52.88 187.52,50.28 188.73,49.08 194.52,49.08 v1(194.98,48.62)
+PCH_CORE: length 2.8
  TOP w0.254: 112.41,127.05 CC96.1 112.08,126.7
  BOTTOM w0.254: 108.08,125.36 v2(108.03,125.36) ; 108.08,125.36 108.1,125.36 UC1.V21 ; 108.08,125.36 UC1.V20 ; UC1.AF19 111.54,126.56 v2(111.35,126.56) UC1.AF18
  vias: v1(82.97,135.2) v1(83.62,135.2) v1(84.26,135.2) v1(84.89,135.2) v2(108.01,124.76) v2(111.37,127.27) v4(109.85,125.04)
+RTCBATT: length 131.9
  TOP w0.508: RC11.1 139.01,147.19 140.25,147.19 142.11,149.04 142.11,150.29 141.15,151.24 v1(141.15,151.56)
  IN2 w0.508: v1(217.04,172.13) 217.04,169.21 217.91,168.33 217.91,148.88 216.91,147.87 200.91,147.87 198.24,145.21 190.37,145.21 181.48,154.1 174.7,154.1 172.34,156.45 147.83,156.45 145.59,154.21 143.11,154.21 141.85,152.95 141.85,152.26 v1(141.15,151.56)
  BOTTOM w0.762: v1(217.04,172.13) 217.14,172.23 PD6.1 218.15,172.99 219.02,173.86 221.76,173.86 v4(221.99,173.63) 222.49,173.13 D6.1
+RTCVCC: length 31.2
  TOP w0.254: CC59.1 114.82,126.63 v2(114.82,126.63)
  TOP w0.381: RC16.1 132.63,144.67 v1(133.22,145.26)
  TOP w0.508: RC14.1 133.4,136.06 v1(131.99,136.06) ; v1(133.22,145.26) 133.52,145.56 135.45,145.56 v3(135.65,145.77) 135.97,146.08 RC11.2
  IN1 w0.254: v2(114.82,126.63) 114.82,126.47 115.11,126.18 120.13,126.18 120.8,126.84 120.8,127.22
  IN1 w0.508: 120.8,127.22 120.8,127.9 v2(121.97,129.07) 121.97,129.13 123.28,130.45 123.28,130.88 v1(124.68,132.28)
  IN3 w0.254: v2(121.97,129.07) 121.57,129.07 119.39,126.88 119.39,126.58 118.99,126.18 115.27,126.18 v2(114.82,126.63)
  BOTTOM w0.203: UC1.BB14 121.95,129.08 v2(121.97,129.07)
  BOTTOM w0.254: v2(114.82,126.63) 114.53,126.34 UC1.AK19
+USB_VCCA: length 7.9
  TOP w0.508: D8.5 282.32,37.18 282.86,36.64 v1(282.86,36.58)
  IN3 w0.508: v1(282.86,36.58) 283.57,35.87 v1(283.57,30.26)
  vias: v1(280.97,10.1) v1(280.97,9.34) v1(282.68,30.26) v1(283.28,8.81) v1(284.11,8.72) v1(284.51,30.23) v1(284.64,8.21) v1(284.84,28.73) v1(284.84,27.95) v1(284.84,27.18) v1(285.35,6.48) v1(285.48,28.23) v1(286.11,6.51) v4(283.88,28.25)
+V_DDR_REFA: length 7.3
  TOP w0.508: RD2.2 RD1.2 160.79,89.01 CD3.1 CD1.1 RD3.1 163.43,89.32 v1(162.15,90.6)
  BOTTOM w0.305: JDIMM1.1 162.4,90.35 v1(162.15,90.6)
+V_DDR_REFB: length 8.2
  TOP w0.508: v1(151.62,89.82) 150.81,89.01 RD16.1 CD33.1 CD32.1 RD15.2 RD17.2 146.79,90.51 v4(146.76,90.55)
  BOTTOM w0.356: JDIMM2.1 151.09,90.35 v1(151.62,89.82)
+VCOREVCC: length 4.6
  TOP w0.114: v4(175.3,127.66) 175.19,127.54 CE7.2 176.82,124.77 UE1.12
+VGA_B+:
  vias: v1(105.21,168.08) v1(105.54,167.52) v1(105.87,168.08) v1(108.11,160.46) v1(108.77,160.46) v1(109.43,160.46) v4(103.37,167.31)
+VGA_CORE: length 216.3
  TOP w0.254: v1(88.58,161.83) 88.94,161.47 88.94,157.89 90.16,156.67 105.43,156.67 106.03,157.26 107.16,157.26 107.67,156.74 112.34,156.74 113.9,158.3 113.9,160.99 114.76,161.86 121.5,161.86 v1(122,162.36) ; PR622.1 114.61,164.29 113.95,163.63 v1(113.95,163.53) ; v1(80.4,159.47) 80.4,158.37 81.82,156.94 86.76,156.94 87.84,155.86 v4(88.79,155.86) 88.87,155.79 112.58,155.79 114.79,157.99 114.79,159.88 v1(115.03,160.12) ; v1(123.76,162.31) 124.44,162.31 125.09,162.96 125.09,164.54 125.64,165.08 126.61,165.08 127.39,165.86 127.39,174.43 125.55,176.27 89.69,176.27 86.04,172.62 86.04,170.09 v1(85.7,169.75)
  TOP w0.381: CV38.1 59.92,155.7 v2(59.64,155.98) ; CV44.1 52.6,148.66 v2(53.11,149.17) ; v2(57.77,153.83) 57.25,154.35 CV54.1 ; v2(51.01,152.76) 50.51,153.27 CV63.1 ; CV55.1 52.98,151.7 v2(53.11,151.83) ; v2(55.77,151.83) 55.67,151.73 CV59.1 ; RV1.2 73.32,155.98 72.93,156.37 CV48.1 CV49.1 72.37,154.16 71.78,153.58 70.62,153.58 70.22,153.97 ; CV43.1 53.31,155.83 53.87,156.39 v2(53.87,156.52) ; CV52.1 51.58,149.56 v2(51.05,149.02) ; CV60.1 55.33,154.27 v2(55.77,153.83) ; CV58.1 60.75,155.88 v2(60.55,155.68) ; v2(52.11,154.83) 51.54,155.4 CV53.1 ; v2(56.87,147.01) 56.41,147.47 CV39.1 ; CV61.1 54.43,148.49 v2(54.11,148.17) ; CV50.1 58.46,151.14 v2(57.77,151.83) ; CV65.1 58.8,157.71 v2(58.42,157.33) ; v2(56.85,148.11) 56.44,148.52 CV51.1 ; v2(52.18,152.88) 51.75,153.32 CV57.1 ; CV45.1 56.04,150.89 v2(56.77,150.17) ; v2(59.9,154.68) 59.9,154.45 60.22,154.13 CV40.1 ; v2(57.13,156.59) 57.19,156.64 CV42.1 ; CV56.1 61.01,155.02 v2(60.65,154.66) ; v2(51.11,151.83) 50.71,151.43 CV46.1 50.71,150.56 v2(51.11,150.17)
  TOP w0.457: v2(56.84,153.09) 56.84,152.86 CV37.1 ; v2(53.06,153.98) 52.78,153.7 CV64.1 ; CV47.1 54.96,156.64 v2(55.84,155.76) ; CV41.1 56.74,157.94 v2(57.22,157.46)
  BOTTOM w0.254: v1(115.03,160.12) 115.02,160.13 115.02,162.56 114.04,163.53 v1(113.95,163.53) ; PR636.2 123.62,162.17 v1(123.76,162.31) ; PR618.2 121.83,163.05 122,162.87 v1(122,162.36) ; v1(88.58,161.83) 88.22,161.47 PL603.2 ; PL604.2 v1(85.7,169.75)
  BOTTOM w0.305: UV3.M11 v2(52.11,154.83) UV3.N12 ; UV3.N15 52.54,152.52 v2(52.18,152.88) 51.67,153.4 UV3.M13 ; v2(54.11,148.17) UV3.T20
  BOTTOM w0.381: UV3.AB11 59.34,155.68 v2(59.64,155.98) ; UV3.V17 v2(56.77,150.17) ; v2(51.11,150.17) UV3.M17 ; v2(51.11,151.83) UV3.M16 ; UV3.M21 51.54,147.55 v2(51.15,147.16) ; v2(56.84,153.09) 56.84,152.9 UV3.V15 ; v2(51.01,152.76) 51.18,152.76 UV3.M15 ; v2(57.88,147.04) 57.88,147.05 UV3.Y21 ; UV3.Y9 57.96,157 58.3,157.33 v2(58.42,157.33) ; UV3.R18 v2(53.11,149.17) ; UV3.V20 56.36,148.6 56.85,148.12 v2(56.85,148.11) ; v2(52.09,148.03) 52.09,148.13 52.54,148.58 UV3.N20 ; v2(54.01,152.75) 54.36,152.4 UV3.T15 ; UV3.W9 56.76,157 v2(57.22,157.46) ; v2(57.84,149.29) 57.85,149.29 57.85,149.29 57.54,149.6 UV3.Y18 ; UV3.AC11 60.14,155.27 v2(60.55,155.68) ; UV3.N17 52.42,150.6 52.04,150.22 v2(52.04,150.2) ; UV3.M18 51.05,149.11 v2(51.05,149.02) ; v2(53.06,153.98) 53.06,153.88 UV3.R13 ; v2(57.77,151.83) UV3.Y16 ; UV3.AA12 58.49,154.4 v2(58.82,154.73) ; v2(56.87,147.01) 56.87,147.07 UV3.V21 ; v2(59.9,154.68) 59.9,154.7 59.59,154.4 UV3.AB12 ; UV3.AB13 v2(58.77,152.83) UV3.AA15 ; v2(60.55,153.47) 60.55,153.19 60.16,152.8 UV3.AC14 ; v2(51.15,148.06) 51.54,148.44 UV3.M20 ; v2(57.77,153.83) UV3.Y13 ; v2(53.11,151.83) UV3.R16 ; v2(53.87,156.52) 54.02,156.52 UV3.T10 ; v2(60.65,154.66) 60.14,154.15 UV3.AC13 ; v2(55.77,151.83) UV3.U16 ; v2(55.77,149.17) UV3.U18 ; v2(57.13,156.59) UV3.W10
  BOTTOM w0.457: v2(55.84,155.76) 55.84,155.89 UV3.U10 ; v2(54.11,154.83) UV3.T12 ; v2(55.77,153.83) UV3.U13 ; v2(55.8,154.94) 55.35,155.4 UV3.U11 ; v2(54.11,150.17) UV3.T17
  vias: v1(73.56,168.49) v1(73.86,169.06) v1(73.86,167.91) v1(74.2,168.49) v1(74.5,169.06) v1(74.51,167.92) v1(74.54,166.78) v1(74.53,165.39) v1(74.83,168.49) v1(74.85,167.34) v1(74.84,166.19) v1(75.13,169.05) v1(75.15,167.92) v1(75.11,164.8) v1(75.18,166.77) v1(75.41,165.36) v1(75.41,164.21) v1(75.47,168.48) v1(75.48,167.34) v1(75.5,166.21) v1(75.75,164.79) v1(75.77,169.05) v1(75.78,167.92) v1(75.82,166.77) v1(76.05,165.36) v1(76.12,169.64) v1(76.13,168.49) v1(76.12,167.33) v1(76.13,166.21) v1(76.06,164.23) v1(76.43,169.06) v1(76.42,167.91) v1(76.39,164.79) v1(76.45,166.76) v1(76.68,165.36) v1(76.7,164.23) v1(76.76,169.64) v1(76.77,168.49) v1(76.76,167.33) v1(76.77,166.2) v1(77.03,163.65) v1(77.06,169.06) v1(77.08,167.92) v1(77.33,164.22) v1(77.33,163.07) v1(77.39,169.63) v1(77.4,168.49) v1(77.7,169.05) v1(77.71,167.92) v1(77.67,163.65) v1(78.03,169.63) v1(78.04,168.48) v1(77.97,164.22) v1(77.98,163.08) v1(78.34,169.04) v1(78.35,167.91) v1(78.31,163.65) v1(78.6,164.21) v1(78.62,163.08) v1(78.7,169.64) v1(78.7,168.48) v1(78.94,163.64) v1(79.01,169.06) v1(79.01,167.92) v1(79.24,164.21) v1(79.34,169.64) v1(79.34,168.47) v1(79.25,163.08) v1(79.65,169.05) v1(79.65,167.91) v1(79.6,163.65) v1(79.9,164.22) v1(79.89,163.07) v1(80,169.65) v1(80,168.48) v1(80.21,166.69) v1(80.21,165.42) v1(80.24,163.65) v1(80.3,169.06) v1(80.3,167.92) v1(80.51,167.26) v1(80.51,165.99) v1(80.52,164.86) v1(80.54,164.22) v1(80.63,169.65) v1(80.63,168.48) v1(80.85,166.69) v1(80.85,165.42) v1(80.94,169.06) v1(80.94,167.92) v1(80.87,163.65) v1(81.14,167.26) v1(81.14,165.99) v1(81.16,164.86) v1(81.17,164.21) v1(81.27,168.47) v1(81.48,166.69) v1(81.48,165.42) v1(81.51,163.64) v1(81.57,169.06) v1(81.57,167.91) v1(81.78,167.25) v1(81.78,165.98) v1(81.79,164.85) v1(81.81,164.2) v2(56.78,150.98)
+VREF_CA: length 24
  TOP w0.508: RD11.1 CD17.1 CD49.1 172.22,129.34 RD9.2 173.12,130.21 v1(173.16,130.25) 173.61,130.7 v4(173.61,130.99) ; v1(160.18,129.74) 160.2,129.77 CD18.1 RD10.1
  IN3 w0.508: v1(173.16,130.25) 171.48,128.57 160.77,128.57 160.18,129.17 v1(160.18,129.74)
  BOTTOM w0.356: JDIMM1.126 v1(173.16,130.25) ; v1(160.18,129.74) 160.05,129.74 159.54,130.25 JDIMM2.126
A_DE0: length 3.5
  TOP w0.114: R9468.2 221.7,99.47 R49.1 222.59,98.66 v4(222.76,98.48) 223.51,97.74 U6.16
A_DE1: length 4.8
  TOP w0.114: U6.18 222.51,97.73 222.35,97.88 221.51,97.88 v4(220.94,98.46) 220.9,98.42 219.96,98.42 219.03,99.35 R52.1
A_EQ0: length 4.2
  TOP w0.114: R50.1 220.78,99.47 R9467.2 221.36,98.9 221.7,98.9 v1(222.1,98.5) 223.01,97.59 U6.17
A_EQ1: length 2.4
  TOP w0.114: R53.1 223.48,98.95 v1(223.93,98.49) 224.01,98.42 U6.15
AA_DE0: length 6.2
  TOP w0.114: U5.16 206.11,97.97 v3(205.47,98.61) 204.83,99.24 R35.1 204.63,99.52 204.34,99.82 204.34,102.69 R9462.2
AA_DE1: length 4.6
  TOP w0.114: v3(201.78,99.52) R37.1 204.12,98.2 204.83,98.2 205.11,97.93 U5.18
AA_EQ0: length 6.9
  TOP w0.114: U5.17 205.61,97.94 204.96,98.58 204.32,98.58 203.82,99.09 R36.1 203.49,99.52 203.29,99.72 v3(203.29,101.85) 203.4,101.95 R9461.2
AA_EQ1: length 5.1
  TOP w0.114: U5.15 206.61,98.21 205.85,98.97 R39.1 205.65,99.52 205.33,99.84 v3(205.33,101.8)
AAA_DE0: length 3.3
  TOP w0.114: R249.1 266.82,125.47 v1(266.35,125) 266.06,124.71 U16.16
  BOTTOM w0.114: R9458.2 266.35,123.99 v1(266.35,125)
AAA_DE1: length 3.1
  TOP w0.114: v4(263.72,125.7) R250.1 265.06,125.68 U16.18
AAA_EQ0: length 3
  TOP w0.114: U16.17 v1(265.56,124.98) 265.56,125.33 R245.1
  BOTTOM w0.114: v1(265.56,124.98) 264.78,124.98 R9457.2
AAA_EQ1: length 2.2
  TOP w0.114: U16.15 266.56,124.55 v1(267.02,125.01) R246.1
AC_PRESENT: length 130.1
  TOP w0.114: UE1.128 179.46,129.17 179.69,128.94 179.69,128 181.05,126.63 v1(181.89,126.63) ; v1(134.74,147.5) 134.37,147.87 133.5,147.87 133.37,148 133.37,148.97 132.76,149.58 131.49,149.58 131.16,149.9 RPC18.8
  BOTTOM w0.076: UC1.AY15 120.57,128.2 120.85,128.2 120.96,128.09 122.53,128.09 122.79,128.35 122.89,128.35
  BOTTOM w0.114: 122.89,128.35 123.38,128.35 125.17,130.15 127.53,130.15 128.93,131.56 130.63,131.56 135.36,136.29 135.36,145.83 135.12,146.07 135.12,147.12 v1(134.74,147.5) 134.74,147.99 135,148.24 135,150.49 137.6,153.09 137.6,156.53 138.82,157.75 146.86,157.75 148.01,158.89 181.34,158.89 182.62,157.62 182.62,142.67 182.11,142.16 182.11,138.22 181.45,137.56 181.45,135.28 181.22,135.05 181.22,127.31 v1(181.89,126.63)
ACIN: length 10.2
  TOP w0.203: UE1.108 187.46,131.65 188.45,132.64 CE12.1
  TOP w0.254: v4(190.95,137.54) 190.24,137.54 DEV1.2 189.41,136.71 RE34.1 189.85,136.05 190.1,135.8 190.1,133.94 189.85,133.69 RE33.1 CE12.1
ACN: length 5
  BOTTOM w0.229: PU101.1 220.61,109.43
  BOTTOM w0.254: PC109.1 PR108.1 PR106.2 221.75,107.42 v4(221.75,108.21) 221.75,108.29 220.61,109.43
ACOFF: length 94.1
  TOP w0.114: v1(192.78,130.88) 192.78,131.29 192.12,131.95 191.75,131.95 191.46,131.65 UE1.98
  TOP w0.254: PR109.1 266.87,112.59 v1(266.88,112.61) 266.88,113.34 v4(266.95,113.41)
  IN1 w0.254: v1(192.78,130.88) 193.41,130.25 193.41,128.32 198.65,123.08 200.8,123.08 204.51,126.79 241.29,126.79 241.3,126.8 243.58,126.8 245.1,128.32 251.33,128.32 256.91,122.73 260.98,122.73 264.58,119.12 264.58,115.95 266.88,113.65 v1(266.88,112.61)
ACP: length 3
  BOTTOM w0.229: PU101.2 220.21,108.93
  BOTTOM w0.254: PR107.2 221.22,107.92 220.21,108.93
ACPRN: length 58.9
  TOP w0.254: v1(214.75,113.71) 214.37,113.33 v4(214.37,112.31) 214.37,108.96 v1(217.79,105.54) ; v1(203.19,115.74) 203.7,116.25 203.7,125.65 198.17,131.18 198.17,136.05 197.04,137.18 192.19,137.18 191.23,138.15 188.53,138.15 188.01,137.63 DEV1.1 188.5,136.96 RE34.2
  IN1 w0.254: v1(214.75,113.71) 214.75,114.02 214,114.78 204.9,114.78 203.93,115.74 v1(203.19,115.74)
  BOTTOM w0.254: v1(217.79,105.54) 217.9,105.66 PR118.1
ADAPTER_ID_ON:
  vias: v4(274.97,106.95)
ADAPTER_ID_ON#: length 122.7
  TOP w0.114: UE1.118 183.46,131.92 v1(181.73,133.65)
  TOP w0.254: v1(228.47,128.57) 228.47,128.96 229.73,130.22 233.51,130.22 234.28,129.46 248.4,129.46 250.82,127.05 251.72,127.05 257.66,121.11 257.66,120.53 259.39,118.79 261.99,118.79 266.9,113.89 270.25,113.89 270.94,113.2 272.2,113.2 274.47,110.94 274.47,109.28 273.31,108.12 273.31,105.8 272.55,105.04 272.55,103.94 273.45,103.04 v4(274.44,103.04) 274.86,103.04 275.62,103.81 PQ4.5
  IN1 w0.14: v1(228.47,128.57) 224.59,132.45 215.45,132.45 211.94,135.95 203.01,135.95 199.9,132.84 188.52,132.84 188.12,132.44 183.48,132.44 182.28,133.65 v1(181.73,133.65)
ADDR_SEL: length 6.2
  TOP w0.203: RC347.1 RC292.2 176.55,108.94 176.55,109.11 176.84,109.4 v4(179.16,109.4) 179.43,109.4 180.14,108.7 UGSEN1.7
ADP_I: length 30.8
  TOP w0.114: v1(213.6,108.29) 213.6,108.49 213.61,108.5 v4(213.61,110.66) v1(213.61,113.71) ; v1(198.9,117.65) 198.32,118.23 197.99,118.23 197.73,118.49 194.99,118.49 194.31,119.17 UE1.71
  IN1 w0.14: v1(213.61,113.71) 213.43,113.89 203.32,113.89 199.56,117.65 v1(198.9,117.65)
  BOTTOM w0.254: v1(213.6,108.29) 213.6,106.97 213.85,106.71 PC125.2 214.28,107.55 PR122.1
ADP_ID: length 99.5
  TOP w0.203: 194.41,119.97 UE1.73
  TOP w0.254: v1(199.31,118.89) 199.28,118.92 198.19,118.92 197.96,119.15 195.24,119.15 194.41,119.97
  IN1 w0.254: v1(199.31,118.89) 200.47,117.72 200.47,117.24 203.32,114.4 213.76,114.4 214.24,113.91 214.24,113.1 214.61,112.73 216.04,112.73 219.47,109.31 219.49,109.31 222.38,106.42 226.38,106.42 231.64,101.16 241.62,101.16 241.75,101.3 247.59,101.3 248.91,102.61 251.88,102.61 252.23,102.95 257.6,102.95 258.91,101.65 273.42,101.65 278.12,106.35 v1(278.12,109.39)
  vias: v4(277.87,107.62)
ALL_PWRGD: length 3
  TOP w0.114: UE1.29 176.72,117.97 176.58,117.83 176.36,117.83 175.49,116.96 RE41.2
AOU_CTL1: length 103.4
  TOP w0.114: v1(195.18,110.65) 194.64,110.65 193.51,109.52 191.14,109.52 184.59,102.97 179.74,102.97 178.9,102.14 178.01,102.14 175.72,99.86 175.72,98.47 172.05,94.8 172.05,90.29 168.63,86.87 165.94,86.87 163.43,84.35 162.02,84.35 159.45,81.78 153.05,81.78 148.99,77.71 137.67,77.71 135.44,75.48 v4(135.07,75.48) 133.73,74.14 133.73,68.64 134.16,68.2 U14.6 ; v1(192.13,123.49) 192.13,123.86 192.64,124.37 UE1.84
  IN3 w0.114: v1(192.13,123.49) 194.36,121.26 194.36,111.47 v1(195.18,110.65)
AOU_CTL3: length 91.5
  TOP w0.203: UE1.48 v1(185.46,113.84)
  TOP w0.254: U14.8 134.71,67.2 134.6,67.09 133.92,67.09 133.78,67.23
  TOP w0.508: v1(147.34,78.94) 146.88,78.94 146.53,79.29 138.5,79.29 v4(136.14,76.93) 135.63,76.93 133.08,74.38 133.08,67.93 133.78,67.23
  IN1 w0.508: v1(185.46,113.84) 185.46,109.56 184.79,108.9 183.27,108.9 182.11,107.74 180.71,107.74 180.33,108.12 177.92,108.12 176.09,106.29 176.09,90.67 171.93,86.52 166.54,86.52 158.96,78.94 v1(147.34,78.94)
AOU_EN: length 104.2
  TOP w0.114: v1(192.14,122.86) 191.64,123.36 191.64,124 192.41,124.77 UE1.85 ; v1(195.2,110.01) 194.34,110.01 193.61,109.28 191.24,109.28 184.69,102.73 179.84,102.73 179,101.9 178.11,101.9 175.97,99.76 175.97,98.37 172.3,94.7 172.3,90.19 168.73,86.62 166.04,86.62 163.53,84.11 162.12,84.11 159.55,81.53 153.15,81.53 149.09,77.47 137.77,77.47 133.97,73.67 133.97,71.33 v4(134.33,70.96) 133.97,70.6 133.97,68.74 134.17,68.54 134.83,68.54 135,68.7 U14.5
  IN3 w0.114: v1(192.14,122.86) 194.11,120.89 194.11,111.1 v1(195.2,110.01)
AOU_IFG#: length 96.6
  TOP w0.114: v1(178.67,102.66) 178.15,102.66 175.48,100 175.48,98.57 171.81,94.9 171.81,90.39 168.53,87.11 165.84,87.11 163.33,84.59 161.88,84.59 159.31,82.02 148.77,82.02 146.48,79.73 137.79,79.73 v4(136.75,78.68) 132.57,74.51 132.57,67.82 134.47,65.92 135.97,65.92 136.21,66.16 U14.9 ; UE1.25 v1(179.19,119.57) ; RPE1.7 v1(176.13,120.93)
  IN1 w0.14: v1(176.13,120.93) 177.27,119.79 178.96,119.79 v1(179.19,119.57)
  IN3 w0.114: v1(179.19,119.57) 179.69,119.07 179.69,118.49 179.1,117.91 179.1,109.91 179.81,109.2 179.81,106.74 178.67,105.6 v1(178.67,102.66)
APDIN:
  vias: v4(282.26,107.08) v4(282.44,101.01) v4(282.47,102.81)
B+: length 52
  IN2 w0.508: 77.89,59 77.89,58.13 v1(73.26,53.5)
  IN3 w0.254: v1(222.21,104.65) 222.71,104.65 223.83,103.54 243.77,103.54 248.14,99.17 254.44,99.17 255.94,100.67 v1(257.28,100.67)
  BOTTOM w0.254: PR401.1 v1(73.26,53.5) ; PC106.1 222.84,104.65 v1(222.21,104.65) 222.21,105.21 PC105.1 222.08,105.34 PR106.1 ; v1(257.28,100.67) 257.13,100.67 256.84,100.38 PR101.2 ; PD3.2 228.38,127.72 v1(228.25,127.85)
  BOTTOM w0.508: PD103.2 v1(228.44,107.89)
  vias: v1(65.14,112.95) v1(65.52,112.31) v1(66.29,112.31) v1(67.05,112.31) v1(74.86,94.67) v1(75.5,94.67) v1(76.13,94.67) v1(76.68,95.09) v1(77.32,95.09) v1(77.39,71.5) v1(77.64,69.03) v1(78.07,71.5) v1(78.07,70.87) v1(78.07,70.23) v1(78.07,69.6) v1(78.67,71.2) v1(78.67,70.57) v1(78.67,69.93) v1(78.67,69.3) v1(79.32,70.94) v1(79.27,70.25) v1(111.49,159.6) v1(111.59,158.96) v1(111.63,158.29) v1(112.12,159.6) v1(112.25,158.96) v1(112.33,161.5) v1(112.33,160.87) v1(112.33,160.23) v1(112.26,158.26) v1(112.73,162.01) v1(154.79,174.99) v1(154.79,174.35) v1(154.79,173.72) v1(155.35,174.68) v1(155.35,174.05) v1(155.94,174.96) v1(155.94,174.33) v1(155.94,173.69) v1(156.5,174.66) v1(156.5,174.02) v1(174.96,167.27) v1(174.96,166.63) v1(174.96,166) v1(175.52,167.6) v1(175.52,166.96) v1(175.52,166.33) v1(195.04,173.88) v1(195.01,172.66) v1(195.32,174.47) v1(195.32,173.27) v1(195.39,175.74) v1(195.62,172.36) v1(195.75,175.18) v1(196.11,175.74) v1(196.16,171.95) v1(196.46,175.18) v1(201.02,89.57) v1(201.4,88.93) v1(201.78,89.57) v1(202.17,88.93) v1(202.55,89.57) v1(202.93,88.93) v1(203.31,89.57) v1(203.69,88.93) v1(204.07,89.57) v1(204.45,88.93) v1(204.83,89.57) v1(205.21,88.93) v1(205.59,89.57) v1(205.98,88.93) v1(206.36,89.57) v1(206.74,88.93) v1(207.12,89.57) v1(207.5,88.93) v1(207.88,89.57) v1(208.26,88.93) v1(208.64,89.57) v1(209.02,88.93) v1(209.4,89.57) v1(209.79,88.93) v1(211.54,173.01) v1(211.54,172.32) v1(212.17,173.01) v1(212.17,172.32) v1(212.81,173.01) v1(212.81,172.32) v1(213.44,173.01) v1(213.44,172.32) v1(218.13,127.53) v1(218.28,128.19) v1(218.76,127.71) v1(218.94,128.37) v1(229.55,120.5) v1(229.85,121.06) v1(230.21,120.5) v1(230.51,121.06) v1(230.84,120.48) v1(231.15,121.04) v1(231.48,120.48) v1(250.25,100.01) v1(250.88,100.01) v1(251.19,100.57) v1(251.54,101.12) v1(251.52,100.01) v1(251.85,100.57) v1(252.2,101.12) v1(252.18,100.01) v1(252.51,100.57) v1(252.84,101.12) v1(252.81,100.01) v1(253.14,100.57) v1(253.45,100.01) v1(253.47,101.12) v1(253.78,100.57) v1(254.13,101.1) v4(196.26,173.73)
B+_1.35V: length 23.8
  TOP w0.254: PR309.1 v1(185.58,172.14)
  IN1 w0.254: v1(185.58,172.14) 186.3,172.87 186.3,174.8 185.29,175.81 176.14,175.81 173.47,173.15 173.47,169.46 172.44,168.43 v1(171.84,168.43)
  vias: v1(170.48,169.24) v1(170.5,168.58) v1(171.15,168.49) v1(171.84,169.09) v4(169.48,169.15)
B_DE0: length 2.9
  TOP w0.114: U6.3 223.51,92.32 v1(223.26,92.07) 222.84,91.65 R54.1
  BOTTOM w0.114: v1(223.26,92.07) 223,92.32 R9466.2
B_DE1: length 3.4
  TOP w0.114: v3(227.18,91.5) R56.1 225.89,91.5 225.01,92.38 U6.6
B_EQ0: length 3.7
  TOP w0.114: R55.1 221.95,92.08 v1(222.03,92.16) 222.44,92.16 223.01,92.73 U6.2
  BOTTOM w0.114: R9465.2 221.76,92.44 v1(222.03,92.16)
B_EQ1: length 2
  TOP w0.114: U6.4 v1(224.01,92.15) 223.73,91.87 R57.1
BATLOW#: length 28.2
  TOP w0.114: RPC18.7 v1(129.9,150.4)
  IN3 w0.114: v2(118.58,129.36) 120.02,130.79 120.02,131.95 122.77,134.7 122.77,135.5 123.58,136.31 123.58,139.01 125.3,140.73 127.02,140.73 129.24,142.94 129.24,147.39 129.46,147.61 129.46,149.97 v1(129.9,150.4)
  BOTTOM w0.076: UC1.AU13 118.3,129.68 118.58,129.4 v2(118.58,129.36)
BATT+: length 60.2
  IN3 w0.254: v1(218.12,117.84) 218.45,117.84 225.2,124.59 246.77,124.59 252.08,119.29 252.08,105.21 v1(249.99,103.13)
  BOTTOM w0.254: v1(218.12,117.84) 218.75,117.84 PC124.2 219.18,117.41 PR128.1 218.19,116.9 PC123.1 ; v1(249.99,103.13) 250.29,103.42 PR117.2
BATT_TEMP: length 75.2
  TOP w0.203: UE1.68 194.59,117.97 194.91,117.65 194.91,117.32 196.12,116.11 CE16.1
  TOP w0.254: v1(252.18,128.25) 252.18,128.48 250.82,129.84 234.43,129.84 233.67,130.6 229.57,130.6 219.68,120.71 v4(219.68,120.44) 219.68,118.14 217.04,115.49 217.04,114.19 v1(217.46,113.77) ; v1(201.16,117.88) 201.16,117.45 199.28,115.57 197.05,115.57 CE16.1
  IN1 w0.254: v1(201.16,117.88) 202.52,117.88 205.03,115.36 215.87,115.36 v1(217.46,113.77)
  BOTTOM w0.254: PR17.2 v1(252.18,128.25)
BB_DE0: length 3.3
  TOP w0.114: R40.1 206.99,91.75 206.42,92.32 v1(206.42,92.45) 206.37,92.5 206.37,92.76 206.11,93.02 U5.3
  BOTTOM w0.114: R9464.2 206.49,92.38 v1(206.42,92.45)
BB_DE1: length 3.9
  TOP w0.114: R42.1 210.32,91.7 v3(209.58,92.44) 209.1,92.92 207.75,92.92 207.61,93.06 U5.6
BB_EQ0: length 3.1
  TOP w0.114: U5.2 205.61,92.58 v1(205.71,92.48) 206.05,92.13 v4(206.05,91.99) R41.1
  BOTTOM w0.114: v1(205.71,92.48) 205.68,92.45 R9463.2
BB_EQ1: length 2.6
  TOP w0.114: R43.1 207.88,91.88 v3(207.47,92.29) 207.27,92.29 206.61,92.95 U5.4
BBB_DE0: length 5.5
  TOP w0.114: R9460.2 268.45,115.64 268.45,117.5 268.09,117.85 R251.1 267.52,118.29 267.38,118.29 266.85,118.83 v4(266.81,118.83) 266.81,118.89 266.06,119.64 U16.3
BBB_DE1: length 4.7
  TOP w0.114: U16.6 267.56,119.57 267.68,119.46 268.72,119.46 v4(270.02,118.16) 270.32,117.85 R252.1
BBB_EQ0: length 5.3
  TOP w0.114: R9459.2 267.43,115.64 267.43,117.62 267.2,117.85 R247.1 266.9,118.16 v1(266.03,119.02) 265.56,119.49 U16.2
BBB_EQ1: length 3.6
  TOP w0.114: R248.1 268.98,118.05 268.25,118.78 v1(268.11,118.78) 267.43,118.78 266.56,119.65 U16.4
BEEP#: length 92.3
  TOP w0.114: v1(176.52,115.14) 177.24,115.86 177.4,115.86 177.83,116.28 UE1.32 ; CA22.1 193.53,67.15 192.48,68.21 187.5,68.21 184.77,65.48 174.21,65.48 173.82,65.08 173.82,62.23 173.34,61.75 172.14,61.75 DA1.2 170.95,66.25 v4(170.93,66.26) 170.25,66.95 170.25,75.74 175.84,81.33 176.35,81.33 178.46,83.44 178.46,84 182.85,88.39 182.85,89.51 v1(182.42,89.95)
  IN3 w0.114: v1(182.42,89.95) 180.86,89.95 175.93,94.87 175.93,112.1 176.45,112.63 176.45,115.07 v1(176.52,115.14)
BKOFF#: length 224.2
  TOP w0.114: v1(183.13,129.45) 183.06,129.52 UE1.119 ; v1(55.18,114.59) 55.2,114.61 55.2,114.95 55.53,115.28 JLCD.11
  IN3 w0.114: v1(180.46,91.36) 180.13,91.36 176.42,95.06 176.42,111.73 176.94,112.25 176.94,114.3 177.51,114.88 177.51,128.82 179.16,130.46 182.11,130.46 v1(183.13,129.45)
  BOTTOM w0.114: v1(180.46,91.36) 180.24,91.14 177.28,91.14 177.01,90.87 177.01,89.35 167.5,79.85 161.38,79.85 160.96,79.43 128.51,79.43 127.3,78.22 106.4,78.22 105.74,77.56 102.48,77.56 101.71,76.79 96.66,76.79 94.31,79.14 89.99,79.14 80.97,88.16 80.97,112.64 79.47,114.15 79.47,115.51 69.74,125.24 61.18,125.24 59.42,123.48 59.42,122.89 59.93,122.38 59.93,120.78 57.22,118.07 R26.1 55.18,116.95 v4(55.18,115.74) v1(55.18,114.59)
BOARD_ID: length 4.6
  TOP w0.114: UE1.69 194.67,118.37 195.32,117.72 v3(195.32,117.45) 195.64,117.13 RE7.2 196.5,117.99 RE3.1
BQ24780_BATDRV: length 58.1
  IN3 w0.254: v1(250.17,102.04) 249.31,102.9 249.31,104.08 250.98,105.75 250.98,118.55 246.16,123.37 225.89,123.37 221.11,118.6 221.11,116.75 v1(219.16,114.79)
  BOTTOM w0.114: 219.41,113.68 PU101.18
  BOTTOM w0.203: v1(219.16,114.79) 219.41,114.54 219.41,113.68
  BOTTOM w0.254: v1(250.17,102.04) PQ104.4
BQ24780_VDD: length 4.3
  BOTTOM w0.229: 222.14,112.06 PU101.24
  BOTTOM w0.254: 222.14,112.06 222.62,112.06 223.09,112.53 PC116.1 224.06,113.51 224.31,113.76 v4(224.4,113.76)
BST_1.00VS:
  vias: v1(147,170.52) v1(147,169.88) v4(146.7,171.67)
BST_CHG:
  vias: v4(222.98,111.76)
BT_ON: length 196.5
  TOP w0.114: RPC10.1 110.08,155.34 109.2,154.46 v1(109.2,153.45) ; v1(257.55,151.68) 257.92,152.05 R239.1 R150.2
  IN3 w0.114: v2(116.2,134.95) 116.71,135.45 116.71,140.76 113.42,144.05 113.42,147.94 113.01,148.34 111.37,148.34 110.07,149.64 108.82,149.64 108.14,150.32 108.14,152.39 v1(109.2,153.45) 109.64,153.89 115.19,153.89 119.4,158.1 125.63,158.1 126.87,159.33 130.27,159.33 131.04,158.56 134.52,158.56 135.29,159.33 145,159.33 146.03,160.36 161.24,160.36 161.81,160.93 180.57,160.93 191.55,149.96 191.55,148.67 v1(191.24,148.37)
  BOTTOM w0.076: v2(116.2,134.95) 116.35,134.79 UC1.AP5
  BOTTOM w0.114: v1(191.24,148.37) 192.04,149.16 201.65,149.16 v4(202.05,148.76) 207.4,143.42 229.14,143.42 238.23,152.51 247.63,152.51 249.52,150.62 257.14,150.62 257.55,151.03 v1(257.55,151.68)
BT_ON_R: length 4.9
  TOP w0.114: v1(256.65,153.96) 256.65,153.65 R90.1 R239.2 v4(257.92,154.46)
  BOTTOM w0.114: v1(256.65,153.96) 256.14,153.96 255.7,154.4 JWLBT.54
BYPASS_PAD: length 9.6
  TOP w0.114: JCP.1 117.66,65.67 v4(119.87,67.88) v1(120.68,68.69)
  BOTTOM w0.114: R108.2 R61.2 119.79,69.37 R66.2 v1(120.68,68.69)
C_COVER_LOGO: length 4.2
  TOP w0.203: JLOGO.1 280.79,25.56 281.06,25.83 R84.2 v4(279.65,27.26)
CFG0: length 16.3
  BOTTOM w0.076: UC1.E68 100.41,99.07 100.15,99.14 99.89,99.18 99.7,99.23 99.55,99.28 99.51,99.28 99.5,99.28 99.39,99.28 99.33,99.28 99.25,99.26 99.16,99.25 99.02,99.25 98.92,99.28 98.57,99.28 98.56,99.28 98.41,99.28 98.26,99.13 97.94,99.13 97.39,98.58
  BOTTOM w0.114: RC105.2 87.33,96.22 88.29,96.22 88.58,96.5 RC201.2 90.14,96.68 TP36.1 90.72,96.11 92,96.11 93.71,97.82 97.08,97.82 97.39,98.13 97.39,98.58
CFG1: length 11.1
  BOTTOM w0.076: UC1.B67 99.26,98.85 98.9,98.49 98.67,98.49 98.5,98.32 98.28,98.1 98.05,98.1 97.93,97.99
  BOTTOM w0.114: 97.93,97.99 97.15,97.21 93.77,97.21 92.06,95.49 89.97,95.49 TP38.1
CFG2: length 11
  BOTTOM w0.076: UC1.D65 100.41,99.98 100.15,99.91 100.03,99.91 99.55,99.77 99.3,99.77 99.21,99.8 99.02,99.8 98.92,99.77 98.56,99.77 98.39,99.94 97.96,99.94 97.67,99.65 97.67,99.12 97.14,98.58
  BOTTOM w0.114: 97.14,98.58 96.73,98.18 92.94,98.18 TP40.1
CFG3: length 13.9
  BOTTOM w0.076: 97.64,98.57 98.04,98.97 98.33,98.97 98.48,99.12 98.9,99.12 99.01,99.06 99.16,99.06 99.35,99.12 99.53,99.12 99.78,99.03 UC1.D67
  BOTTOM w0.114: TP41.1 88.79,95.86 90.11,95.86 90.23,95.73 91.96,95.73 93.67,97.45 97.05,97.45 97.64,98.04 97.64,98.57
CFG4: length 18.6
  BOTTOM w0.076: UC1.E70 101.09,96.81 100.89,96.61 100.89,96.28 100.68,96.06 100.68,95.9 100.34,95.56
  BOTTOM w0.114: RC144.2 87.05,91.32 TP42.1 ; RC144.2 87.71,92.62 88.42,93.33 91.72,93.33 92.93,94.54 99.32,94.54 100.34,95.56 ; RC144.2 RC104.2
CFG5: length 13.8
  TOP w0.114: v2(99.99,97.64) 98.96,97.64 98.74,97.42 96.85,97.42 94.95,95.51 94.32,95.51 91.97,93.16 89.73,93.16 TP44.1
  BOTTOM w0.076: v2(99.99,97.64) UC1.C68
CFG6: length 12.7
  TOP w0.114: TP46.1 90.75,92.91 92.06,92.91 94.42,95.27 95.05,95.27 96.74,96.97 v2(100.6,96.97)
  BOTTOM w0.076: UC1.D68 v2(100.6,96.97)
CFG7: length 10
  TOP w0.114: TP47.1 92.25,93.8 94.2,95.75 94.85,95.75 96.84,97.75 98.51,97.75 99.01,98.24 v2(99.29,98.24)
  BOTTOM w0.076: UC1.C67 v2(99.29,98.24)
CFG8: length 15.7
  BOTTOM w0.076: UC1.F71 101.65,96.82 101.65,95.52 101.47,95.34
  BOTTOM w0.114: 101.47,95.34 101.03,94.9 100.97,94.9 100.13,94.06 93.13,94.06 91.23,92.16 89.37,92.16 TP48.1
CFG9: length 26.2
  BOTTOM w0.076: 102.33,95.03 102.33,96 102.61,96.28 102.61,96.54 102.55,96.66 102.55,96.8 102.62,97.03 102.62,97.17 102.54,97.38 102.54,97.64 UC1.G69
  BOTTOM w0.114: TP50.1 89.43,89.36 90.11,89.36 90.8,88.67 90.8,88.23 94.14,84.89 97.82,84.89 100.93,87.99 100.93,93.49 102.33,94.9 102.33,95.03
CFG10: length 14.3
  BOTTOM w0.076: UC1.F70 101.45,97.21 101.45,96.61 101.47,96.59 101.47,95.62 101.13,95.28
  BOTTOM w0.114: 101.13,95.28 101.01,95.28 100.03,94.3 93.03,94.3 91.79,93.06 90.76,93.06 TP52.1
CFG11: length 17.8
  BOTTOM w0.076: 101.67,95.26 101.83,95.42 101.83,96.42 102.08,96.98 102.08,97.24 102.15,97.32 102.15,97.78 102.17,97.85 UC1.G68
  BOTTOM w0.114: TP53.1 89.42,91.88 91.29,91.88 93.23,93.82 100.23,93.82 101.67,95.26
CFG12: length 26.3
  BOTTOM w0.076: UC1.H70 103.24,97.18 103.24,96.95 103.29,96.82 103.29,96.71 103.24,96.57 103.24,96 103.31,95.92 103.31,95.62 102.85,95.16 102.85,94.93
  BOTTOM w0.114: 102.85,94.93 102.85,94.73 101.41,93.29 101.41,87.79 98.02,84.41 93.76,84.41 89.61,88.56 TP55.1
CFG13: length 23.1
  BOTTOM w0.076: UC1.G71 102.16,96.26 102.16,95.15 102.09,95.08
  BOTTOM w0.114: TP56.1 91.24,88.91 91.24,88.13 94.24,85.13 97.72,85.13 100.69,88.09 100.69,93.59 102.09,95 102.09,95.08
CFG14: length 24.9
  BOTTOM w0.076: UC1.H69 102.74,97.79 102.74,97.33 102.79,97.17 102.79,97.03 102.73,96.81 102.73,96.69 102.77,96.58 102.77,96.17 102.53,95.92 102.53,95.28 102.58,95.22
  BOTTOM w0.114: TP57.1 90.32,88.35 94.03,84.65 97.92,84.65 101.17,87.89 101.17,93.39 102.58,94.8 102.58,95.22
CFG15: length 15.3
  BOTTOM w0.076: 101.8,95.05 102,95.25 102,96.38 102.2,96.8 102.34,96.94 UC1.G70
  BOTTOM w0.114: 101.8,95.05 100.33,93.57 93.37,93.57 91.26,91.47 90.54,91.47 TP58.1
CFG16: length 14
  TOP w0.114: TP61.1 90.72,95.52 92.52,95.52 93.72,96.72 94.18,96.72 98.15,100.69 101.05,100.69 v2(101.29,100.93)
  BOTTOM w0.076: UC1.E63 v2(101.29,100.93)
CFG17: length 13.3
  TOP w0.114: v2(101.92,100.93) 101.92,100.91 101.4,100.39 98.19,100.39 94.28,96.48 93.83,96.48 92.45,95.09 TP63.1
  BOTTOM w0.076: UC1.F63 v2(101.92,100.93)
CFG18: length 13.7
  TOP w0.114: TP62.1 90.72,94.2 92.3,94.2 94.09,95.99 94.75,95.99 96.75,98 98.23,98 99.12,98.9 v2(101.29,98.9)
  BOTTOM w0.101: UC1.E66 v2(101.29,98.9)
CFG19: length 16
  TOP w0.114: v2(101.92,98.9) 101.92,99.01 101.61,99.32 100.87,99.32 100.69,99.14 97.55,99.14 94.65,96.23 93.97,96.23 92.19,94.46 89.76,94.46 TP65.1
  BOTTOM w0.101: UC1.F66 v2(101.92,98.9)
CFG_RCOMP: length 1.8
  TOP w0.254: v4(101.61,103.33) 101.61,103.18 v2(101.29,102.86) 101.25,102.83 RC152.1
  BOTTOM w0.254: v2(101.29,102.86) 101.32,102.94 UC1.E60
CHG: length 115.9
  IN3 w0.254: v1(218.35,115.02) 218.35,114.71 218.78,114.28 219.46,114.28 221.62,116.44 221.62,118.47 226.09,122.94 245.96,122.94 250.48,118.42 250.48,105.88 246.87,102.27 v1(246.87,101.81) ; v1(220.35,117.81) 220.35,118.98 225.53,124.16 246.54,124.16 251.52,119.18 251.52,105.57 v1(249.82,103.87)
  BOTTOM w0.203: PU101.17 219.01,114.26 218.69,114.58 218.69,114.68 v1(218.35,115.02)
  BOTTOM w0.254: v1(249.82,103.87) 249.37,103.42 PR117.1 ; v1(220.35,117.81) PC124.1 219.69,117.63 PR125.1 221.37,116.9 PC122.1
CL_CLK_WLAN: length 191.4
  IN3 w0.114: v2(101.71,138.84) 102.46,139.59 102.46,142.02 103.64,143.2 103.64,145.5 103.16,145.98 103.16,149.58 108.79,155.22 114.33,155.22 118.73,159.62 125.01,159.62 126.77,161.38 130.3,161.38 130.72,160.96 143.38,160.96 144.11,161.69 160.68,161.69 161.25,162.26 181.13,162.26 192.95,150.44 v1(192.95,150.08)
  BOTTOM w0.076: v2(101.71,138.84) 102.05,138.5 102.05,137.5 101.87,137.32 101.87,136.93 102.03,136.52 102.03,136.23 102.3,135.97 UC1.G3
  BOTTOM w0.114: v1(192.95,150.08) 192.95,150.53 193.17,150.75 202.82,150.75 207.6,145.96 229.92,145.96 241.36,157.4 245.99,157.4 v4(247.38,158.78) 253.09,158.78 255.14,156.74 258.08,156.74 258.7,156.12 JWLBT.42
CL_DATA_WLAN: length 194.7
  TOP w0.114: v1(258.82,153.96) 258.81,153.94 R150.1
  IN3 w0.114: v2(101.71,139.48) 102.09,139.86 102.09,142.17 103.27,143.35 103.27,145.35 102.79,145.83 102.79,149.74 108.64,155.59 114.18,155.59 118.58,159.99 124.86,159.99 126.62,161.75 130.66,161.75 130.82,161.59 131.68,161.59 132.15,162.06 160.53,162.06 161.1,162.63 181.28,162.63 193.39,150.52 193.39,148.89 v1(193.91,148.37)
  BOTTOM w0.076: v2(101.71,139.48) 101.71,139.4 102.23,138.88 102.23,137.45 102.03,137.25 102.03,136.96 102.16,136.71 102.3,136.56 UC1.G2
  BOTTOM w0.114: JWLBT.40 259.2,155.42 259.2,154.34 v1(258.82,153.96) 258.82,151.81 257.39,150.38 249.42,150.38 248.25,151.54 237.61,151.54 229.24,143.17 206.88,143.17 v4(202.94,147.11) 201.13,148.92 194.46,148.92 v1(193.91,148.37)
CL_RST_WLAN#: length 204.6
  TOP w0.114: v1(258.95,156.51) 258.19,156.51 256.14,154.46 256.14,150.53 255.81,150.2 R151.1
  IN3 w0.114: v1(194.55,148.37) 193.63,149.28 193.63,150.62 181.38,162.87 161,162.87 160.43,162.3 151.03,162.3 149.88,163.45 148.28,163.45 147.13,162.3 132.05,162.3 131.58,161.83 130.92,161.83 130.76,161.99 126.52,161.99 124.76,160.23 118.48,160.23 114.08,155.83 108.54,155.83 102.55,149.84 102.55,145.73 103.03,145.25 103.03,143.45 101.85,142.27 101.85,140.25 v2(101.71,140.11)
  BOTTOM w0.076: UC1.G1 102.3,137.28 102.41,137.39 102.41,138.96 102.1,139.26 102.1,139.72 v2(101.71,140.11)
  BOTTOM w0.114: v1(258.95,156.51) 259.2,156.51 259.7,156.01 JWLBT.38 259.7,153.83 259.06,153.19 259.06,151.71 257.49,150.14 249.32,150.14 248.15,151.3 237.71,151.3 229.34,142.93 206.27,142.93 v4(203.83,145.37) 200.52,148.68 194.86,148.68 v1(194.55,148.37)
CLK_PCI_EC: length 115.6
  TOP w0.114: v1(125.24,138.68) 124.94,138.68 124.38,138.12 124.38,137.23 124.78,136.83 128.03,136.83 128.49,136.37 CC537.1 128.52,136.32 RC24.2 ; UE1.13 179.45,124.37 180.05,123.77 183.27,123.77 183.63,123.4 188.85,123.4 190.92,125.47 v1(190.92,126.26)
  IN3 w0.114: v1(190.92,126.26) 190.82,126.36 190.82,132.2 187.93,135.1 187.93,137.36 185.36,139.92 183.74,139.92 181.22,142.44 181.22,144.8 174.47,151.56 170.91,151.56 170.78,151.68 161.14,151.68 159.01,153.82 151.33,153.82 151.12,154.02 142.31,154.02 141.65,153.36 140.05,153.36 137.76,151.07 137.76,148.53 137.15,147.93 135.98,147.93 135.83,148.08 134.66,148.08 134.26,147.67 134.26,147.16 131.41,144.32 131.41,141.78 130.12,140.48 128.69,140.48 127.52,139.31 125.74,139.31 125.24,138.81 v1(125.24,138.68)
CLK_PCIE_CR: length 136
  TOP w0.114: JCR.8 167.95,55.28 167.8,55.42 167.8,58.97 168.03,59.2 168.03,74.12 167.41,74.75 166.77,74.75 166.5,75.02 v1(166.5,75.28)
  IN1 w0.14: v2(101.29,114.75) 101.42,114.75 101.56,114.89 101.56,115.17 101.32,115.42 98.36,115.42 97.01,114.08 93.56,114.08 92.55,113.07 92.55,106.53 96.34,102.74 96.34,96.88 95.44,95.98 95.44,95.23 96.03,94.65 99.34,94.65 100.45,93.54 104.05,93.54 108.36,89.23 108.36,83.77 113.94,78.19 139.66,78.19 140.61,77.24 163.77,77.24 166.16,74.84 166.32,74.84 166.5,75.03 v1(166.5,75.28)
  BOTTOM w0.076: v2(101.29,114.75) 101.43,114.75 101.6,114.91 101.6,115.12 UC1.E38
CLK_PCIE_CR#: length 136
  TOP w0.114: v1(166.48,74.42) 166.57,74.52 167.31,74.52 167.81,74.03 167.81,59.29 167.57,59.06 167.57,55.42 167.45,55.3 JCR.7
  IN1 w0.14: v2(101.92,114.75) 101.84,114.83 101.84,115.26 101.42,115.68 98.25,115.68 96.9,114.33 93.45,114.33 92.3,113.18 92.3,106.42 96.09,102.63 96.09,96.98 95.19,96.08 95.19,95.13 95.92,94.39 99.24,94.39 100.34,93.29 103.95,93.29 108.11,89.12 108.11,83.67 113.84,77.94 139.55,77.94 140.5,76.99 163.66,76.99 166.06,74.59 166.31,74.59 v1(166.48,74.42)
  BOTTOM w0.076: UC1.E40 101.51,114.33 v2(101.92,114.75)
CLK_PCIE_LAN: length 213
  TOP w0.114: v1(205.57,106.33) 205.57,106.13 205.72,105.98 206.07,105.98 210.14,101.9 226.99,101.9 229.69,99.19 238.32,99.19 241.33,96.19 244.35,96.19 248.38,92.16 250.57,92.16 250.66,92.24 UL1.44
  IN1 w0.14: v1(205.57,106.33) 205.57,106.19 205.35,105.97 200.78,105.97 191.24,96.43 191.24,90.08 180.19,79.03 174.47,79.03 173.46,78.02 140.93,78.02 139.92,79.03 114.2,79.03 112,81.24 112,82.02 109.25,84.76 109.25,89.63 104.43,94.46 100.63,94.46 99.6,95.48 98.61,95.48 97.18,96.91 97.18,103.13 93.33,106.98 93.33,111.21 94.06,111.94 94.06,112.5 94.26,112.7 v1(94.29,112.7)
  BOTTOM w0.076: UC1.C40 100.25,113.55 100.39,113.55 100.46,113.63 100.46,113.88 100.36,113.99 100.05,114.02 99.87,113.94 99.66,113.94 99.53,113.98 99.35,113.98 99.16,113.93 99.01,113.93 98.9,113.98 98.63,113.98 98.48,113.83 97.9,113.83 97.53,114.2 97.39,114.2 97.36,114.17 97.34,114.17
  BOTTOM w0.114: v1(94.29,112.7) 94.25,112.7 94.04,112.91 94.04,113.11 95.09,114.17 97.34,114.17
CLK_PCIE_LAN#: length 213.1
  TOP w0.114: v1(205.56,105.57) 205.74,105.75 205.97,105.75 210.05,101.67 226.89,101.67 229.6,98.97 238.22,98.97 241.23,95.96 244.26,95.96 248.29,91.93 250.59,91.93 250.67,91.84 UL1.45
  IN1 w0.14: v1(93.65,112.7) 93.8,112.55 93.8,112.04 93.07,111.31 93.07,106.88 96.93,103.02 96.93,96.8 98.5,95.23 99.5,95.23 100.52,94.2 104.32,94.2 109,89.53 109,84.66 111.74,81.91 111.74,81.13 114.1,78.77 139.81,78.77 140.82,77.76 173.57,77.76 174.58,78.77 180.3,78.77 191.5,89.97 191.5,96.32 200.89,105.71 205.42,105.71 v1(205.56,105.57)
  BOTTOM w0.076: UC1.D40 100.63,113.83 100.63,113.95 100.44,114.14 100.03,114.19 99.87,114.12 99.84,114.11 99.68,114.11 99.55,114.15 99.3,114.15 99.21,114.12 99.21,114.11 99.02,114.11 98.96,114.14 98.93,114.15 98.56,114.15 98.41,114 97.97,114 97.6,114.36 97.39,114.36 97.36,114.39 97.34,114.39
  BOTTOM w0.114: 97.34,114.39 95,114.39 93.81,113.21 93.81,112.86 v1(93.65,112.7)
CLK_PCIE_VGA: length 79.3
  IN3 w0.114: v1(95.56,112.69) 95.74,112.87 95.74,113.21 95.47,113.48 92.58,113.48 90.78,111.68 89.38,111.68 82.47,118.59 76.63,118.59 76.13,119.1 74.08,119.1 73.51,119.66 69.21,119.66 68.14,118.59 66.33,118.59 57.22,127.7 57.22,128.33 55.97,129.59 55.97,137.73 56.9,138.67 64.32,138.67 65.41,137.58 65.41,136.02 v1(65.56,135.87)
  BOTTOM w0.076: v1(95.56,112.69) 95.8,112.93 95.8,113.12 96.3,113.62 98.69,113.62 UC1.A40
  BOTTOM w0.114: UV3.AK30 64.94,140.76 65.34,140.37 65.34,136.1 v1(65.56,135.87)
CLK_PCIE_VGA#: length 79.2
  IN3 w0.114: v1(96.24,112.69) 96.15,112.69 95.95,112.89 95.95,113.3 95.56,113.68 92.5,113.68 90.7,111.88 89.47,111.88 82.55,118.8 76.72,118.8 76.22,119.3 74.16,119.3 73.59,119.87 69.13,119.87 68.06,118.8 66.41,118.8 57.42,127.79 57.42,128.42 56.17,129.67 56.17,137.64 56.99,138.46 64.24,138.46 65.2,137.49 65.2,136.12 64.96,135.88 v1(64.67,135.88)
  BOTTOM w0.076: v1(96.24,112.69) 96.06,112.69 95.96,112.79 95.96,113.05 96.37,113.45 98.92,113.45 99.18,113.72 UC1.B40
  BOTTOM w0.114: v1(64.67,135.88) 64.98,135.88 65.11,136 65.11,137.25 64.98,137.37 64.98,137.71 65.11,137.84 65.11,138.18 64.98,138.3 64.98,138.64 65.11,138.77 65.11,139.11 64.98,139.23 64.98,139.58 65.11,139.7 65.11,140.03 UV3.AK32
CLK_PCIE_WLAN: length 265
  IN1 w0.14: v1(97.65,112.64) 97.46,112.64 97.14,112.31 97.14,111.81 97.47,111.48 97.73,111.48 99.43,109.77 99.43,99.49 98.84,98.9 98.84,97.26 100.75,95.35 104.72,95.35 110.03,90.05 110.03,85.08 112.88,82.23 112.88,81.44 114.41,79.92 138.16,79.92 138.43,80.18 158.85,80.18 166.14,87.47 170.96,87.47 173.75,90.27 173.75,106.57 173.47,106.85 173.47,110.21 174.9,111.64 174.9,119.73 173.65,120.97 173.65,122.71 174.49,123.54 174.49,136.05 181.64,143.2 186.1,143.2 188.78,140.53 193.47,140.53 193.88,140.11 196.7,140.11 197.42,140.83 229.9,140.83 231.5,139.24 238.58,139.24 240.42,141.08 240.42,150.79 248.67,159.04 256.48,159.04 256.78,158.74 256.78,158.51 v1(257.19,158.1)
  IN3 w0.114: v1(257.02,161.54) 256.78,161.31 256.78,158.47 257.15,158.1 v1(257.19,158.1)
  BOTTOM w0.076: UC1.C41 99.64,113.28 99.29,113.28 99.09,113.08 97.42,113.08 97.27,112.92 97.27,112.74 97.45,112.56 97.57,112.56 v1(97.65,112.64)
  BOTTOM w0.114: v1(257.02,161.54) 257.45,161.97 JWLBT.47
CLK_PCIE_WLAN#: length 265
  IN1 w0.14: v1(96.9,112.65) 96.88,112.64 96.88,111.7 97.36,111.22 97.63,111.22 99.18,109.67 99.18,99.6 98.58,99 98.58,97.16 100.65,95.09 104.62,95.09 109.77,89.94 109.77,84.98 112.63,82.12 112.63,81.34 114.31,79.66 138.26,79.66 138.53,79.93 158.96,79.93 166.25,87.22 171.06,87.22 174.01,90.17 174.01,106.68 173.73,106.95 173.73,110.11 175.15,111.53 175.15,119.83 173.91,121.08 173.91,122.6 174.74,123.44 174.74,135.94 181.75,142.95 186,142.95 188.67,140.27 193.36,140.27 193.78,139.86 196.81,139.86 197.53,140.58 229.8,140.58 231.39,138.98 238.68,138.98 240.67,140.97 240.67,150.68 248.77,158.78 256.37,158.78 256.52,158.63 v1(256.52,158.1)
  IN3 w0.114: v1(256.35,161.49) 256.55,161.29 256.55,158.13 v1(256.52,158.1)
  BOTTOM w0.076: UC1.D41 100.18,113.15 99.88,113.45 99.22,113.45 99.02,113.25 97.36,113.25 97.1,112.99 97.1,112.85 v1(96.9,112.65)
  BOTTOM w0.114: JWLBT.49 256.95,162.08 v1(256.35,161.49)
