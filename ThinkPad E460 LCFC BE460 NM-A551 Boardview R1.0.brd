# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N13886213: length 16.5
  IN3 w0.114: v2(58.65,145.39) 57.82,144.56 57.82,143.64 54.95,140.78 54.95,136.03 54.21,135.29 v1(54.01,135.29)
  BOTTOM w0.114: v2(58.65,145.39) 58.3,145.74 58.3,145.95 58.09,146.16 57.78,146.16 UV3.Y22 ; RV47.1 v4(54.95,134.58) 54.95,134.93 54.59,135.29 v1(54.01,135.29)
N13886217: length 15
  IN3 w0.114: v2(58.67,146.12) 58.16,146.12 56.85,144.81 56.85,143.21 54.01,140.37 v1(54.01,135.95)
  BOTTOM w0.114: v1(54.01,135.95) 53.63,135.95 53.09,135.41 RV48.1 ; v2(58.67,146.12) 58.34,146.45 UV3.AA22
N13886250: length 16.7
  IN1 w0.14: v1(50.32,166.45) 51.09,165.69 51.09,164.39 52.91,162.57 52.91,161.74 52.01,160.85 52.01,157.1 v2(51.55,156.63)
  BOTTOM w0.114: v1(50.32,166.45) v4(50.32,168.39) 49.6,169.12 48.8,169.12 48.47,169.45 RV40.2 ; UV3.N10 51.94,156.24 v2(51.55,156.63)
N13887174: length 10.3
  BOTTOM w0.114: UV3.U1 55.34,161.82 56.12,162.59 57.43,162.59 58.75,163.91 60.03,163.91 61.27,165.16 TPV1.1 61.45,165.61 62.44,165.61 63.35,166.53 RV55.2
N13887181: length 11.7
  BOTTOM w0.114: UV3.U3 55.34,161.18 56.5,162.34 57.53,162.34 58.79,163.6 60.28,163.6 61.41,164.74 62.22,164.74 TPV2.1 62.64,165.15 62.64,165.39 63.18,165.94 63.78,165.94 64.24,166.4 RV54.2
N13887277: length 10.8
  BOTTOM w0.102: RV71.2 61.11,166.2 60.02,166.2 59.71,165.88 59.71,164.79 59.53,164.61 59.07,164.61 58.73,164.95 v3(58.53,164.95) 57.23,163.66 55.56,163.66 53.74,161.84 UV3.R1
N13887284: length 11.2
  BOTTOM w0.102: 58.9,165.53 58.42,165.53 56.8,163.91 54.12,163.91 53.31,163.1 53.31,161.42 UV3.R3
  BOTTOM w0.114: RV70.2 59.82,166.65 v4(59.7,166.53) 59.65,166.48 59.65,166.28 58.9,165.53
N13887527: length 12.6
  BOTTOM w0.114: v4(66.5,167.47) 65.74,166.71 RV81.2 65.13,166.28 64.55,165.7 63.28,165.7 63.02,165.44 63.02,164.85 62.67,164.5 61.52,164.5 60.38,163.36 59.19,163.36 58.12,162.29 58.12,161.59 58.54,161.17 UV3.AA3
N13887571: length 7
  BOTTOM w0.114: TPV13.1 63.74,165.04 62.88,164.18 61.56,164.18 60.48,163.11 59.37,163.11 58.54,162.28 UV3.AA1
N13887575: length 20.7
  IN1 w0.14: v1(59.88,152.11) 59.47,152.52 59.47,153.8 59.82,154.16 61.03,154.16 61.32,154.45 61.32,156.75 61.71,157.15 61.71,158.64 62.65,159.58 v1(62.65,159.96)
  BOTTOM w0.114: v4(69.25,161.68) 69.12,161.55 RV78.2 RV79.2 68.24,159.8 67.84,159.39 66.73,159.39 66.31,159.81 66.31,160.27 65.98,160.6 63.16,160.6 62.65,160.09 v1(62.65,159.96) ; UV3.AB16 59.34,151.57 v1(59.88,152.11)
N13887638: length 17.2
  BOTTOM w0.114: UV3.AJ27 64.54,143.56 64.8,143.82 66.01,143.82 66.8,144.61 66.8,145.53 67.65,146.38 70.07,146.38 70.21,146.52 70.21,147.42 70.34,147.54 70.74,147.54 v4(71.19,147.99) 72.09,148.9 72.09,149.59 QV4.3 72.85,148.85 72.85,148.14 73.11,147.89 74.37,147.89 74.64,147.61 RV80.2 RV106.2
N13887928: length 24.5
  TOP w0.114: RV77.2 45.6,172.42 45.22,172.8 45.22,173.29 v4(44.99,173.51) 44.99,173.69 v1(45.32,174.02) 45.32,174.84 RV76.2
  IN1 w0.14: v2(51.2,158.29) 51.37,158.29 51.74,158.66 51.74,160.96 52.64,161.86 52.64,162.45 50.68,164.41 50.68,165.03 47.73,167.97 47.73,169.21 46.06,170.89 46.06,173.16 45.32,173.9 v1(45.32,174.02)
  BOTTOM w0.114: v2(51.2,158.29) 51.1,158.19 50.14,158.19 UV3.K7
N13887997: length 6.3
  TOP w0.114: v2(58.53,144.56) 58.83,144.25 RV82.2 58.83,143.45 59.05,143.24 v4(59.05,142.83)
  IN3 w0.114: v2(58.53,144.56) 60.37,146.4 v2(60.37,147.42)
  BOTTOM w0.114: v2(60.37,147.42) 60.37,147.03 UV3.AC22
N13887999: length 11.1
  BOTTOM w0.114: RV83.2 68.4,147.16 67.91,147.16 67.82,147.07 v4(67.74,147.07) 67.57,146.9 67.02,146.9 65.53,145.4 59.86,145.4 59.66,145.6 59.66,146.28 UV3.AB22
N13916283: length 11.6
  IN1 w0.14: v2(50.21,144.65) 50.55,144.31 50.55,143.14 51.06,142.63 51.06,139.61 51.62,139.05 v1(51.75,139.05)
  BOTTOM w0.114: RV14.2 v4(52.18,136.15) 52.18,138.61 v1(51.75,139.05) ; v2(50.21,144.65) 49.76,144.2 UV3.K25
N13962114: length 5
  BOTTOM w0.114: UV9.2 20.93,170.91 20.44,170.42 20.44,170.31 RV93.1 19.97,168.95 RV91.2 19.97,168.92 RV89.2 20.27,168.06 v3(20.83,167.49)
N13962118: length 5.2
  BOTTOM w0.114: UV9.3 20.99,171.41 20.31,170.73 RV94.1 RV92.2 19.94,171.62 RV90.2 18.75,172.19 v4(18.02,172.19)
N13962250: length 6.2
  BOTTOM w0.114: UV9.5 25.43,171.91 25.83,171.52 CV151.1 26.18,172.4 CV152.1 25.95,173.83 26.17,174.05 v4(26.42,174.05) 27.06,174.05 RV95.1
N13963666: length 2.7
  BOTTOM w0.114: RV96.1 25.65,169.74 v3(25.31,170.09) 25.31,170.57 24.96,170.91 UV9.7
N13963670: length 2.5
  BOTTOM w0.114: UV9.6 v3(25.31,171.41) 25.51,171.21 25.51,170.92 25.81,170.63 RV97.1
N13969324: length 12.7
  TOP w0.114: v4(47.26,167.19) 47.75,166.71 RV112.2 48.24,166.05 49.13,165.16 49.13,162.01 50.55,160.59 51.98,160.59 52.43,160.13 52.43,159.68 RV75.2 52.83,158.88 v2(52.55,158.6)
  BOTTOM w0.114: UV3.N7 v2(52.55,158.6)
N13973823: length 1.3
  BOTTOM w0.114: TPV12.1 70.03,160.97 RV78.1
N15168718:
  vias: v4(174.64,173.05)
N15172206: length 4.3
  TOP w0.254: 181.58,171.95 181.74,171.95 182.56,172.78 182.56,173.73 PR301.2 183.92,174.16 v4(184.27,174.52)
N15172224: length 5.5
  TOP w0.229: 180.96,172.43 PU301.12
  TOP w0.254: PR306.2 181.2,175.56 v4(180.46,175.56) 180.46,175.53 180.33,175.41 180.33,174.79 180.85,174.26 180.85,173.89 181.13,173.61 PC316.1 180.96,173.13 180.96,172.43
N15173757: length 2.8
  TOP w0.229: 182.04,171.44 PU301.10
  TOP w0.254: 182.04,171.44 183.35,172.75 PR308.1
N15178230: length 4.5
  TOP w0.229: PU301.13 180.56,172.47
  TOP w0.254: v4(178.38,174.47) 178.5,174.6 179.5,174.6 PR302.2 180.56,173.53 180.56,172.47
N15269244: length 1.3
  BOTTOM w0.114: v4(194.3,174.54) 193.72,175.13 PR805.1
N15269410: length 3.7
  TOP w0.508: PR803.1 190.03,169.99 PC804.2 191.48,170.13 192.21,170.86 192.21,170.86 v4(192.5,171.15)
N16794113: length 3.1
  BOTTOM w0.229: PU101.11 216.68,111.66
  BOTTOM w0.254: 216.68,111.66 216.15,112.19 v4(215.89,112.19) 215.77,112.06 PR120.2
N16794114: length 4.6
  BOTTOM w0.229: PU101.12 216.91,112.06
  BOTTOM w0.254: 216.91,112.06 216.65,112.31 216.65,113.2 v4(215.89,113.97) 214.88,112.95 PR121.2
N16794121: length 42.5
  IN3 w0.254: v1(222.2,104.01) 222.21,104.02 222.76,104.02 223.65,103.13 243.54,103.13 247.91,98.76 254.62,98.76 255.84,99.98 v1(257.31,99.98)
  BOTTOM w0.254: PR101.1 257.85,100.38 257.46,99.98 v1(257.31,99.98) ; v1(222.2,104.01) 222.19,104.02 PC107.1 221.19,104.12 PC105.2 221.22,105.34 PR107.1
N16794165: length 5.7
  BOTTOM w0.508: v4(227.63,108.89) 226.89,108.89 226.24,108.24 PR114.1 225.41,107.93 223.7,107.93 222.84,108.8 PC115.1
N16794166:
  vias: v4(228.32,104.08)
N16794173:
  vias: v4(226.98,110.51)
N16794272: length 2.8
  BOTTOM w0.229: PU101.4 219.41,109.05
  BOTTOM w0.254: PR111.2 218.95,108.01 219.41,108.46 219.41,109.05
N16794274: length 2.9
  BOTTOM w0.229: PU101.3 219.81,109
  BOTTOM w0.254: PR112.2 219.81,107.39 219.81,108.07 v4(219.98,108.25) 219.98,108.58 219.81,108.76 219.81,109
N16794279: length 75
  TOP w0.254: v1(271.79,104.35) 271.79,104.88 272.93,106.03 272.93,108.89 273.77,109.73 ; v1(273.18,111.06) 273.18,110.38 PD101.2
  TOP w0.381: PD101.2 273.77,109.73
  IN3 w0.254: v1(271.79,104.35) 269.12,104.35 266.25,101.48 260.61,101.48 257.11,97.97 247.45,97.97 245.62,99.8 244.39,99.8 241.85,102.34 221.55,102.34 v1(218.95,104.93)
  BOTTOM w0.254: PR111.1 v1(218.95,104.93)
  BOTTOM w0.381: PC101.2 273.03,109.13 273.72,109.81 273.8,109.81 ; PQ103.1 270.39,111.06 v4(271.14,111.81) 271.89,111.06 v1(273.18,111.06) 273.8,110.44 273.8,109.81 ; 273.8,109.81 PR102.2
N16794300: length 8.7
  BOTTOM w0.229: PU101.6 218.61,109.19 218.18,108.76
  BOTTOM w0.254: 218.18,108.76 218,108.76 217.02,107.78 PC117.2 PR115.2 216.11,107.09 215.45,106.43 215.45,105.29 216.06,104.68 PR113.2 216.06,103.95 v4(216.64,103.36)
N16794308: length 3
  BOTTOM w0.229: PU101.5 219.01,109.03
  BOTTOM w0.254: PR118.2 217.9,107.92 v4(218.2,108.22) 219.01,109.03
N16794310: length 1
  BOTTOM w0.254: PR123.1 214.27,109.11 PC126.2
N16794326: length 2.9
  BOTTOM w0.229: 216.67,111.26 PU101.10
  BOTTOM w0.254: 216.67,111.26 214.66,111.26 PR126.2
N16794335: length 5.1
  TOP w0.254: v4(269.57,105.9) 270.54,106.87 PR104.1 269.98,107.96 PR105.2 269.98,108.8 v1(270.26,109.07)
  BOTTOM w0.254: v1(270.26,109.07) 269.83,109.51 269.29,109.51 PQ103.2
N16794344: length 4
  BOTTOM w0.229: PU101.7 218.21,109.39 217.95,109.14
  BOTTOM w0.254: 217.95,109.14 217.09,109.14 v4(216.43,108.48) 215.51,107.56 PR122.2
N16794345: length 3.3
  BOTTOM w0.229: 216.85,110.17 217.14,110.46 PU101.8
  BOTTOM w0.254: 216.85,110.17 216.85,109.82 215.49,108.45 PR123.2
N16794346: length 3.1
  BOTTOM w0.229: PU101.9 216.67,110.86
  BOTTOM w0.254: PR124.2 216.07,110.28 v4(216.08,110.27) 216.67,110.86
N16797507: length 8.1
  BOTTOM w0.254: v4(228.34,126.16) 229.1,126.92 230.12,126.92 230.92,127.72 PD3.1 PD1.1 231.72,129.47 232.38,128.81 PR2.2 PR3.2
N16797515: length 24.6
  BOTTOM w0.254: PC1.2 239.07,128.45 239.35,128.18 PQ2.2 ; PRT1.2 238.27,116.58 v4(240.12,118.44) 241.54,119.85 241.54,125.48 240.65,126.37 239.89,126.37 239.35,126.91 PQ2.2 ; PQ2.2 237.29,127.16 236.89,126.75 PQ1.1 236.13,127.01 235.06,128.07 PQ3.1 233.99,129.5 PR3.1
N16797523: length 7.2
  BOTTOM w0.254: PR2.1 233.79,128.3 PR1.2 234.14,125.69 234.37,125.46 234.62,125.46 235.16,124.92 PQ1.3 233.96,124.67 v4(233.16,123.87)
N16797527: length 15.2
  BOTTOM w0.254: PQ2.1 239.91,124.67 PQ1.2 v4(237.09,122.6) 233.55,122.6 232.4,123.74 232.4,125.09 PD2.1 233.05,127.24 233.23,127.41 PR1.1
N16797541: length 100.6
  IN1 w0.254: v1(67.6,97.37) 61.55,97.37 59.91,99 59.91,102.18 62.35,104.62 62.35,107.74 66.11,111.5 69.92,111.5 73.26,114.84 73.26,118.19 73.72,118.64 73.72,125.34 79.99,131.61 79.99,133.17 81.78,134.96 81.78,135.98 83.06,137.26 90.72,137.26 92.58,139.11 92.58,145.72 94.94,148.08 99.81,148.08 100.99,149.26 101.71,149.26 106.04,153.59 106.04,155.22 106.76,155.94 v1(106.76,156.34)
  BOTTOM w0.254: v1(106.76,156.34) 106.71,156.34 106.69,156.37 105.79,156.37 v4(105.66,156.5) 104.55,157.61 PRT2.1 ; PRT4.1 65.69,98.58 66.91,97.37 v1(67.6,97.37)
N16797550: length 42.8
  IN2 w0.254: v1(64.5,67.47) 62.62,67.47 59.2,70.89 59.2,71.84 58.59,72.44 58.59,77.68 59.81,81.97 60.29,85.6 65.89,91.2 65.89,96.55 67.34,98 v1(67.44,98)
  BOTTOM w0.254: v1(64.5,67.47) 65.62,68.59 v4(66.35,68.59) PRT5.1 ; PRT4.2 66.61,98.58 67.19,98 v1(67.44,98)
N16797569: length 27.3
  TOP w0.254: v1(67.56,69.5) 66.54,68.49 v4(66.54,65.98) 66.54,60.7 70.07,57.17 72.03,57.17 73.31,55.89 74.21,55.89 77.28,52.81 78.92,52.81 v1(79.46,52.28)
  BOTTOM w0.254: PRT5.2 v1(67.56,69.5) ; PRT6.1 v1(79.46,52.28)
N16797599: length 115.8
  TOP w0.254: v1(241.59,135.45) 237.32,135.45 230.06,142.71 230.06,147.03 228.9,148.2 v1(228.9,148.74)
  IN1 w0.254: v1(228.9,148.74) 226.61,151.03 212.43,151.03 211.81,150.42 199.21,150.42 v1(197.16,152.47)
  BOTTOM w0.254: v1(197.16,152.47) 196.28,153.35 188.93,153.35 187.06,155.22 187.06,158.16 180.98,164.24 168.66,164.24 167.44,165.46 167.44,166.66 PRT3.2 ; PRT1.1 238.04,115.67 242.04,119.67 v4(242.04,129.33) 242.04,134.99 v1(241.59,135.45)
N16797601: length 70.9
  IN3 w0.254: v1(115.55,160.64) 115.55,161.05 116.14,161.63 124.46,161.63 124.82,161.99 124.82,162.62 125.7,163.5 132.33,163.5 132.83,162.99 146.8,162.99 149.05,165.23 149.81,165.23 150.64,166.06 151.4,166.06 153.15,167.81 163.31,167.81 164.99,166.14 v1(167.99,166.14)
  BOTTOM w0.254: PRT3.1 168.56,166.7 v1(167.99,166.14) ; v1(115.55,160.64) 115.69,160.5 115.69,159.81 v4(115.16,159.28) 112.63,156.75 107.93,156.75 106.79,157.89 PRT2.2
N16880284: length 4.9
  BOTTOM w0.203: PU601.9 120.12,169.91 120.42,169.6 v4(122.8,169.6) 123.91,169.6 PR606.2
N16880287: length 7.8
  BOTTOM w0.203: PU601.3 119.66,172.31 120.87,173.52 120.87,174.39 120.62,174.64 120.62,175.05 v4(121.1,175.53) 121.24,175.67 123.65,175.67 PR609.2
N16880290: length 4.3
  BOTTOM w0.203: PR615.2 121.61,173.63 121.61,173.12 v4(120.49,172) 120,171.51 PU601.5
N16880296: length 3.4
  BOTTOM w0.203: PU601.7 120.31,170.71 121.31,171.71 121.85,171.71 122.14,171.42 PR611.2
N16880299: length 4.6
  BOTTOM w0.203: PU601.4 119.73,171.91 121.28,173.46 121.28,174.19 PR610.2
N16901916:
  vias: v4(90.77,161.97)
N16902103:
  vias: v4(91.15,168.87)
N16922606: length 3.8
  BOTTOM w0.229: 220.61,113.95 PU101.21
  BOTTOM w0.254: 220.61,113.95 221.37,114.71 222.71,114.71 PR129.2 222.73,113.91 v4(222.55,113.74)
N16922622: length 11.4
  BOTTOM w0.254: PR131.1 217.18,117.94 218.5,119.26 v4(219.34,119.26) 221.42,119.26 222.89,117.79 PR130.2 222.89,116.77 PC128.1 PR132.1 223.64,115.16 PR129.1
N16922664: length 4.9
  BOTTOM w0.229: PU101.16 218.61,114.15
  BOTTOM w0.254: v4(215.77,116.63) 216.54,115.86 PR131.2 217.18,114.92 217.63,114.46 218.29,114.46 218.61,114.15
N16922835:
  vias: v4(234.51,116.15)
N16954250: length 4.4
  BOTTOM w0.508: PR16.2 PR17.1 252.25,126.02 v1(252.25,125.44) 252.25,122.59
N19577504: length 1.9
  TOP w0.114: UL1.33 253.24,96.85 v1(253.2,96.89) 253.2,97.01 RL5.2
N19577505: length 2.8
  TOP w0.114: RL6.2 251.23,97.49 v1(251.66,97.06) 251.78,97.06 252.44,96.41 UL1.35
N19577517: length 1.7
  TOP w0.114: UL1.30 254.44,96.5 254.55,96.61 254.55,97.1 254.49,97.16 RL7.1
N19577520: length 1.9
  TOP w0.114: UL1.12 256.63,89.84 257.33,89.14 RL8.1
N19577582: length 3.4
  TOP w0.114: v1(251.44,88.92) 251.44,89.69 251.59,89.84 UL1.1
  BOTTOM w0.114: v4(250.06,89.45) 250.17,89.57 RL4.1 251.31,89.05 v1(251.44,88.92)
N26325477:
  vias: v1(74.57,68.39) v1(74.9,68.97) v1(75.23,68.39) v1(75.59,68.97) v1(75.87,68.34) v4(73.4,68.52)
N26386889:
  vias: v4(68.9,75.31)
N31349441:
  vias: v1(66.57,69.29)
N31382737:
  vias: v4(79.24,59.61)
N31383366:
  vias: v4(98.9,52.45)
N31383897:
  vias: v4(81.15,54.91)
N31383905:
  vias: v4(81.53,50.59)
N31389989:
  vias: v1(72.93,97.39) v1(75.14,97.57) v1(75.14,96.93) v4(71.99,97.83)
N31390138:
  vias: v4(68.93,100.48)
N31390261:
  vias: v1(73.74,103.26)
N31390277:
  vias: v4(76.19,102.21)
N31396697: length 8.6
  TOP w0.254: v4(73.02,63.04) 72.93,63.13 71.04,63.13 70.75,62.84 PR425.2 v1(70.06,62.57)
  BOTTOM w0.203: PU401.1 67.62,60.36 68.63,61.37 69.88,61.37 70.23,61.72 70.23,62.05 70.72,62.54
  BOTTOM w0.254: v1(70.06,62.57) 70.7,62.57 70.72,62.54 PR425.2
N31396723: length 5.1
  TOP w0.254: v4(68.04,63.06) 68.47,63.06 v1(69.02,62.52) 68.54,62.03 PR424.2
  BOTTOM w0.203: PR424.2 68,61.88 67.14,61.02 PU401.48
  BOTTOM w0.254: PR424.2 68.54,62.01 69.02,62.49 v1(69.02,62.52)
N31396745: length 5.8
  TOP w0.203: v1(59.44,55.02) 59.39,55.07 PR420.2 58.76,53.8 v4(58.86,53.7)
  BOTTOM w0.203: PU401.27 60.97,56.76 59.44,55.23 v1(59.44,55.02)
  BOTTOM w0.254: PR420.2 58.81,55.02 v1(59.44,55.02)
N31396767: length 6
  TOP w0.254: v1(59.34,57.61) 59.18,57.45 PR421.1 58.58,58.57 v4(59.22,59.2)
  BOTTOM w0.203: PU401.30 60.67,57.96 60.33,57.61 v1(59.34,57.61)
  BOTTOM w0.254: v1(59.34,57.61) 58.73,57.61 PC411.2
N31396821: length 6.7
  BOTTOM w0.229: PU401.24 62.01,55.05
  BOTTOM w0.254: 62.01,55.05 62.01,51.09 PR415.2 PR414.2 62.08,49.59 v4(61.51,49.02)
N31396831: length 2.3
  BOTTOM w0.254: v4(59.05,49.75) 59.41,50.12 PC404.2 60.31,50.15 PR414.1
N31396857: length 2.2
  BOTTOM w0.254: PC428.1 65.41,65.21 PR440.2 65.41,67.09 v4(65.27,67.23)
N31396859: length 4.2
  BOTTOM w0.203: PC427.2 64.5,63.76 64.66,63.6 v4(64.66,63.14) PU401.43
  BOTTOM w0.254: PC427.2 PC428.2
N31396879: length 5.1
  BOTTOM w0.203: PC409.2 60,53.65 60.27,53.92 60.27,55.24 v4(60.34,55.32) 60.97,55.94 60.97,56.11 61.22,56.36 PU401.26
  BOTTOM w0.254: PC410.2 PC409.2
N31396887: length 2.3
  BOTTOM w0.254: PC410.1 PR419.2 56.39,52.76 v4(56.25,52.62)
N31396963: length 4.3
  BOTTOM w0.229: PU401.25 61.4,55.76
  BOTTOM w0.254: 61.4,55.76 v4(61.4,53.92) 61.4,52.97 PR416.2 61.17,52.79 PC407.2
N31397011: length 8.9
  BOTTOM w0.203: PC429.1 61.83,63.71 63.46,62.08 PU401.40
  BOTTOM w0.254: PC429.1 PC439.1 61.83,65.49 PR438.1 ; PR439.1 60.89,66.43 PR438.1 ; v4(61.64,67.74) 61.64,66.77 PR438.1
N31397019: length 54.2
  IN2 w0.254: v1(58.66,104.55) 58.66,99.68 59.85,98.48 59.85,87.98 59.01,82.3 57.78,77.76 57.78,72.18 58.44,71.52 58.44,70.51 60.97,67.98 v1(60.97,67.8)
  BOTTOM w0.254: v1(58.66,104.55) 59.49,104.55 62.23,107.29 62.23,107.82 65.44,111.03 v4(67.41,111.03) 69.27,111.03 69.63,110.67 PRT405.1 ; PR439.2 60.61,67.8 v1(60.97,67.8)
N31397040: length 5.6
  BOTTOM w0.203: PR409.1 56.7,58.25 58.27,58.25 58.31,58.29 v4(60.25,58.29) 60.32,58.36 PU401.31
N31397051: length 5.6
  BOTTOM w0.203: PR435.1 71.88,55.39 71.79,55.3 PC424.1 70.21,55.3 v3(70,55.52) 68.95,55.52 68.12,56.36 PU401.11
N31397062: length 4.5
  BOTTOM w0.254: PRT404.1 75.57,54.52 v4(74.71,55.38) 74.69,55.39 PR435.2 73.24,55.31 PR436.2
N31397070: length 3.8
  BOTTOM w0.203: PR432.1 70.57,59.32 69.55,59.32 v4(69.47,59.24) 69.06,58.83 67.82,58.83 67.75,58.76 PU401.5
N31397078: length 26.2
  TOP w0.203: PC418.1 71.84,58.17 v1(72.35,58.17)
  TOP w0.254: v1(84.64,65.21) 84.41,65.44 v4(81.65,65.44) 81.29,65.44 73.11,57.26 72.73,57.26 72.35,57.64 v1(72.35,58.17)
  BOTTOM w0.203: 71.71,58.86 71.71,58.07 PC419.1 71.1,58.58 70.39,58.58 70.15,58.82 69.69,58.82 69.37,58.5 67.95,58.5 67.81,58.36 PU401.6 ; 71.71,58.86 72.35,58.22 v1(72.35,58.17) ; 71.71,58.86 PR432.2
  BOTTOM w0.254: PR432.2 72.35,59.72 PR427.1 ; v1(84.64,65.21) 85.45,65.21 PRT403.1
N31397084: length 10
  TOP w0.254: v1(73.62,60) 73.06,59.44 71.58,59.44 PR430.2 70.49,58.91 v1(69.91,58.33) 70.27,57.97 70.72,57.97 PC418.2
  BOTTOM w0.203: PC419.2 70.54,58.22 70.01,58.22 v1(69.91,58.33) 69.74,58.16 68.36,58.16 68.35,58.17 68.09,58.17 67.88,57.96 PU401.7
  BOTTOM w0.254: v1(73.62,60) 73.74,59.87 PR426.1
N31397096: length 19
  TOP w0.254: v1(84.69,66.2) v4(83.3,66.2) 81.46,66.2 73.08,57.82 v1(72.9,57.82) 72.9,58.48 72.47,58.91 PR430.1
  BOTTOM w0.254: v1(84.69,66.2) 85.45,66.2 PRT403.2 ; v1(72.9,57.82) 72.9,58.53 PR427.2
N31397121: length 4.8
  BOTTOM w0.203: PC417.1 70.39,57.18 PC414.2 69.87,57.7 v3(68.5,57.7) 68.27,57.7 68.12,57.56 PU401.8
  BOTTOM w0.254: PR423.1 70.92,57.16 PC417.1
N31397144: length 6.2
  BOTTOM w0.203: PR422.1 72.19,56.29 71.69,55.79 70.52,55.79 69.91,56.4 PC414.1 69.52,56.75 69.23,56.46 v3(68.98,56.46) 68.52,56.46 68.22,56.76 PU401.10
N31397166: length 5.1
  BOTTOM w0.203: PU401.23 62.66,52.83 v3(62.76,52.73) 63.37,52.12 63.49,52.12 63.79,51.82 PC408.1
  BOTTOM w0.254: PC408.1 63.6,51.53 PR417.1
N31397172: length 34.8
  BOTTOM w0.254: PRT402.1 62.09,70.52 61.73,70.16 v3(60.84,70.16) 59.52,68.84 59.52,67.29 53.07,60.84 53.07,55.05 59.71,48.41 61.74,48.41 PR418.2 62.98,49.83 PR417.2
N31397188: length 5.4
  BOTTOM w0.229: PU401.12 67.85,55.96
  BOTTOM w0.254: 67.85,55.96 68.12,55.69 68.12,55.16 v4(68.34,54.94) 68.52,54.76 69.54,54.76 PC401.1 70.09,54.24 70.82,53.5 PR401.2
N31397190: length 7.5
  BOTTOM w0.203: PU401.13 67.97,53.98 PC402.1
  BOTTOM w0.254: v4(72.43,51.51) 71.38,52.56 PR402.2 71.33,52.66 69.17,52.66 68.13,53.7 PC402.1
N31397230: length 5.1
  BOTTOM w0.203: PR407.2 58.48,62.8 58.48,62.8 ; PC441.1 58.59,61.79 v4(60.04,61.79) 60.61,61.22 62.05,61.22 PU401.37
  BOTTOM w0.254: 58.48,62.8 58.48,61.91 PC441.1
N31397238: length 3.1
  BOTTOM w0.203: PR410.2 59.99,59.56 PU401.34
N31397260: length 7.8
  BOTTOM w0.203: PC405.1 60.08,56.83 60.81,57.56 PU401.29
  BOTTOM w0.254: PC405.1 57.74,56.83 PC440.1 56.9,56.85 PR412.1 56.78,56.22 PR405.1 56.24,54.54 v4(56.13,54.43)
N31397268: length 43.6
  TOP w0.254: v1(54.62,55.73) 53.96,56.39 v4(53.59,56.39) v1(52.48,56.39)
  BOTTOM w0.254: v1(54.62,55.73) 54.67,55.68 PR405.2 ; PRT401.1 65.16,85.17 64.55,85.78 61.75,85.78 59.99,84.02 59.99,80.62 59.52,80.15 59.52,78.06 59,77.55 59,67.69 52.48,61.17 v1(52.48,56.39)
N31397346: length 5.7
  TOP w0.254: v4(62.72,61.98) 62.87,62.14 PR441.2 63.46,63.35 v1(63.61,63.51)
  BOTTOM w0.203: v1(63.61,63.51) 64.26,62.86 PU401.42
  BOTTOM w0.254: PC431.2 v1(63.61,63.51)
N31397348: length 5.1
  BOTTOM w0.203: PU401.2 67.81,59.96 68.65,60.8 v4(68.7,60.8) 68.91,61.02 70.09,61.02 PR428.1
  BOTTOM w0.254: PR428.1 70.8,61.68 PR431.1
N31397350: length 9
  TOP w0.254: v1(69.53,60.48) 69.73,60.69 70.64,60.69 PC422.1 71.13,61.17 72.07,61.17 PR429.1
  BOTTOM w0.203: PC421.2 72.02,61.12 71.1,61.12 PR428.2 70.54,60.79 70.24,60.48 v1(69.53,60.48) 69.21,60.17 68.48,60.17 67.87,59.56 PU401.3
N31397402: length 6.2
  TOP w0.254: PC422.2 70.64,60.03 69.98,60.03 v1(69.76,59.8) 69.13,59.18 v4(68.73,59.18)
  BOTTOM w0.203: PU401.4 68.32,59.16 68.97,59.8 v1(69.76,59.8) 69.91,59.95 PC420.2
N31397404: length 4.7
  BOTTOM w0.203: PU401.39 63.06,61.82 v4(62.2,62.68) 61.54,63.34 61.54,63.37 PC430.2
  BOTTOM w0.254: PR442.2 PC430.2
N31397538: length 6.1
  BOTTOM w0.203: PR443.2 66.48,54.71 66.46,54.71 66.26,54.92 PU401.14
  BOTTOM w0.254: v4(70.6,51.51) 70.26,51.85 PR443.2
N31397546: length 4.5
  BOTTOM w0.203: PU401.15 65.86,54.71 v3(67.8,52.76) 68.49,52.08 PR444.2
N31397550: length 4.4
  BOTTOM w0.203: PU401.19 64.26,54.27 66.48,52.05 PR446.2
N31397552: length 4.9
  BOTTOM w0.203: PR445.2 67.29,51.85 v3(65.35,53.79) 64.66,54.48 PU401.18
N31397554: length 4.2
  BOTTOM w0.203: PR447.2 65.62,52.23 63.86,53.99 PU401.20
N31397556: length 4
  BOTTOM w0.203: PR448.2 64.75,52.28 v3(64.24,52.79) 63.46,53.57 PU401.21
N31397566: length 2.9
  BOTTOM w0.203: PU401.33 59.52,59.16 PR408.2
N31397696: length 5.3
  BOTTOM w0.203: PR434.2 67.45,64.66 67.38,64.66 66.96,64.24 PR433.2 66.68,63.94 66.68,62.98 v4(66.63,62.92) 65.46,61.75 PU401.45
N31397710: length 2.7
  BOTTOM w0.203: PU401.32 59.04,58.76 PR411.2
N31397718: length 1.6
  BOTTOM w0.203: PC423.2 68.55,64.87 68.55,64.56 68.21,64.22 PR433.1
N31398277: length 5.6
  BOTTOM w0.203: PU401.44 65.06,62.27 65.95,63.15 65.95,64.9 PR437.2
  BOTTOM w0.254: PR437.2 PC426.2
N31398315: length 4.3
  TOP w0.254: v4(73.88,61.51) 73.88,61.21 72.62,59.95 PR429.2 72.17,59.95 v1(71.48,60.64)
  BOTTOM w0.254: PC420.1 71.63,60.48 v1(71.48,60.64)
N31398319: length 2.2
  BOTTOM w0.254: PR431.2 72.79,61.92 73.32,61.92 v4(73.49,61.76) 73.49,61.4 73.24,61.15 PC421.1
N36436059:
  vias: v4(169.49,173.81)
N36436199:
  vias: v4(174.67,170.89)
N38076593: length 7.5
  BOTTOM w0.114: v3(23.32,146.13) 23.13,145.94 23.13,144.8 RV16.1
  BOTTOM w0.229: UV5.L8 20.11,140.13 20.5,140.52 20.5,141.11
  BOTTOM w0.381: 20.5,141.11 20.5,141.4 22.56,143.46 RV16.1
N38077179: length 4.9
  TOP w0.229: UV6.L8 20.11,135.16 20.11,134.94 20.5,134.54 20.5,134
  TOP w0.381: RV17.1 20.17,131.38 v4(20.28,131.48) 20.28,132.23 20.5,132.46 20.5,134
N38081150: length 7.9
  TOP w0.114: RV28.1 23.83,150.33 23.83,148.95 v4(23.65,148.77)
  TOP w0.229: 20.5,153.94 20.5,154.54 20.11,154.94 UV7.L8
  TOP w0.381: 20.5,153.94 20.5,153.9 23.32,151.08 RV28.1
N38081832: length 6
  BOTTOM w0.114: v3(17.51,164.24) 18.4,164.24 RV29.1
  BOTTOM w0.203: RV29.1 19.31,163.34 19.31,161.88 19.49,161.7 19.49,161.69 19.74,161.44 19.74,160.54 19.74,160.54 19.74,160.27 UV8.L8
N48440511: length 3
  BOTTOM w0.229: 149.47,167.33 PU701.26
  BOTTOM w0.254: 149.47,167.33 149.47,167.2 149.84,166.83 PC702.2 150.4,166.66 150.7,166.35 PR702.2
N48440559: length 2.3
  BOTTOM w0.229: 151.7,169.96 PU701.20
  BOTTOM w0.254: 151.7,169.96 152,169.96 v4(152.22,169.75) 152.39,169.58 PR706.2
N48440565: length 3.9
  BOTTOM w0.229: PU701.21 151.72,169.56
  BOTTOM w0.254: v4(154.37,168.04) 154.04,168.04 153.35,168.74 PC703.1 153.02,168.74 152.71,169.05 152.24,169.05 151.72,169.56
N48440766:
  vias: v4(142.33,170.38)
N48440774: length 5
  BOTTOM w0.229: PU701.28 148.67,167.62
  BOTTOM w0.254: v4(147.82,164.26) 147.82,164.59 147.36,165.04 PR701.2 147.64,165.48 147.92,165.76 147.92,165.89 148.44,166.4 PC701.1 148.67,166.58 148.67,167.62
N48440814:
  vias: v4(143.96,174.47)
N50697329: length 4.3
  TOP w0.114: v1(166.49,152.83) 166.31,153.01 RC316.2
  BOTTOM w0.102: v1(166.49,152.83) 165.21,151.55 JDIMM1.197
N50697343: length 2.4
  TOP w0.508: v4(156.46,89.01) RD4.1 CD2.2
N50697618: length 2.3
  TOP w0.114: v1(165.02,152.83) 164.85,152.66 RC315.2
  BOTTOM w0.102: v1(165.02,152.83) 164.94,152.75 163.55,152.75 JDIMM1.201
N50697658: length 0.9
  TOP w0.508: CD12.2 RD12.1
N50702365: length 2.4
  TOP w0.508: CD31.2 RD18.1 v4(145.02,90.55)
N50702825: length 9
  TOP w0.114: v1(147.72,151.93) 148.06,151.58 148.58,151.58 149.85,150.32 149.85,148.95 RC317.2 150.28,148.15 v4(151.02,147.42)
  BOTTOM w0.114: JDIMM2.197 148.1,151.55 v1(147.72,151.93)
N51647759: length 2
  TOP w0.114: TPV17.1 51.94,157.63 51.5,157.19 v2(51.38,157.19)
  BOTTOM w0.114: v2(51.38,157.19) 51.74,157.19 UV3.N9
N51647766: length 1.4
  TOP w0.114: TPV18.1 50.19,156.62 v2(50.16,156.59)
  BOTTOM w0.114: UV3.L9 50.57,157 v2(50.16,156.59)
N51647773: length 1.5
  TOP w0.114: v2(62.15,157.41) 62.33,157.58 TPV19.1
  BOTTOM w0.114: v2(62.15,157.41) 61.74,157 UV3.AE9
N51647780: length 1.5
  TOP w0.114: TPV20.1 58.27,154.55 v2(57.81,155.02)
  BOTTOM w0.114: v2(57.81,155.02) 57.43,155.4 UV3.Y11
N51647787: length 1.7
  TOP w0.114: v2(62.13,158.22) 62.25,158.22 TPV21.1
  BOTTOM w0.114: v2(62.13,158.22) 61.74,157.83 UV3.AE8
N51647794: length 2
  TOP w0.114: TPV22.1 62.29,156.67 61.56,157.41 v2(61.31,157.41)
  BOTTOM w0.114: UV3.AD9 60.94,157.03 v2(61.31,157.41)
N51647801: length 2.6
  TOP w0.114: TPV23.1 60.4,157.97 60.05,157.62 60.05,157.07 v2(60.53,156.59)
  BOTTOM w0.114: v2(60.53,156.59) 60.14,156.21 UV3.AC10
N51647808: length 1.4
  TOP w0.114: TPV24.1 61.34,159.07 v2(61.34,158.97)
  BOTTOM w0.114: v2(61.34,158.97) 60.96,158.6 UV3.AD7
N51647815: length 13.4
  BOTTOM w0.114: TPV25.1 66.17,162.72 61.69,162.72 60.55,161.58 60.55,158.35 60.14,157.93 UV3.AC8
N51647822: length 13.8
  BOTTOM w0.114: UV3.AC7 60.14,158.65 59.74,159.05 59.74,162.08 60,162.34 60.84,162.34 61.6,163.1 65.89,163.1 67.55,164.75 TPV26.1
N51647829: length 3
  TOP w0.114: TPV27.1 60.03,158.75 60.03,158.12 59.66,157.76 v2(59.66,157.37)
  BOTTOM w0.114: UV3.AB9 59.29,157 v2(59.66,157.37)
N51647836: length 1.8
  TOP w0.114: TPV28.1 59.57,158.97 v2(59.57,158.25)
  BOTTOM w0.114: UV3.AB8 59.19,157.8 59.57,158.17 v2(59.57,158.25)
N51647843: length 1.3
  TOP w0.114: TPV29.1 58.34,157.96 v2(58.65,158.27)
  BOTTOM w0.114: UV3.AB7 58.97,158.6 v2(58.65,158.27)
N51647850: length 9.1
  BOTTOM w0.114: UV3.AB4 58.98,160.96 58.98,162.21 59.63,162.86 60.59,162.86 61.58,163.86 63.49,163.86 64.89,165.26 TPV30.1
N51647857: length 2.1
  TOP w0.114: TPV32.1 56.64,159.08 v2(57.45,158.27)
  BOTTOM w0.114: v2(57.45,158.27) 57.92,157.8 UV3.Y8
N51647864: length 1.3
  TOP w0.114: v2(58.4,158.86) 58.4,159 TPV33.1
  BOTTOM w0.114: v2(58.4,158.86) 58.38,158.86 58.11,158.6 UV3.Y7
N51647871: length 4.2
  BOTTOM w0.114: TPV34.1 68.43,158.4 67.47,158.4 66.07,157 UV3.AL9
N51647878: length 9.1
  BOTTOM w0.114: TPV31.1 64.62,163.48 61.55,163.48 60.69,162.62 59.87,162.62 59.34,162.08 UV3.AB2
N52745643: length 4.6
  BOTTOM w0.114: RV107.1 v4(68.17,155.61) 67.62,155.61 66.99,154.97 65.49,154.97 65.11,154.6 UV3.AK12
N52745645: length 5.1
  BOTTOM w0.114: RV109.1 67.98,157.77 v4(67.7,157.49) 66.02,155.81 64.94,155.81 64.54,155.41 UV3.AJ11
N52745647: length 3.9
  BOTTOM w0.114: UV3.AL11 66.34,155.4 67.68,156.74 68.52,156.74 RV108.1
N53646061: length 2.8
  BOTTOM w0.114: v4(73.41,148.29) 73.4,148.3 QV4.2 74.06,148.94 RV115.2
N53646159: length 4
  BOTTOM w0.114: QV4.1 72.75,151.61 v4(73.65,152.51) 73.74,152.51 74.58,151.67 RV140.2
N54603879: length 4.7
  BOTTOM w0.229: PU701.25 149.87,167.73
  BOTTOM w0.254: 149.87,167.73 150.63,166.97 PR703.2 151.28,166.41 PR702.1 151.62,166.02 150.87,165.27 v4(150.87,165.02)
N54887023: length 5.5
  TOP w0.114: v1(148.77,152.5) 148.77,151.75 150.28,150.24 RD19.2
  BOTTOM w0.114: JDIMM2.201 148.93,152.75 148.77,152.6 v1(148.77,152.5)
N55632055: length 4.5
  TOP w0.254: PR627.2 v1(117.48,174.53) 117.95,175 v4(117.95,175.31)
  BOTTOM w0.203: v1(117.48,174.53) 117.89,174.13 PU601.38 ; v1(117.48,174.53) 117.09,174.13 PU601.36 ; v1(117.48,174.53) 117.48,173.71 PU601.37
N55632901: length 3.5
  TOP w0.254: PR637.2 118.45,173.87 v1(118.45,174.48)
  BOTTOM w0.203: PU601.40 118.69,174.24 v1(118.45,174.48) 118.29,174.32 PU601.39
  BOTTOM w0.254: v4(118.03,175.33) 118.03,174.9 v1(118.45,174.48)
N55634236: length 3
  BOTTOM w0.203: PR640.1 120.07,174.66 120.36,174.37 v4(120.36,173.96) 120.36,173.48 119.59,172.71 PU601.2
N55637104: length 2.3
  TOP w0.254: v4(121.39,174.05) PR638.1 119.79,174.05 119.41,173.67 v1(119.26,173.67)
N55638710: length 3.9
  TOP w0.254: PR628.1 115.83,173.95 115.83,174.58 v1(115.96,174.71) 116.22,174.97 v4(116.22,175.33)
  BOTTOM w0.229: PU601.32 115.49,174.34 ; 115.89,174.64 PU601.33
  BOTTOM w0.254: v1(115.96,174.71) 115.89,174.64 115.78,174.64 115.49,174.34
N56243451:
  vias: v4(279.52,101.33)
N56300303: length 4.3
  BOTTOM w0.203: PR612.2 121.42,172.3 120.23,171.11 PU601.6
  BOTTOM w0.254: PR612.2 PR644.2
N56340374: length 2.6
  TOP w0.254: PR629.1 v1(116.57,174.48)
  BOTTOM w0.203: PU601.34 116.29,174.29 116.47,174.48 v1(116.57,174.48)
  BOTTOM w0.254: v1(116.57,174.48) 116.57,175.01 v4(116.25,175.33)
N56471499: length 3.5
  TOP w0.254: v1(147.05,168.92) 147.05,168.97 147.53,169.45 PR705.1 147.96,169.13 v4(147.96,168.22)
  BOTTOM w0.229: PU701.3 147.42,169.56
  BOTTOM w0.254: 147.42,169.56 147.05,169.2 v1(147.05,168.92)
N56799483: length 9.6
  BOTTOM w0.508: TL1.9 274.09,94.51 v1(274.73,95.16) 275.36,94.53 TL1.10 ; 268,95.6 268,94.72 267.74,94.46 TL1.4 ; 268,95.6 267.76,95.36 267.01,95.36 v1(266.91,95.26) ; 268,95.6 CL9.1 ; v1(266.91,95.26) 266.64,95.53 CL13.1 ; v1(266.91,95.26) 266.91,94.88 266.47,94.43 TL1.3
N57615062: length 2.6
  TOP w0.114: T24.1 251.7,97.67 252.84,96.53 UL1.34
N57615075: length 2.1
  TOP w0.114: UL1.32 253.64,97.91 T23.1
N57722199:
  vias: v4(281.55,120.09)
N57725801: length 9.8
  TOP w0.254: JKB.25 159.2,71.12 159.56,70.76
  TOP w0.508: 159.56,70.76 163.52,70.76 164.37,71.61 R111.2 163.17,73.82 v4(163.14,73.86)
N57726117: length 3.5
  BOTTOM w0.508: R112.1 v4(233.79,175.15)
  BOTTOM w0.762: R112.1 233.66,173.13 D6.2
N57726123: length 5.1
  BOTTOM w0.508: R112.2 v4(236.8,173.26)
  BOTTOM w0.762: JRTC.1 234.32,171.76 235.19,172.63 R112.2
N57732272: length 1.6
  TOP w0.114: R120.1 v1(139.31,68.43) 139.17,68.43 138.91,68.7 U14.16
N57732400: length 3.9
  TOP w0.114: v4(141.89,67.16) 141.74,67.01 140.57,67.01 R118.1 139.53,67.55 138.87,68.2 U14.15
N57740748: length 4.4
  TOP w0.254: U1.7 47.1,124.65 v4(47.17,124.58) 47.03,124.44 47.03,123.41 46.59,122.97 R3.1
N57771515: length 4.3
  TOP w0.114: R30.2 211.16,92.51 v3(210.88,92.79) 210.75,92.92 209.63,92.92 208.92,93.63 208.92,93.99 208.8,94.11 U5.7
N57771580: length 2.5
  TOP w0.114: U5.22 203.72,95.11 203.56,94.95 203.56,94.77 203.09,94.29 202.93,94.29 202.65,94.57 C31.2
N57771583: length 2.4
  TOP w0.114: U5.23 203.73,94.61 203.73,94.61 203.16,94.04 202.82,94.04 202.62,93.84 C33.2
N57771966: length 3.2
  TOP w0.114: U5.5 207.11,92.8 207.27,92.64 207.63,92.64 TP72.1
N57771968: length 2.1
  TOP w0.114: U6.5 224.51,92.27 224.97,91.8 TP73.1
N57772670: length 2.4
  TOP w0.114: U6.7 226.63,94.01 v3(226.83,93.81) 227.69,92.95 R45.2
N57772804: length 5.3
  TOP w0.114: U6.22 221.17,95.01 221.14,94.98 v1(220.45,94.98) 218.61,94.98 218.35,94.72 218.35,94.27 C38.2
N57772807: length 5.2
  TOP w0.114: U6.23 221.1,94.51 220.86,94.75 v1(219.04,94.75) 218.7,94.75 218.57,94.62 218.57,93.99 219.2,93.36 C39.2
N57774513: length 6.1
  TOP w0.254: URE1.20 248.13,84.33 248.13,83.89 248.05,83.82 v1(248.05,83.61) 247.97,83.61 247.51,84.08 URE1.19 ; URE1.31 247.91,89.97 248.14,90.2 v1(248.14,90.46) ; URE1.12 244.71,83.65 v1(244.66,83.6) ; URE1.40 v1(244.31,90.46)
  BOTTOM w0.508: v1(244.31,90.46) 244.31,90.17 CRE18.1
  vias: v1(248.79,90.32) v4(248.38,83.13)
N57774860: length 2.7
  TOP w0.114: URE1.36 245.91,91.16 v1(245.86,91.21)
  BOTTOM w0.114: v1(245.86,91.21) 245.75,91.09 245.09,91.09 TP71.1
N57775834: length 4.7
  TOP w0.114: v4(250.51,82.37) 249.66,82.37 RRE20.1 249.15,82.66 248.68,83.13 247.86,83.13 247.5,83.49 247.5,83.68 247.11,84.07 URE1.18
N57806855: length 4.5
  TOP w0.203: U11.12 218.82,133.1 C71.1 219.03,133.08 219.39,132.72 219.39,130.99 v4(219.05,130.65)
N57806872: length 1.6
  TOP w0.203: U11.10 v1(218.02,133.8) 218.02,133.19 C72.1
N57919388: length 1
  TOP w0.203: CA29.1 RA14.2
N57919390: length 2.4
  TOP w0.254: CA30.1 182.7,51.19 v3(182.72,51.21) 183.75,52.24 RA15.2
N57919402: length 0.9
  TOP w0.203: RA19.2 CA31.1
N57919452: length 12.4
  TOP w0.203: v1(193.5,48.6) 193.44,48.66 DA4.1 ; v1(186.75,52.86) 187.08,53.19 RA22.2
  IN1 w0.203: v1(186.75,52.86) 186.75,50.3 188.49,48.56 193.46,48.56 v1(193.5,48.6)
N57919454: length 0.9
  TOP w0.203: RA24.2 CA32.1
N57919809: length 32.5
  TOP w0.114: CA23.2 192.93,62.82 RA11.1 RA13.1 194.16,64.04 193.53,64.68 CA22.2 194.06,66.66 194.06,68.1 v4(193.91,68.26) 193.72,68.45 187.4,68.45 184.67,65.72 174.11,65.72 173.57,65.18 173.57,63.06 DA1.1
N57919838: length 2.3
  TOP w0.114: RA11.2 193.45,62.07 193.45,61.31 v3(193.36,61.22) 193.08,60.94 192.45,60.94 CA24.1
N57924109: length 4.2
  TOP w0.203: UA1.11 188.83,59.74 189.03,59.94 189.91,59.94 190.49,60.52 v4(190.49,60.57) 190.49,60.75 190.94,61.2 190.94,61.77 191.12,61.94 CA16.2
N57924172: length 4.1
  TOP w0.203: CA17.2 183.1,60.99 183.79,60.31 185.28,60.31 185.63,59.96 UA1.19
N57924174: length 4.5
  TOP w0.203: CA17.1 181.52,60.9 181.93,60.48 182.98,60.48 v3(183.31,60.15) 183.49,59.97 185.02,59.97 185.23,59.77 UA1.20
N58156905: length 4.4
  BOTTOM w0.381: v4(271.01,109.9) 271.1,109.81 PR102.1 272.45,108.04 273.04,107.45 PQ101.4
N58599815: length 11
  TOP w0.203: v3(192.69,51.01) 192.79,50.91 193.19,50.91 v1(193.44,51.16) DA3.1 ; v1(188.09,51.95) 188.09,51.31 RA16.2
  IN1 w0.203: v1(188.09,51.95) 188.09,50.36 188.92,49.54 192.68,49.54 193.44,50.3 v1(193.44,51.16)
N58636514: length 3.8
  BOTTOM w0.114: QV8.5 78.98,153.45 78.37,154.06 v4(77.78,154.06) 77.76,154.03 77.76,153.22 RV137.1 RV136.2
N58636526: length 3.9
  BOTTOM w0.114: QV8.6 78.94,154.55 78.94,155.39 v4(79.5,155.95) 78.92,156.52 RV138.1
N58636528: length 6.3
  BOTTOM w0.114: QV8.2 80.85,153.45 80.33,152.93 80.33,151.3 79.54,150.51 78.02,150.51 RV139.2 77.91,151.06 v3(77.68,151.29)
N58636569: length 5.2
  TOP w0.508: RV135.2 CV169.1 71.35,158.35 v4(70.53,159.16) 71.39,160.03 QV5.2
N58636580:
  vias: v4(72.2,162.99)
N58868284: length 7.2
  TOP w0.114: 57.51,113.3 57.17,112.96 56.93,112.96 55.26,111.3 v3(55.26,110.79) ; 57.51,113.3 JLCD.4 ; 57.51,113.3 57.53,113.3 57.72,113.49 57.72,113.98 58.12,114.38 58.45,114.38 58.96,113.88 v1(59.42,113.88)
  BOTTOM w0.114: v1(59.42,113.88) 59.47,113.88 R21.2
N59027813: length 7
  TOP w0.254: PR4.1 277.22,103.49 276.37,104.34 PQ4.6 276.42,104.36 276.89,104.83 278.49,104.83 PR6.2 279.43,102.75 v4(279.65,102.54)
N59062655: length 37.2
  TOP w0.254: v1(121.32,167.57) 121.32,167.9 123.44,170.02 v4(124.5,170.02) 125.07,170.02 v1(125.89,170.85)
  BOTTOM w0.254: v1(121.32,167.57) 121.47,167.72 PR643.1 121.9,167.8 PR641.2 ; PRT602.2 102.67,175.47 103.03,175.83 107.93,175.83 108.67,176.56 125.28,176.56 126.14,175.7 126.14,171.1 v1(125.89,170.85)
N59727618: length 3.9
  TOP w0.381: PQ105.1 270.03,109.79 PD101.1 271.63,111.52 v4(271.73,111.62)
N59727917:
  vias: v4(268.58,112.3)
N60801854: length 4.6
  BOTTOM w0.114: RV142.2 54.97,131.96 v4(55.58,132.57)
  BOTTOM w0.381: RV142.2 54.13,130.64 53.26,130.64 QV11.2
N60801856: length 4.2
  BOTTOM w0.114: QV11.1 54.03,129.85 54.74,130.56 v3(55.05,130.56)
  BOTTOM w0.381: RV141.1 52.79,129.55 QV11.1
N60801870: length 8.6
  BOTTOM w0.381: RV130.2 46.49,132.16 CV160.1 46.49,131.22 46.03,130.77 45.14,130.77 44.76,130.39 44.76,126.8 45.24,126.32 QV9.4
N60802017: length 9.6
  BOTTOM w0.203: QV10.6 41.61,133.9 41.78,133.73 41.78,133.45 41.58,133.25 QV10.5 40.13,133.25 39.68,132.8 39.68,127.92 v3(39.52,127.76) 39.17,127.41 39.17,127.13 RV143.2
N60939795:
  vias: v4(215.89,169.03)
N60939813: length 2.2
  BOTTOM w0.508: PC209.2 208.39,164.65 v1(207.87,164.13) 207.87,164.09 208.37,163.58 PR204.1
N61716887: length 2.4
  BOTTOM w0.254: PC212.2 PR207.1 219.52,166.9 v4(219.52,166.9)
N62639755: length 14
  TOP w0.114: v1(127.24,89.19) 127.49,89.19 128.28,89.97 TP37.1
  BOTTOM w0.076: 125.43,92.45 125.43,92.48 122.08,95.83 122.08,97.32 121.42,97.99 UC1.BB68
  BOTTOM w0.114: v1(127.24,89.19) 127.67,89.62 127.67,90.02 126.69,91.01 126.01,91.01 125.43,91.59 125.43,92.45
N62639757: length 13
  TOP w0.114: v1(127.24,89.82) 127.7,90.28 127.7,91.2 TP39.1
  BOTTOM w0.076: 124.95,92.36 124.95,92.62 121.92,95.64 121.92,97.26 121.63,97.55 UC1.BB69
  BOTTOM w0.114: 124.95,92.36 124.95,91.54 125.8,90.69 126.43,90.69 127.24,89.88 v1(127.24,89.82)
N62639791: length 2.4
  TOP w0.114: v2(114.72,130.32) 114.53,130.32 114.17,130.69 114.17,131.24 TP43.1
  BOTTOM w0.076: UC1.AK13 114.12,129.93 114.63,130.33 v2(114.72,130.32)
N62639793: length 3
  TOP w0.114: TP45.1 114.75,132 114.75,131.85 114.99,131.6 114.99,131.31 v2(114.54,130.86)
  BOTTOM w0.076: UC1.AK12 114.12,130.52 v2(114.54,130.86)
N62639820: length 22.2
  BOTTOM w0.114: UC1.BB2 121.67,136.86 121.67,137.75 122.26,138.34 122.26,143.08 122.42,143.24 122.42,146.89 118.88,150.43 118.88,151.9 118.35,152.43 115.55,152.43 TP49.1
N62639829: length 22.4
  BOTTOM w0.076: UC1.BA3 120.82,135.79 121.32,136.29 121.55,136.29 121.87,136.61 121.87,136.86
  BOTTOM w0.114: TP51.1 116.71,152.67 118.45,152.67 119.12,152 119.12,150.53 122.66,146.99 122.66,143.14 122.5,142.98 122.5,138.2 121.87,137.57 121.87,136.86
N62639863: length 2
  TOP w0.114: TP59.1 119.4,134.7 v2(118.65,133.95)
  BOTTOM w0.076: v2(118.65,133.95) 118.3,134.3 UC1.AU5
N62639865: length 1.7
  TOP w0.114: TP60.1 117.34,134.64 v2(117.34,133.93)
  BOTTOM w0.076: v2(117.34,133.93) 117.65,134.24 UC1.AT5
N62639899: length 10.6
  BOTTOM w0.076: UC1.B3 99.42,135.94 98.95,136.41 98.95,136.65 98.38,137.22 97.17,137.22
  BOTTOM w0.114: TP64.1 90.46,138.14 92.09,138.14 93,137.22 97.17,137.22
N62639901: length 7.8
  BOTTOM w0.076: 97.18,136.98 98.38,136.98 98.79,136.58 UC1.A3
  BOTTOM w0.114: TP66.1 92.27,136.98 97.18,136.98
N62640032: length 10.6
  TOP w0.114: TP29.1 128.78,139.07 127.51,139.07 126.98,139.61 124.81,139.61 123.27,138.06 120.88,138.06 120.51,137.7 v2(120,137.7)
  BOTTOM w0.076: v2(120,137.7) 119.86,137.56 119.86,137.27 UC1.AW1
N62640090: length 13.5
  TOP w0.114: v2(100.03,135.88) 99.29,136.62 92.5,136.62 91.62,137.5 89.48,137.5 88.78,136.8 TP23.1
  BOTTOM w0.076: UC1.D4 100.42,135.5 v2(100.03,135.88)
N62640092: length 10.3
  BOTTOM w0.076: UC1.B2 99.27,136.83 99.26,136.84 99.26,136.98 98.78,137.47 98.03,137.47
  BOTTOM w0.114: 98.03,137.47 93.1,137.47 92.19,138.38 91,138.38 TP25.1
N62640101: length 9.5
  BOTTOM w0.076: 98.77,137.71 99.42,137.05 99.42,136.91 UC1.C2
  BOTTOM w0.114: TP27.1 92.63,139.29 94.21,137.71 98.77,137.71
N62640103: length 11
  TOP w0.114: TP22.1 91.73,136.38 98.75,136.38 99.89,135.23 v2(101.07,135.23)
  BOTTOM w0.076: v2(101.07,135.23) 100.74,134.9 UC1.D5
N62640164: length 14.9
  BOTTOM w0.076: 99.73,139 100.45,138.27 100.45,138.18 100.6,138.03 100.6,137.53 100.87,137.26 100.87,137.24 101.05,137.07 UC1.E1
  BOTTOM w0.114: TP31.1 89.49,141.44 92.09,141.44 94.86,138.67 97.93,138.67 98.25,139 99.73,139
N62640180: length 11.8
  BOTTOM w0.076: 98.37,138.61 99.87,138.61 100.29,138.2 100.29,138.11 100.44,137.96 100.44,137.46 100.71,137.19 100.71,136.77 UC1.E2
  BOTTOM w0.114: TP33.1 92.2,140.74 94.51,138.43 98.18,138.43 98.37,138.61
N62640214: length 25.1
  BOTTOM w0.076: 122.66,136.28 122.66,136.13 121.54,135.01 121.29,135.01 121.18,135.12 UC1.BA4
  BOTTOM w0.114: 122.66,136.28 122.66,137.04 123.46,137.84 123.46,140.9 124.28,141.72 124.28,146.73 120.09,150.93 120.09,152.52 117.38,155.23 117.33,155.23 TP34.1
N62640216: length 25.1
  BOTTOM w0.076: UC1.BB4 121.47,135.3 122.46,136.29 122.46,136.48
  BOTTOM w0.114: TP35.1 116.76,154.45 117.81,154.45 119.84,152.42 119.84,150.83 124.04,146.63 124.04,141.88 123.22,141.06 123.22,137.88 122.46,137.12 122.46,136.48
N62640259: length 8
  BOTTOM w0.076: UC1.A4 98.79,135.46 98.63,135.62 98.56,135.62 98.13,136.04 97.75,136.43
  BOTTOM w0.114: TP67.1 91.87,136.5 96.46,136.5 96.53,136.43 97.75,136.43
N62640261: length 10.6
  BOTTOM w0.076: UC1.C4 99.38,135.37 98.96,135.78 98.63,135.78 98.2,136.21 97.96,136.45 97.96,136.55 97.77,136.74
  BOTTOM w0.114: TP68.1 90.46,136.74 97.77,136.74
N62640281: length 26.9
  BOTTOM w0.076: 123.06,136.23 123.06,136.03 121.57,134.54 UC1.BB5
  BOTTOM w0.114: TP54.1 117.72,156.64 120.63,153.73 120.63,151.06 124.77,146.93 124.77,141.52 123.95,140.7 123.95,137.72 123.06,136.84 123.06,136.23
N62640313: length 21.9
  BOTTOM w0.076: UC1.AY2 120.64,136.94 120.64,137.2 120.68,137.24 120.68,137.99
  BOTTOM w0.114: 120.68,137.99 121.15,138.46 121.15,139.85 120.77,140.23 116.27,140.23 113.96,142.54 113.96,147.66 115.17,148.87 115.17,151.77 TP24.1
N62640315: length 20.7
  BOTTOM w0.076: UC1.AY1 120.3,137.1 120.51,137.3 120.51,137.94 120.48,137.96
  BOTTOM w0.114: 120.48,137.96 120.48,138.13 120.88,138.52 120.88,139.79 120.68,139.99 116.17,139.99 113.71,142.45 113.71,147.75 113.77,147.81 113.77,151.83 TP26.1
N62640335: length 12.2
  BOTTOM w0.076: 98.99,138.36 99.81,138.36 100.25,137.92 100.25,137.22 UC1.D1
  BOTTOM w0.114: 98.99,138.36 98.82,138.19 94.41,138.19 92.57,140.03 91,140.03 TP74.1
N62640353: length 14.3
  BOTTOM w0.076: UC1.D3 100.49,136.48 100.08,136.89 100.08,137.85 99.78,138.16 99.19,138.16
  BOTTOM w0.114: 99.19,138.16 98.98,137.95 94.31,137.95 92.47,139.79 89.32,139.79 TP30.1
N62640386: length 15.4
  TOP w0.114: v2(101.92,102.86) 101.92,102.86 101.45,102.39 101.07,102.39 100.82,102.14 100.82,101.89 100.44,101.51 97.94,101.51 94,97.57 92.01,97.57 91.6,97.97 90.17,97.97 89.96,97.77 TP32.1
  BOTTOM w0.076: v2(101.92,102.86) 101.96,102.94 UC1.F60
N62640584: length 2.5
  TOP w0.114: v2(102.45,110.17) 102.87,109.74 TP86.1
  BOTTOM w0.114: UC1.K46 103.26,110.63 102.8,110.17 v2(102.45,110.17)
N62640593: length 3.4
  TOP w0.114: v2(102.56,111.09) 102.12,110.65 101.45,110.65 TP85.1
  BOTTOM w0.114: v2(102.56,111.09) 102.78,111.09 103.24,111.55 UC1.K45
N62640620: length 2.8
  TOP w0.114: TP88.1 114.06,124.48 v2(113.49,123.91)
  BOTTOM w0.114: v2(113.49,123.91) 113.67,123.73 114.23,123.73 114.58,123.39 UC1.AL25
N62640629: length 1.3
  TOP w0.114: v2(113.8,122.06) 113.8,122.13 TP87.1
  BOTTOM w0.114: UC1.AL27 v2(113.8,122.06)
N62640656: length 11.1
  TOP w0.114: TP90.1 91.58,91.28 94.43,94.14 96.35,94.14 v2(97.62,95.41)
  BOTTOM w0.114: v2(97.62,95.41) 99.04,95.41 99.9,96.27 UC1.C71
N62640665: length 10.3
  BOTTOM w0.076: UC1.B70 99.42,96.72 99.57,96.57 99.57,96.27 99.24,95.94
  BOTTOM w0.114: 99.24,95.94 93.91,95.94 91.81,93.85 91.2,93.85 TP89.1
N62640692: length 9
  BOTTOM w0.076: UC1.A52 98.76,107.61 97.22,107.61 96.96,107.34
  BOTTOM w0.114: TP91.1 92.17,109.73 92.17,108.68 93.5,107.34 96.96,107.34
N62640710: length 13.1
  TOP w0.114: TP92.1 126.62,91.99 126.62,91.5 126.35,91.22 v1(126.35,89.77)
  BOTTOM w0.076: 121.38,95.21 120.64,95.96 120.64,96.92 UC1.BA70
  BOTTOM w0.114: v1(126.35,89.77) 125.91,90.21 125.6,90.21 124.37,91.44 124.37,92.59 121.74,95.21 121.38,95.21
N62640712: length 14.1
  TOP w0.114: TP93.1 127.08,90.42 126.8,90.15 126.8,89.59 v1(126.35,89.14)
  BOTTOM w0.076: 124.61,92.56 124.61,92.66 121.73,95.54 121.73,97.03 121.55,97.22 121.32,97.22 120.82,97.72 UC1.BA68
  BOTTOM w0.114: 124.61,92.56 124.61,91.54 125.7,90.45 126.33,90.45 126.78,89.99 126.78,89.57 v1(126.35,89.14)
N62640746: length 25.1
  BOTTOM w0.076: UC1.J71 103.64,96.41 103.64,95.49 103.36,95.21 103.36,95.03
  BOTTOM w0.114: TP94.1 91.82,83.87 98.16,83.87 101.89,87.59 101.89,93.09 103.36,94.56 103.36,95.03
N62640748: length 25.2
  BOTTOM w0.076: UC1.J68 103.44,98.25 103.44,97.93 103.4,97.89 103.4,97.58 103.44,97.55 103.44,97.27 103.4,97.19 103.4,96.98 103.46,96.87 103.46,96.65 103.4,96.54 103.4,96.23 103.48,96.15 103.48,95.56 103.09,95.17 103.09,95.03
  BOTTOM w0.114: 103.09,95.03 103.09,94.63 101.65,93.19 101.65,87.69 98.12,84.16 92.8,84.16 TP95.1
N62640782: length 17.1
  TOP w0.114: v2(102.56,101.94) 101.97,101.35 101.18,101.35 100.76,100.93 98.05,100.93 94.08,96.96 93.58,96.96 92.4,95.78 89.81,95.78 TP96.1
  BOTTOM w0.076: UC1.F61 v2(102.56,101.94)
N62640784: length 13.2
  TOP w0.114: v2(101.92,101.94) 101.55,101.57 100.89,101.57 100.49,101.18 97.95,101.18 93.98,97.2 91.82,97.2 91.69,97.33 TP97.1
  BOTTOM w0.076: UC1.E61 v2(101.92,101.94)
N62640818: length 6.9
  TOP w0.114: v2(119.61,96.94) 120.87,96.94 121.89,95.93 125.5,95.93 TP98.1
  BOTTOM w0.076: UC1.AW69 119.64,96.98 v2(119.61,96.94)
N62640820: length 8
  TOP w0.114: v2(120.23,97.58) 121.13,97.58 122.28,96.43 126.32,96.43 TP99.1
  BOTTOM w0.076: UC1.AW68 120.01,97.82 v2(120.23,97.58)
N62640854: length 8.3
  TOP w0.114: TP100.1 124.36,99.81 122.54,101.63 121.69,101.63 v2(118.63,104.69)
  BOTTOM w0.076: UC1.AU56 v2(118.63,104.69)
N62640856: length 27.3
  TOP w0.114: TP101.1 128.02,95.96 v2(128.02,96.53)
  BOTTOM w0.076: 120.94,109.4 120.65,109.69 119.91,109.69 119.58,110.02 UC1.AW48
  BOTTOM w0.114: v2(128.02,96.53) 128.23,96.53 133.45,101.75 133.45,104.57 129.78,108.24 125.33,108.24 125.08,108.49 124.19,108.49 123.55,109.13 122.79,109.13 122.52,109.4 120.94,109.4
N62640904: length 11.7
  TOP w0.114: TP102.1 90.46,136.12 95.54,136.12 96.99,134.68 v2(97.01,134.68)
  BOTTOM w0.076: v2(97.01,134.68) 97.74,133.95 99.24,133.95 99.28,133.97 99.59,133.97 99.64,133.93 99.71,133.93 100.09,133.55 UC1.C7
N62640906: length 1.3
  TOP w0.114: TP103.1 108.29,131.04 v2(108.29,130.78)
  BOTTOM w0.076: UC1.U12 v2(108.29,130.78)
N62640922: length 23.4
  TOP w0.114: TP104.1 112.62,148.18 110,148.18 v1(109.92,148.1)
  BOTTOM w0.076: 110.47,138.04 110.45,138.03 110.45,137.46 110.51,137.4 110.51,136.9 110.41,136.8 110.41,136.7 110.51,136.6 110.51,135.58 110.38,135.45 110.18,135.45 109.92,135.2 109.92,134.69 109.67,134.44 109.67,132.48 109.44,132.25 109.44,131.67 109.19,131.42 108.2,131.42 107.87,131.09 UC1.U11
  BOTTOM w0.114: v1(109.92,148.1) 109.85,148.03 109.85,145.98 110.57,145.26 110.57,142.5 110.15,142.08 110.15,139.77 110.31,139.61 110.31,139 110.47,138.84 110.47,138.04
N62640924: length 4
  TOP w0.114: v2(103.19,130.29) 102.45,130.29 102,129.84 101.05,129.84 100.63,129.42 TP105.1
  BOTTOM w0.076: UC1.H11 103.31,130.49 v2(103.19,130.29)
N62641188: length 3.5
  TOP w0.114: v2(101.92,133.03) 102.41,133.52 103.12,133.52 103.98,134.39 TP106.1
  BOTTOM w0.076: UC1.F6 v2(101.92,133.03)
N62641190: length 15
  BOTTOM w0.076: 99.75,139.28 101.2,137.83 101.2,137.45 101.35,137.29 101.35,136.29 101.06,136 UC1.E3
  BOTTOM w0.114: 99.75,139.28 96.69,139.28 96.37,139.59 94.28,139.59 92.19,141.68 90.72,141.68 TP107.1
N62641192: length 12.4
  BOTTOM w0.076: UC1.C11 99.78,131.25 99.53,131.33 99.35,131.33 99.16,131.27 99.01,131.27 98.9,131.33 98.81,131.42 98.01,131.42 97.28,132.15 97.05,132.15
  BOTTOM w0.114: 97.05,132.15 92.69,132.15 92.37,131.83 91.95,131.83 91.2,131.09 91.2,128.98 TP108.1
N62641208: length 15.2
  BOTTOM w0.076: UC1.B11 99.32,130.95 99.09,130.95 98.94,130.8 98.63,130.8 98.34,131.09 97.81,131.09 97.24,131.67
  BOTTOM w0.114: TP109.1 90.34,126.79 91.73,128.18 91.73,130.93 92.15,131.35 92.57,131.35 92.89,131.67 97.24,131.67
N62641224: length 13
  BOTTOM w0.076: 97.32,131.85 97.32,131.85 97.92,131.25 98.6,131.25 UC1.A11
  BOTTOM w0.114: 97.32,131.85 97.26,131.91 92.79,131.91 92.47,131.59 92.05,131.59 91.49,131.03 91.49,128.28 90.89,127.68 TP110.1
N62641226: length 2.7
  TOP w0.114: TP111.1 99.92,130.35 101.13,130.35 v2(101.19,130.29)
  BOTTOM w0.114: UC1.D12 100.98,130.5 v2(101.19,130.29)
N62641228: length 16.7
  BOTTOM w0.076: 97.23,131.42 97.89,130.76 98.18,130.76 98.3,130.64 99.24,130.64 99.37,130.5 UC1.C12
  BOTTOM w0.114: 97.23,131.42 92.99,131.42 92.67,131.11 92.25,131.11 91.97,130.83 91.97,128.08 90.43,126.54 89.91,126.54 89.15,125.78 TP112.1
N62641230: length 2.3
  TOP w0.114: TP113.1 100.68,106.19 v2(101.92,107.43)
  BOTTOM w0.076: UC1.F52 v2(101.92,107.43)
N62685817: length 20.1
  TOP w0.254: v1(87.48,118.27) 87.48,117.63 86.21,116.36 v4(85.45,116.36) 84.72,117.1 RC121.1
  IN3 w0.254: v1(87.48,118.27) 88.5,119.29 97.64,119.29 98.53,118.4 v2(101.29,118.4)
  BOTTOM w0.076: UC1.E32 v2(101.29,118.4)
N62687376: length 20.1
  TOP w0.254: RC142.1 84.13,118.14 v4(85.45,118.14) 86.6,118.14 v1(86.72,118.27)
  IN3 w0.254: v1(86.72,118.27) 87.23,117.76 87.87,117.76 88.88,118.78 97.52,118.78 98.53,117.76 101.45,117.76 101.92,118.23 v2(101.92,118.4)
  BOTTOM w0.076: UC1.E33 v2(101.92,118.4)
N62693311: length 2.3
  TOP w0.254: v4(100.62,133.33) 100.67,133.33 v2(101.29,133.95) 101.63,134.29 RC360.1
  BOTTOM w0.254: UC1.E5 v2(101.29,133.95)
N62870607: length 2.1
  TOP w0.114: T56.1 116.38,131.56 116.38,130.58 v2(116.09,130.29)
  BOTTOM w0.076: v2(116.09,130.29) 115.7,130.68 UC1.AN11
N62959739: length 6.3
  TOP w0.254: RC124.2 104.07,92.09 v1(104.06,92.1)
  BOTTOM w0.076: 103.81,95.3 103.81,95.99 103.94,96.12 103.94,96.54 103.82,96.79 103.81,96.79 103.81,96.8 103.67,96.94 UC1.J70
  BOTTOM w0.254: 103.81,95.3 103.67,95.17 103.67,93.82 v4(103.5,93.65) 103.5,92.66 v1(104.06,92.1)
N62959779: length 8.6
  TOP w0.254: v1(104.14,90.58) 104.07,90.51 RC183.2
  BOTTOM w0.076: 104.06,94.99 104.06,95.47 103.97,95.56 103.97,95.92 104.1,96.05 104.1,96.57 103.94,96.98 103.94,97.27 103.67,97.53 UC1.J69
  BOTTOM w0.254: v1(104.14,90.58) 104.64,91.08 v4(104.64,91.61) 104.64,92.48 104.06,93.06 104.06,94.99
N62960030: length 5.1
  TOP w0.203: RC126.1 99.99,125.64 100.37,125.25 101.5,125.25 101.94,124.81 ; 101.94,124.81 101.94,124.85 102.35,125.25 102.76,125.25 v2(103.21,124.8) ; 101.94,124.81 v4(101.94,124.61)
  BOTTOM w0.076: UC1.H21 103.46,125.06 v2(103.21,124.8)
N62960070: length 4.5
  TOP w0.203: v2(103.26,125.72) 102.82,126.16 v4(100.97,126.16) 100.04,126.16 99.68,126.52 RC185.1
  BOTTOM w0.076: v2(103.26,125.72) 103.46,125.9 UC1.H20
N63157869: length 10.1
  TOP w0.305: 120.07,64.04 120.07,63.5 120.16,63.41 JCP.6
  TOP w0.508: v1(125.34,68.75) 125.34,68.5 124.95,68.1 v4(123.19,68.1) 120.07,64.98 120.07,64.04
  BOTTOM w0.508: v1(125.34,68.75) 125.72,68.75 125.91,68.94 R58.2
N63295136: length 5.4
  TOP w0.508: v4(217.49,161.96) 213.71,161.96 PR202.2 213.71,161.96 212.1,161.96 PC203.1
N63299821: length 4.3
  BOTTOM w0.254: PC229.2 205.26,171.23 PR215.1 207.24,171.22 v4(208.22,172.21)
N63299840: length 3.7
  TOP w0.254: PR211.2 205.29,171.45 PR209.2 ; PR211.2 205.23,172.42 v4(205.8,172.99) ; PR211.2 205.23,170.89 PR210.2
