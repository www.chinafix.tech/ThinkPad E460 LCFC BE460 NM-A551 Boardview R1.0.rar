# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_DQS5: length 54.3
  TOP w0.127: UV7.C7 26.69,156.08 26.69,156.38 26.18,156.89 26.18,157.3 26.57,157.68 26.97,157.68 27.55,157.1 28.63,157.1 30.56,159.04 30.56,160.48 31.03,160.94 v1(34.36,160.94) 42.13,160.94 42.45,160.62 42.45,160.17 42.13,159.85 38.03,159.85 38.01,159.82 37.42,159.82 37.4,159.85 32.07,159.85 31.88,159.66 31.88,159.4 32.07,159.21 38.51,159.21 38.77,158.95 38.77,158.07 38.89,157.94 39.28,157.94 39.4,158.07 39.4,158.95 39.66,159.21 40.23,159.21 40.49,158.95 40.49,158.07 40.62,157.94 41,157.94 41.13,158.07 41.13,158.84 41.5,159.21 42.03,159.21 42.4,158.84 42.4,157.59 42.89,157.1 44.82,157.1 45.09,156.83 45.98,156.83 46.25,156.57 46.25,156.2 v2(45.95,155.9)
  BOTTOM w0.127: UV3.D10 45.64,155.9 v2(45.95,155.9)
FBA_DQS6: length 51.3
  BOTTOM w0.084: UV3.D6 45,159.74 43.87,159.74 43.58,160.03 42.92,160.03 42.88,159.99 42.87,159.99
  BOTTOM w0.127: 42.87,159.99 42.63,159.99 42.33,160.29 42.33,165.2 41.68,165.85 35.44,165.85 35.31,165.72 35.31,165.34 35.44,165.21 41.23,165.21 41.55,164.89 41.55,164.44 41.23,164.12 v1(37.47,164.12) 34.79,164.12 34.77,164.09 34.17,164.09 34.14,164.12 32.82,164.12 30.48,161.77 30.48,161.51 30.66,161.32 30.93,161.32 33.25,163.64 33.7,163.64 34.02,163.32 34.02,162.87 28.86,157.71 27.07,157.71 26.76,158.02 26.76,158.93 26.6,159.1 UV8.C7
FBA_DQS7: length 47.3
  IN1 w0.14: v1(24.34,156.79) 24.16,156.96 24.16,157.21 24.37,157.41 25.67,157.41 25.72,157.46 27.34,157.46 28.22,158.35 28.22,160.2 34.31,166.29 38.78,166.29 38.97,166.1 38.97,165.83 38.78,165.64 34.92,165.64 34.59,165.31 34.59,164.84 34.92,164.51 37.53,164.51 37.67,164.37 37.67,163.53 37.95,163.25 38.52,163.25 38.8,163.53 38.8,164.37 38.94,164.51 39.3,164.51 39.44,164.37 39.44,163.53 39.73,163.25 40.29,163.25 40.57,163.53 40.57,164.37 40.71,164.51 41.93,164.51 45.25,161.18 46.93,161.18 47.38,160.74 47.38,160.26 47.22,160.09 v2(46.73,160.09)
  BOTTOM w0.127: UV8.F3 24.04,155.97 24.04,156.49 v1(24.34,156.79) ; v2(46.73,160.09) 46.73,160.11 47.02,160.41 47.25,160.41 47.34,160.32 UV3.G5
FBA_DQS#0: length 47.8
  IN3 w0.14: v1(23.68,137.1) 23.68,137.1 23.88,136.9 23.88,136.3 24.13,136.05 25.47,136.05 25.9,135.62 25.9,133.55 26.87,132.58 28.46,132.58 31.24,129.8 34.08,129.8 34.28,129.6 34.28,128.91 34.62,128.57 35.1,128.57 35.44,128.91 35.44,129.65 35.58,129.79 35.95,129.79 36.09,129.65 36.09,128.86 36.37,128.58 36.94,128.58 37.22,128.86 37.22,129.65 37.36,129.79 37.72,129.79 37.86,129.65 37.86,128.86 38.14,128.58 44.55,128.58 48.5,132.53 48.5,134.88 48.21,135.17 48.21,141.14 47.67,141.67 47.67,142.13 v2(47.74,142.2)
  BOTTOM w0.102: v1(23.68,137.1) 23.89,136.9 23.89,136.66 23.48,136.25 23.48,136.13 UV5.G3
  BOTTOM w0.127: UV3.H27 v2(47.74,142.2)
FBA_DQS#1: length 50.9
  TOP w0.127: UV6.B7 27.22,135.87 27.03,135.87 26.91,135.99 26.91,136.46 27.28,136.83 28.1,136.83 28.24,136.68 28.62,136.68 28.77,136.83 29.15,136.83 29.29,136.68 29.67,136.68 29.81,136.83 30.25,136.83 31.03,137.61 31.03,143.92 31.26,144.15 31.51,144.15 31.54,144.13 32.13,144.13 32.15,144.15 34.17,144.15 34.37,143.95 34.37,143.61 34.17,143.41 v1(33.24,143.41) 32.01,143.41 31.68,143.08 31.68,142.62 32.01,142.3 32.95,142.3 33.15,142.09 33.15,141.74 32.95,141.54 32.11,141.54 31.82,141.24 31.82,136.57 35.31,133.08 39.69,133.08 42.84,136.24 42.84,139.54 42.94,139.64 43.97,139.64 44.3,139.98 44.3,141 43.97,141.34 43.38,141.34 43.22,141.5 43.22,142.17 43.34,142.29 v2(43.46,142.29)
  BOTTOM w0.102: UV3.A27 44.2,142.53 44.2,142.38 44.13,142.3 43.92,142.3 43.72,142.1 43.52,142.1 43.46,142.16 v2(43.46,142.29)
FBA_DQS#2: length 47.8
  TOP w0.127: v1(24.44,138.09) 24.59,138.24 24.59,138.42 24.46,138.55 23.82,138.55 23.6,138.77 23.6,139.04 23.48,139.16 UV6.G3
  IN1 w0.14: v1(24.44,138.09) 24.63,137.91 24.63,137.66 24.95,137.35 25.33,137.35 25.63,137.05 27.69,137.05 32.23,132.51 38,132.51 40.53,135.03 40.8,135.03 40.99,134.84 40.99,134.58 39.74,133.33 39.74,132.86 40.07,132.53 40.54,132.53 42.18,134.17 42.18,134.82 42.32,134.96 42.56,134.96 42.89,135.29 42.89,135.76 42.56,136.09 42.18,136.09 41.99,136.28 41.99,136.55 42.18,136.74 42.55,136.74 42.83,137.02 42.83,137.59 42.55,137.87 42.32,137.87 42.18,138.01 42.18,140.38 40.18,142.38 40.18,143.53 40.41,143.76 40.8,143.76 40.97,143.59 40.97,143.37 v1(40.79,143.19)
  BOTTOM w0.084: 42.33,145.75 42.34,145.76 42.38,145.76 42.81,146.19 44.55,146.19 UV3.C23
  BOTTOM w0.127: v1(40.79,143.19) 40.8,143.2 40.8,144.23 42.33,145.75
FBA_DQS#3: length 52.9
  BOTTOM w0.084: 42.3,149.12 42.32,149.12 42.35,149.15 42.71,149.15 42.82,149.26 43.74,149.26 43.87,149.39 44.23,149.39 44.32,149.3 44.52,149.3 44.75,149.3 44.84,149.38 45.04,149.38 45.12,149.3 45.2,149.3 45.39,149.11 45.39,148.78 45.33,148.73 45.21,148.73 UV3.C19
  BOTTOM w0.127: 42.3,149.12 41.57,149.12 41.55,149.1 40.95,149.1 40.92,149.12 40.5,149.12 39.76,148.38 39.76,148.38 v1(39.21,147.83) 38.61,147.23 38.61,147.05 39.03,146.63 39.03,146.26 38.62,145.85 38.25,145.85 37.83,146.27 37.65,146.27 37.02,145.64 36.57,145.64 36.25,145.96 36.25,146.42 38.63,148.79 38.63,149.06 38.44,149.24 38.18,149.24 31.58,142.65 31.13,142.65 30.81,142.97 30.81,143.42 35.36,147.97 35.36,148.15 35.09,148.42 34.91,148.42 30.35,143.85 30.35,137.92 30.02,137.59 27.78,137.59 27.31,138.06 27.31,138.17 27.5,138.35 27.5,138.97 UV5.B7
FBA_DQS#4: length 48.5
  TOP w0.114: UV7.G3 23.58,159.1 24.16,158.52 24.69,158.52 24.83,158.37 24.83,158.18 v1(24.77,158.11)
  IN3 w0.14: v1(41.79,153.01) 41.98,153.2 41.98,153.77 42.33,154.12 42.33,154.95 41.44,155.84 41.44,156.56 41.84,156.96 41.84,161.53 40.67,162.69 37.85,162.69 37.57,162.97 37.57,163.63 37.43,163.77 37.06,163.77 36.92,163.63 36.92,162.97 36.64,162.69 36.08,162.69 35.79,162.97 35.79,163.63 35.65,163.77 35.29,163.77 35.15,163.63 35.15,162.97 34.05,161.88 31.54,161.88 28.8,159.14 28.8,158.87 28.99,158.68 29.26,158.68 31.57,161 32.04,161 32.37,160.67 32.37,160.2 29.66,157.49 27.11,157.49 26.6,156.98 25.72,156.98 25.07,157.63 25.07,157.88 24.84,158.11 v1(24.77,158.11)
  BOTTOM w0.084: UV3.C15 44.94,152.36 44.82,152.48 44.42,152.48 arc(44.32,152.5) 44.23,152.56 44.11,152.56 arc(44.01,152.54) 43.92,152.48 43.84,152.4 42.27,152.4 42,152.67 42,152.79 v1(41.79,153.01)
FBA_DQS#5: length 54.2
  TOP w0.127: v2(45.82,156.44) 45.65,156.61 44.99,156.61 44.73,156.87 42.79,156.87 42.17,157.49 42.17,158.75 41.93,158.99 41.6,158.99 41.36,158.75 41.36,157.98 41.1,157.72 40.53,157.72 40.27,157.98 40.27,158.86 40.14,158.99 39.76,158.99 39.63,158.86 39.63,157.98 39.37,157.72 38.8,157.72 38.54,157.98 38.54,158.86 38.41,158.99 31.98,158.99 31.66,159.31 31.66,159.76 31.98,160.08 v1(37.71,160.08) 42.04,160.08 42.22,160.26 42.22,160.53 42.04,160.71 34.7,160.71 34.68,160.69 34.07,160.69 34.04,160.71 31.12,160.71 30.79,160.38 30.79,158.94 28.72,156.87 27.45,156.87 26.88,157.45 26.66,157.45 26.41,157.2 26.41,156.99 26.92,156.48 26.92,155.69 26.99,155.63 27.15,155.63 27.31,155.79 UV7.B7
  BOTTOM w0.127: UV3.E9 45.55,157.18 45.41,157.18 45.31,157.08 45.31,156.75 45.62,156.44 v2(45.82,156.44)
FBA_DQS#6: length 50.7
  BOTTOM w0.084: UV3.C5 44.94,159.95 44.89,159.91 43.94,159.91 43.65,160.2 42.9,160.2 42.88,160.22 42.87,160.22
  BOTTOM w0.127: 42.87,160.22 42.73,160.22 42.56,160.39 42.56,165.29 41.78,166.07 35.35,166.07 35.08,165.81 35.08,165.24 35.35,164.98 41.13,164.98 41.32,164.8 41.32,164.53 41.13,164.35 37.79,164.35 37.76,164.37 37.19,164.37 37.17,164.35 v1(34.47,164.35) 32.73,164.35 30.25,161.87 30.25,161.41 30.57,161.09 31.02,161.09 33.34,163.41 33.6,163.41 33.79,163.23 33.79,162.96 28.77,157.94 27.16,157.94 26.99,158.12 26.99,159.03 27.06,159.1 UV8.B7
FBA_DQS#7: length 47.4
  IN1 w0.14: v2(47.87,160.11) 47.62,160.36 47.62,160.84 47.03,161.42 45.35,161.42 42.03,164.75 40.61,164.75 40.33,164.47 40.33,163.63 40.19,163.49 39.83,163.49 39.69,163.63 39.69,164.47 39.4,164.75 38.84,164.75 38.56,164.47 38.56,163.63 38.42,163.49 38.05,163.49 37.91,163.63 37.91,164.47 37.63,164.75 35.02,164.75 34.83,164.94 34.83,165.21 35.02,165.4 38.88,165.4 39.21,165.73 39.21,166.2 38.88,166.53 34.21,166.53 27.98,160.3 27.98,158.45 27.24,157.71 25.62,157.71 25.57,157.65 24.27,157.65 23.92,157.31 23.92,157.1 v1(23.71,156.89)
  BOTTOM w0.127: v1(23.71,156.89) 23.71,156.88 23.81,156.78 23.81,156.4 UV8.G3 ; v2(47.87,160.11) 48.14,160.38 UV3.H4
FBA_MA0: length 78.3
  TOP w0.102: UV6.N3 18.37,139.02 18.37,138.73 17.69,138.05 v1(17.69,137.81) ; UV7.N3 18.51,158.95 17.74,158.18 v1(17.74,157.76)
  IN1 w0.084: v2(49.49,151.04) 49.49,151.61 49.29,151.8 46.72,151.8 46.38,152.14 45.67,152.14 45.36,152.45
  IN1 w0.102: 45.32,152.49 45.36,152.45
  IN1 w0.216: 45.32,152.49 45.32,152.83 44.68,153.47 43.95,153.47 43.95,153.47 43.58,153.47 43.58,153.47 43.36,153.47 41.98,153.47 41.98,153.47 41.6,153.47 41.6,153.47 40.74,153.47 40.73,153.48 40.62,153.48 40.6,153.49 39.61,153.49 39.07,152.95 36.24,152.95 34.58,151.29 33.99,151.29 33.2,152.08 32.8,152.08 32.6,151.87 32.6,151.57 32.95,151.21 32.95,150.91 32.74,150.7 32.44,150.7 32.08,151.06 31.78,151.06 31.45,150.73 31.45,150.41 31.86,150 31.86,149.79 31.57,149.5 31.36,149.5 31,149.86 30.58,149.86 30.05,149.32 28.76,149.32 28.5,149.07 28.5,148.9 28.64,148.77 31.47,148.77 31.63,148.61 31.63,148.33 31.47,148.18 20.35,148.18 19.93,147.75 16.89,147.75 16.74,147.61 v1(16.74,147.34)
  IN3 w0.114: v1(17.69,137.81) 17.57,137.93 17.57,138.26 17.68,138.37 17.68,138.74 16.37,140.05 16.37,141.4 17.42,142.45 17.42,145.82 17.76,146.16 17.76,146.39 17.3,146.84 16.97,146.84 16.74,147.08 v1(16.74,147.34) 16.74,148.54 17.11,148.91 17.11,151.02 16.37,151.76 16.37,152.12 16.43,152.18 16.43,154.11 16.46,154.14 16.46,155.73 17.71,156.98 17.71,157.73 v1(17.74,157.76)
  BOTTOM w0.102: v1(17.69,137.81) 17.69,137.15 18.5,136.34 18.5,135.97 UV5.N3 ; UV8.N3 18.51,156.16 17.74,156.93 v1(17.74,157.76) ; v2(49.49,151.04) 49.49,150.51 49.6,150.4 UV3.K17
FBA_MA1: length 82.4
  TOP w0.102: v1(15.94,137.84) 15.94,137.14 16.12,136.95 16.71,136.95 16.84,136.82 16.84,136.56 16.97,136.43 17.11,136.43 17.2,136.52 17.36,136.52 17.46,136.43 17.46,136.27 17.38,136.19 17.38,135.99 17.48,135.88 17.63,135.88 UV6.P7 ; v1(15.91,157.75) 15.91,157.09 16.23,156.76 16.83,156.76 16.99,156.6 17.01,156.6 17.02,156.59 17.33,156.59 17.7,156.22 17.7,155.91 UV7.P7
  IN1 w0.084: v2(48.63,148.5) 49.06,148.93 49.33,148.93 49.46,149.06 49.46,149.21 49.39,149.28 48.61,149.28 48.34,149.02 46.84,149.02 46.69,149.17 46.69,149.61 46.46,149.84 44.31,149.84 43.77,150.38
  IN1 w0.216: v1(15.03,146.66) 15.54,146.66 16.14,146.06 16.14,145.66 16.59,145.21 16.59,145.01 16.39,144.81 16.39,144.16 16.58,143.97 16.84,143.97 16.99,144.13 16.99,144.51 17.15,144.66 17.36,144.66 17.52,144.51 17.52,143.64 17.75,143.41 18.18,143.41 18.35,143.58 18.35,143.78 18.49,143.92 18.87,143.92 19.22,143.56 19.53,143.56 19.89,143.92 20.51,143.92 20.88,144.29 21.08,144.29 21.42,143.95 21.74,143.95 21.93,144.14 21.93,144.4 21.56,144.78 21.56,144.97 21.89,145.3 22.77,145.3 23.16,145.69 23.52,145.69 23.85,145.35 26.79,145.35 27.36,144.78 31.04,144.78 35.98,149.72 36.61,149.72 36.91,149.42 37.68,149.42 37.98,149.72 38.79,149.72 39.1,149.42 39.96,149.42 40.27,149.72 42.53,149.72 43.18,150.38 43.77,150.38
  IN3 w0.114: v1(15.94,137.84) 16.06,137.96 16.06,138.14 15.82,138.38 15.82,138.81 14.5,140.12 14.5,141.38 15.32,142.2 15.32,142.37 15.41,142.46 15.57,142.46 15.66,142.55 15.66,142.67 15.57,142.76 15.41,142.76 15.32,142.85 15.32,144.5 14.97,144.85 14.97,145.09 15.16,145.28 15.16,145.39 14.97,145.57 14.97,145.73 15.16,145.91 15.16,146.12 14.87,146.41 14.87,146.5 v1(15.03,146.66) 14.93,146.76 14.93,150.61 14.21,151.33 14.21,155.36 15.91,157.06 v1(15.91,157.75)
  BOTTOM w0.102: UV8.P7 17.71,158.9 17.52,158.72 16.88,158.72 v1(15.91,157.75) ; v2(48.63,148.5) 48.64,148.5 48.64,148.3 UV3.J20 ; v1(15.94,137.84) 15.94,138.09 16.17,138.33 16.27,138.33 16.43,138.17 16.54,138.17 16.65,138.28 16.65,138.42 16.53,138.55 16.53,138.65 16.63,138.76 16.92,138.76 16.99,138.69 17.51,138.69 17.71,138.89 UV5.P7
FBA_MA2: length 88.4
  TOP w0.102: v1(15.03,157.75) 14.63,157.75 14.56,157.82 14.56,158.15 14.91,158.5 15.3,158.5 15.48,158.33 15.88,158.33 16.03,158.48 17.2,158.48 17.71,158.98 UV7.P3 ; UV6.P3 17.54,138.99 17.54,138.7 17.37,138.53 15.94,138.53 15.54,138.14 15.42,138.14 15.33,138.22 15.33,138.35 15.56,138.58 15.56,138.71 15.47,138.79 15.35,138.79 14.61,138.05 14.61,137.92 14.7,137.83 v1(15.06,137.83)
  IN1 w0.102: 45.36,147.65 45.41,147.6 46.28,147.6 47.61,146.26 47.68,146.26 v2(47.72,146.31)
  IN1 w0.216: 45.36,147.65 45.32,147.7 43.08,147.7 43.05,147.73 36.36,147.73 31.69,143.06 26.71,143.06 26.09,143.68 23.84,143.68 22.25,142.09 21.59,142.09 20.99,141.49 20.59,141.49 20.38,141.27 20.38,140.68 20.16,140.47 19.86,140.47 19.65,140.68 19.65,141.27 19.2,141.73 16.35,141.73 14.28,143.8 14.28,144.83 v1(14.14,144.96)
  IN3 w0.114: v1(15.03,157.75) 15.03,157.08 13.37,155.43 13.37,150.88 13.65,150.6 13.65,150.22 13.98,149.89 13.98,148.47 14.13,148.32 14.13,146.24 14.28,146.09 14.28,145.1 v1(14.14,144.96) 14.14,144.9 13.85,144.61 13.85,144.51 13.98,144.38 14.1,144.38 14.24,144.51 14.37,144.51 14.47,144.42 14.47,144.29 14.22,144.03 14.22,143.94 14.28,143.87 14.56,143.87 14.66,143.77 14.66,143.62 14.56,143.51 13.95,143.51 13.85,143.41 13.85,143.27 13.95,143.17 14.56,143.17 14.66,143.06 14.66,142.92 14.56,142.81 13.96,142.81 13.86,142.71 13.86,142.56 13.96,142.46 14.34,142.46 14.44,142.36 14.44,142.22 14.34,142.12 13.98,142.12 13.86,142 13.86,139.85 13.97,139.75 13.97,139.6 13.9,139.53 13.9,139.37 14,139.27 14.16,139.27 14.23,139.34 14.38,139.34 14.49,139.23 14.49,139.08 14.42,139.01 14.42,138.85 14.52,138.75 14.68,138.75 14.75,138.82 14.9,138.82 15.01,138.71 15.01,138.56 14.94,138.49 14.94,138.29 15.15,138.08 15.15,137.92 v1(15.06,137.83)
  BOTTOM w0.102: v1(15.06,137.83) 15.2,137.83 15.29,137.73 15.29,137.58 15.06,137.35 15.06,137.2 14.97,137.11 14.97,136.89 15.07,136.78 15.52,136.78 15.7,136.6 15.8,136.6 15.9,136.7 15.9,136.88 16,136.99 16.15,136.99 16.26,136.88 16.26,136.7 16.36,136.6 16.51,136.6 16.72,136.8 16.82,136.8 17.02,136.6 17.56,136.6 17.9,136.26 17.9,136.15 UV5.P3 ; UV8.P3 17.71,156.02 17.17,156.56 16.48,156.56 16.03,157 15.88,157 15.4,156.52 15.2,156.52 15.03,156.68 v1(15.03,157.75) ; UV3.H23 48.14,145.83 47.72,146.25 v2(47.72,146.31)
FBA_MA3: length 85.4
  TOP w0.102: UV6.N2 18.4,139.85 18.4,139.61 18.12,139.33 18.12,138.81 17.59,138.29 16.59,138.29 16.37,138.07 v1(16.37,137.38) ; UV7.N2 18.51,159.87 18.09,159.46 18.09,158.91 17.41,158.22 16.66,158.22 16.37,157.94 v1(16.37,157.24)
  IN1 w0.114: 45.16,148.95 46.01,148.1 48.28,148.1 48.97,147.41 48.97,145.23 48.76,145.01 48.08,145.01 v2(47.74,145.35)
  IN1 w0.216: 45.16,148.95 42.67,148.95 42.3,148.58 36.02,148.58 31.39,143.94 27.01,143.94 26.44,144.51 23.49,144.51 21.9,142.93 20.89,142.93 20.36,142.4 19.71,142.4 19.54,142.57 16.78,142.57 15.44,143.91 15.44,144.93 v1(15.47,144.96)
  IN3 w0.114: v1(16.37,157.24) 16.24,157.11 16.24,156.95 14.53,155.23 14.53,151.46 15.25,150.74 15.25,147.22 15.47,147 v1(15.47,144.96) 15.65,144.79 15.65,143.15 15.75,143.05 15.9,143.05 16,143.15 16,145.03 16.11,145.13 16.26,145.13 16.38,145.01 16.38,142.82 14.82,141.25 14.82,140.26 16.18,138.89 16.18,138.46 16.37,138.27 16.37,137.35 16.36,137.37 16.36,137.38 16.37,137.38 v1(16.37,137.38)
  BOTTOM w0.102: v1(16.37,157.24) 16.79,156.83 17.44,156.83 18.09,156.18 18.09,155.74 18.24,155.6 18.24,155.37 UV8.N2 ; v2(47.74,145.35) 47.34,145.75 UV3.G23 ; v1(16.37,137.38) 16.37,137.38 16.61,137.38 17.11,136.87 17.61,136.87 18.13,136.35 18.13,135.53 UV5.N2
FBA_MA4: length 91.6
  TOP w0.102: UV7.P8 17.3,155.5 15.12,155.5 14.27,156.35 14.05,156.35 13.64,156.77 13.64,156.77 v1(13.64,157.22) ; UV6.P8 17.69,135.16 17.28,135.58 14.14,135.58 13.69,136.03 13.69,136.5 13.21,136.97 13.21,137.18 13.44,137.41 v1(13.72,137.41)
  IN1 w0.102: 45.24,147.3 46.07,147.3 46.56,146.81 46.56,145.82 46.94,145.44 v2(46.94,145.42)
  IN1 w0.216: v1(12.7,144.6) 12.7,143.98 15.12,141.56 15.65,141.56 16.36,140.85 16.36,140.55 17.14,139.77 20.67,139.77 23.86,142.96 26.22,142.96 26.6,142.58 31.8,142.58 36.52,147.3 40.35,147.3 40.39,147.33 45.2,147.33 45.24,147.3
  IN3 w0.114: v1(13.72,137.41) 13.72,138.2 12.24,139.68 12.24,140.54 12.35,140.65 12.81,140.65 12.89,140.73 12.89,140.95 12.82,141.02 12.35,141.02 12.24,141.13 12.24,141.28 12.35,141.39 12.8,141.39 12.89,141.48 12.89,141.66 12.8,141.76 12.33,141.76 12.24,141.84 12.24,142.07 12.33,142.15 12.8,142.15 12.89,142.24 12.89,142.43 12.8,142.52 12.33,142.52 12.24,142.6 12.24,142.8 12.33,142.89 12.81,142.89 12.89,142.97 12.89,143.17 12.81,143.25 12.35,143.25 12.24,143.36 12.24,144.15 v1(12.7,144.6) 12.7,144.85 13.07,145.22 13.07,145.73 12.94,145.85 12.94,147.7 12.7,147.94 12.7,150.2 12.42,150.48 12.42,155.87 13.64,157.09 v1(13.64,157.22)
  BOTTOM w0.102: UV8.P8 17.33,159.52 15.32,159.52 13.64,157.84 v1(13.64,157.22) ; v2(46.94,145.42) 46.94,145.44 47.34,145.03 UV3.G24 ; v1(13.72,137.41) 13.72,138.14 13.68,138.19 13.68,138.56 13.52,138.72 13.52,139.28 13.82,139.58 17.33,139.58 UV5.P8
FBA_MA5: length 91.1
  TOP w0.102: UV6.P2 17.71,140.08 17.89,140.27 18.05,140.27 18.13,140.19 18.13,139.68 18.02,139.57 17.54,139.57 17.31,139.35 17.31,139.09 17.31,139.09 17.31,138.95 17.14,138.78 15.9,138.78 15.63,139.05 15.26,139.05 15.01,138.79 15.01,138.79 14.78,138.57 14.78,138.57 14.5,138.29 14.5,138.29 14.16,137.94 v1(14.16,137.89) ; v1(14.11,157.68) 14.11,158.05 14.78,158.72 14.8,158.72 14.82,158.74 15.39,158.74 15.41,158.72 17.06,158.72 17.33,158.99 17.33,159.58 17.64,159.9 UV7.P2
  IN1 w0.114: v2(48.55,145.43) 48.19,145.8 48.19,147.47 47.81,147.84 45.81,147.84 45.41,148.24 45.37,148.24
  IN1 w0.216: 45.37,148.24 45.03,148.58 43.09,148.58 42.67,148.16 36.2,148.16 31.53,143.49 26.87,143.49 26.27,144.1 23.66,144.1 22.08,142.51 21.42,142.51 20.82,141.91 19.61,141.91 19.37,142.15 16.56,142.15 14.77,143.94 14.77,145.09 14.69,145.17 14.68,145.17 14.12,145.72 v5(13.52,145.72)
  IN3 w0.114: v1(14.11,157.68) 14.11,157.07 12.74,155.7 12.74,150.61 13.02,150.33 13.02,148.08 13.39,147.71 13.39,145.86 v5(13.52,145.72) 13.39,145.59 13.39,145.09 13.14,144.84 13.14,144.3 13.43,144.02 13.43,143.89 13.3,143.76 13.12,143.76 12.81,144.08 12.68,144.08 12.56,143.96 12.56,143.69 12.68,143.57 12.94,143.57 13.21,143.3 13.21,140.47 13.07,140.33 12.65,140.33 12.57,140.25 12.57,140.09 12.65,140.02 13.12,140.02 13.21,139.93 13.21,139.78 13.14,139.71 12.88,139.71 12.81,139.63 12.81,139.56 14.16,138.21 v1(14.16,137.89)
  BOTTOM w0.102: v2(48.55,145.43) 48.56,145.43 48.56,145.42 48.14,145 UV3.H24 ; UV5.P2 17.32,135.55 17.32,136.09 17.07,136.34 15.94,136.34 15.75,136.15 15.63,136.15 15.53,136.25 15.53,136.44 15.42,136.55 15.27,136.55 15.18,136.46 15.18,136.31 15.08,136.2 14.93,136.2 14.82,136.31 14.82,136.63 14.62,136.83 14.46,136.83 14.16,137.13 v1(14.16,137.89) ; v1(14.11,157.68) 14.11,157.13 15.01,156.23 15.57,156.23 15.65,156.32 17.08,156.32 17.33,156.06 17.33,155.48 UV8.P2
FBA_MA6: length 95.3
  TOP w0.102: v1(11.08,137.97) 11.09,137.96 11.09,137.45 13.77,134.77 16.53,134.77 UV6.R8 ; v1(10.93,157.64) 10.93,157.16 13.4,154.69 16.51,154.69 UV7.R8
  IN1 w0.084: v2(48.69,149.7) 48.31,150.07 44.62,150.07 44.37,150.32
  IN1 w0.216: v1(10.64,147.23) 10.65,147.23 11.24,146.63 14.3,146.63 14.83,147.16 15.63,147.16 16.36,146.43 16.8,146.43 17.17,146.06 17.17,145.44 18.28,144.34 20.33,144.34 21.5,145.51 21.5,145.95 22.01,146.46 26.28,146.46 27.54,145.2 30.87,145.2 35.81,150.14 42.37,150.14 43.01,150.78 43.91,150.78 44.37,150.32
  IN3 w0.114: v1(10.93,157.64) 10.93,157.41 10.64,157.13 v1(10.64,147.23) 10.64,138.47 11.08,138.03 v1(11.08,137.97)
  BOTTOM w0.102: UV8.R8 16.91,159.9 16.51,160.3 15.85,160.3 15.8,160.34 13.55,160.34 10.93,157.72 v1(10.93,157.64) ; UV5.R8 16.53,140.34 12.38,140.34 11.02,138.98 11.02,138.03 v1(11.08,137.97) ; UV3.J19 48.94,149.45 v2(48.69,149.7)
FBA_MA7: length 95
  TOP w0.102: v1(11.59,137.58) 11.59,138.49 13.45,140.35 16.52,140.35 UV6.R2 ; v1(11.44,157.23) 11.44,157.99 12.86,159.41 13.23,159.41 14.09,160.27 14.85,160.27 14.85,160.27 16.53,160.27 16.65,160.16 UV7.R2
  IN1 w0.084: 45.03,150.4 45.11,150.32 48.64,150.32 v5(49.27,149.69)
  IN1 w0.216: v1(11.33,147.26) 11.5,147.1 14.18,147.1 14.66,147.58 15.81,147.58 16.54,146.85 17.2,146.85 17.59,146.45 17.59,145.62 18.45,144.76 20.12,144.76 20.52,145.15 20.52,146.18 20.67,146.33 20.69,146.33 21.24,146.88 26.7,146.88 27.27,146.31 27.93,146.31 28.17,146.06 28.17,146.06 28.61,145.62 30.69,145.62 35.63,150.56 42.18,150.56 42.78,151.16 42.78,151.55 43.08,151.85 44.1,151.85 44.38,151.57 44.38,151.05 45.03,150.4
  IN3 w0.114: v1(11.59,137.58) 11.59,138.34 10.97,138.96 10.97,145.86 11.08,145.97 11.08,147.02 v1(11.33,147.26) 11.33,147.46 10.97,147.82 10.97,156.77 11.43,157.23 v1(11.44,157.23)
  BOTTOM w0.102: v1(11.59,137.58) 11.59,137.29 14.09,134.78 16.53,134.78 UV5.R2 ; UV8.R2 16.5,154.69 13.88,154.69 11.44,157.13 v1(11.44,157.23) ; v5(49.27,149.69) 49.74,149.22 UV3.K19
FBA_MA8: length 92
  TOP w0.102: v1(12.07,138.32) 12.07,136.81 13.68,135.2 16.07,135.2 UV6.T8 ; v1(11.89,157.73) 11.89,156.64 13.43,155.1 13.68,155.1 13.79,155.2 13.79,155.44 13.89,155.54 14.17,155.54 14.27,155.44 14.27,155.2 14.38,155.1 UV7.T8
  IN1 w0.084: v2(48.51,152.23) 47.82,152.91 47.81,152.91 47.63,153.09 47.63,153.6 47.45,153.78 46.97,153.78 46.79,153.6 46.54,153.6 46.39,153.75 45.46,153.75
  IN1 w0.216: v1(11.43,148.56) 10.72,148.56 10.57,148.71 10.57,149.46 10.72,149.61 11.39,149.61 11.62,149.38 13.03,149.38 13.09,149.38 14.05,148.42 16.11,148.42 16.29,148.59 19.36,148.59 19.65,148.88 19.65,149.26 19.97,149.58 27.82,149.58 28.41,150.16 29.7,150.16 32.46,152.91 33.61,152.91 34.09,152.43 34.54,152.43 35.89,153.79 38.72,153.79 39.45,154.52 40.56,154.52 40.9,154.17 43.84,154.17 44.27,154.6 44.73,154.6 45.1,154.23 45.1,154.11 45.46,153.75
  IN3 w0.114: v1(12.07,138.32) 12.06,138.32 11.29,139.09 11.29,145.73 11.4,145.84 11.4,146.71 11.77,147.08 11.77,147.5 11.34,147.94 11.34,148.47 v1(11.43,148.56) 11.29,148.69 11.29,149.07 11.34,149.12 11.6,149.12 11.72,149.25 11.72,149.42 11.6,149.54 11.36,149.54 11.28,149.62 11.28,156.6 11.44,156.76 11.74,156.76 11.89,156.91 v1(11.89,157.73)
  BOTTOM w0.102: v1(11.89,157.73) 11.89,158.24 13.76,160.11 14.01,160.11 14.1,160.02 14.1,159.6 14.2,159.5 14.35,159.5 14.46,159.6 14.46,160.02 14.55,160.11 15.5,160.11 15.71,159.9 UV8.T8 ; v1(12.07,138.32) 12.07,139.4 12.49,139.82 13.25,139.82 13.42,139.99 16.08,139.99 UV5.T8 ; UV3.J14 48.94,152.8 48.51,152.37 v2(48.51,152.23)
FBA_MA9: length 94.2
  TOP w0.102: v1(12.81,137.34) 12.81,138.06 14.3,139.54 16.52,139.54 UV6.R3 ; UV7.R3 16.91,159.1 16.51,159.49 15.84,159.49 15.73,159.61 14.26,159.61 13.56,158.92 13.56,158.65 13.08,158.17 12.73,158.17 12.5,157.94 12.5,157.59 12.7,157.39 v1(12.7,157.22)
  IN1 w0.084: v2(49.38,153.29) 49.38,153.95 48.98,154.35 48.98,155.96 48.75,156.19 48.39,156.19 48.14,156.45 48.14,156.78 47.92,157 46.76,157 46.17,157.59 45.67,157.59
  IN1 w0.216: 45.67,157.59 45.01,157.59 44.29,158.31 41.24,158.31 40.52,157.59 35.41,157.59 34.13,156.3 32.28,156.3 28.74,152.75 22.92,152.75 22.48,153.19 15.24,153.19 v1(11.93,149.88)
  IN3 w0.114: v1(12.81,137.34) 12.52,137.63 12.52,138.5 11.61,139.42 11.61,145.6 11.72,145.7 11.72,146.58 12.09,146.95 12.09,147.63 12.05,147.67 12.05,149.76 v1(11.93,149.88) 11.73,149.88 11.6,150.01 11.6,150.38 11.79,150.56 11.79,150.74 11.6,150.93 11.6,151.11 11.79,151.3 11.79,151.48 11.6,151.67 11.6,151.85 11.79,152.04 11.79,152.22 11.6,152.41 11.6,152.59 11.79,152.77 11.79,152.95 11.6,153.14 11.6,153.32 11.79,153.51 11.79,153.69 11.6,153.88 11.6,154.06 11.79,154.25 11.79,154.43 11.6,154.61 11.6,154.8 11.79,154.98 11.79,155.16 11.6,155.35 11.6,155.54 11.79,155.72 11.79,155.9 11.6,156.09 11.6,156.31 11.73,156.43 12.07,156.43 12.33,156.69 12.33,156.9 12.21,157.02 12.21,157.39 12.35,157.53 12.35,157.92 12.13,158.14 12.13,158.29 12.24,158.39 12.39,158.39 12.73,158.05 12.73,157.25 v1(12.7,157.22)
  BOTTOM w0.102: v1(12.81,137.34) 13.05,137.1 13.06,137.1 14.62,135.54 16.49,135.54 UV5.R3 ; UV8.R3 17.06,155.75 17.06,155.53 17,155.47 15.86,155.47 15.72,155.33 14.65,155.33 13.38,156.6 13.25,156.6 13.08,156.43 12.95,156.43 12.86,156.52 12.86,156.64 13.04,156.82 13.04,156.93 12.74,157.22 v1(12.7,157.22) ; UV3.K14 49.38,153.16 v2(49.38,153.29)
FBA_MA10: length 85.8
  TOP w0.102: UV7.L7 20.11,156.6 19.96,156.75 19.64,156.75 19.36,156.47 19.25,156.47 19.11,156.61 19.11,156.99 19.03,157.06 v1(19.03,157.13) ; v1(19.07,137.15) 19.07,136.91 19.31,136.67 20.27,136.67 20.34,136.6 20.34,136.43 20.25,136.34 19.75,136.34 19.66,136.25 19.66,136.12 19.74,136.05 20.02,136.05 UV6.L7
  IN1 w0.084: 45.72,157.17 46.11,157.17 46.79,156.49 47.32,156.49 47.6,156.21 47.93,156.21 48.33,155.8 v2(48.57,155.8)
  IN1 w0.216: 45.72,157.17 44.81,157.17 44.55,157.42 41.01,157.42 40.75,157.17 35.66,157.17 34.37,155.88 32.46,155.88 28.83,152.26 22.82,152.26 22.31,152.77 15.41,152.77 15.04,152.39 15.04,152.11 15.23,151.91 16.14,151.91 16.61,151.45 17.09,151.45 17.22,151.59 17.93,151.59 v1(18.03,151.69)
  IN3 w0.114: v1(19.07,137.15) 19.03,137.19 19.03,138.03 18.67,138.39 18.67,139.24 18.14,139.77 18.14,141.59 18.5,141.95 18.5,144.67 19.21,145.38 19.21,146.69 18.69,147.21 18.69,151.03 v1(18.03,151.69) 18.25,151.91 18.67,151.91 19.9,150.67 19.9,150.48 19.34,149.91 19.34,149.77 19.44,149.66 19.59,149.66 20.12,150.19 20.38,150.19 20.69,149.88 20.89,149.88 21.03,150.02 21.03,150.21 18.88,152.36 17.99,152.36 17.89,152.47 17.89,152.62 17.99,152.73 18.44,152.73 18.64,152.92 18.64,153.08 18.48,153.23 18.31,153.23 18.11,153.03 17.96,153.03 17.85,153.13 17.85,153.29 18.15,153.58 18.15,155 18.8,155.65 18.8,156.16 18.58,156.38 18.58,156.5 19.03,156.95 v1(19.03,157.13)
  BOTTOM w0.102: UV5.L7 19.71,139.55 19.16,139.55 18.9,139.29 18.9,139 18.83,138.92 18.83,138.2 19.03,138 19.03,137.19 ; v2(48.57,155.8) 48.6,155.8 48.94,155.46 UV3.J11 ; v1(19.03,157.13) 19.03,157.61 19.23,157.81 19.35,157.81 19.51,157.96 19.51,158.19 20,158.68 20,158.98 UV8.L7
  BOTTOM w0.114: 19.03,137.19 v1(19.07,137.15)
FBA_MA11: length 81.3
  TOP w0.102: UV6.R7 16.74,136.13 16.5,136.13 15.5,137.13 v1(15.5,137.21) ; UV7.R7 17.13,155.9 17.35,156.11 17.35,156.21 17.21,156.35 16.2,156.35 15.47,157.08 v1(15.47,157.24)
  IN1 w0.084: v2(48.61,154.54) 48.61,155.11 48.48,155.24 46.85,155.24 46.51,155.58 46.16,155.58 46.1,155.52 45.8,155.52 45.5,155.82 45.5,156
  IN1 w0.216: 45.5,156 45.42,156.08 44.67,156.08 44.17,156.58 41.69,156.58 41.35,156.24 38.97,156.24 38.72,155.99 38.72,155.56 38.55,155.39 38.21,155.39 37.99,155.61 37.99,155.98 37.78,156.19 37.48,156.19 37.27,155.98 37.27,155.26 37.06,155.04 36.76,155.04 36.54,155.26 36.54,155.98 36.33,156.19 36.03,156.19 35.82,155.98 35.82,155.26 35.61,155.04 32.81,155.04 29.18,151.42 27.89,151.42 27.3,150.83 23.96,150.83 23.37,151.42 22.47,151.42 21.96,151.93 19.33,151.93 19.12,151.71 19.12,151.23 18.44,150.56 16.88,150.56 16.35,150.03 15.84,150.03 15.35,150.52 14.59,150.52 13.71,149.64 13.71,149.42 14.22,148.91 v1(14.48,148.91)
  IN3 w0.114: v1(15.5,137.21) 15.5,138.68 14.18,139.99 14.18,141.52 14.98,142.32 14.98,144.37 14.6,144.75 14.6,146.21 14.48,146.33 v1(14.48,148.91) 14.61,149.04 14.61,149.26 14.51,149.36 14.41,149.36 14.3,149.47 14.3,149.7 14.39,149.79 14.51,149.79 14.58,149.85 14.58,150.05 14.48,150.15 14.17,150.15 14.06,150.26 14.06,150.38 14.15,150.48 14.36,150.48 14.43,150.55 14.43,150.66 14.13,150.96 13.77,150.96 13.69,151.04 13.69,151.41 13.9,151.61 13.9,151.77 13.69,151.98 13.69,152.14 13.9,152.34 13.9,152.51 13.69,152.71 13.69,152.88 13.9,153.08 13.9,153.25 13.69,153.45 13.69,153.61 13.9,153.82 13.9,153.98 13.69,154.19 13.69,154.35 13.9,154.55 13.9,154.72 13.69,154.92 13.69,155.29 15.47,157.07 v1(15.47,157.24)
  BOTTOM w0.102: UV5.R7 16.67,139.16 15.53,138.02 15.53,137.24 v1(15.5,137.21) ; UV8.R7 16.76,158.95 16.5,158.95 16.25,158.7 15.91,158.7 15.75,158.55 15.75,158.41 15.86,158.31 15.86,158.22 15.78,158.14 15.67,158.14 15.62,158.19 15.49,158.19 15.4,158.1 15.4,157.97 15.47,157.89 v1(15.47,157.24) ; UV3.J13 48.73,154 48.59,154.15 48.59,154.52 v2(48.61,154.54)
FBA_MA12: length 83.5
  TOP w0.102: UV6.N7 18.51,136.25 17.46,137.3 17.25,137.3 17.25,137.31 17.25,137.31 v1(17.26,137.31) ; v1(17.28,157.24) 17.36,157.32 17.64,157.32 17.72,157.25 17.72,156.86 17.8,156.77 18.29,156.77 18.36,156.71 18.36,156.64 18.21,156.49 18.21,156.39 18.51,156.08 UV7.N7
  IN1 w0.084: 44.99,156.65 45.39,156.65 45.55,156.81 45.97,156.81 46.69,156.09 47.26,156.09 47.51,155.84 47.75,155.84 v2(47.91,155.68)
  IN1 w0.216: v1(16.04,150.52) 15.63,150.94 14.42,150.94 13.28,149.8 13.06,149.8 12.89,149.97 12.89,150.24 14.14,151.49 15.97,151.49 16.49,150.98 18.27,150.98 18.7,151.41 18.7,152.12 18.93,152.35 22.13,152.35 22.64,151.84 23.55,151.84 24.13,151.25 27.13,151.25 27.71,151.84 29.01,151.84 32.63,155.46 34.58,155.46 35.87,156.75 41.11,156.75 41.37,157 44.37,157 44.72,156.65 44.99,156.65
  IN3 w0.114: v1(17.26,137.31) 17.25,137.31 17.25,137.32 17.25,138.72 16.05,139.92 16.05,141.53 17.11,142.58 17.11,146.26 16.23,147.14 16.23,149.3 16.36,149.43 16.36,150.2 v1(16.04,150.52) 15.94,150.63 15.94,150.81 16.08,150.95 16.26,150.95 16.57,150.64 16.71,150.64 16.79,150.73 16.79,150.89 16.43,151.25 15.64,151.25 15.5,151.39 15.5,151.53 15.58,151.61 15.9,151.61 16.05,151.77 16.05,152.25 16.11,152.31 16.11,152.56 16.04,152.64 15.64,152.64 15.54,152.73 15.54,152.92 15.64,153.02 16.01,153.02 16.11,153.12 16.11,153.27 16.01,153.37 15.72,153.37 15.63,153.47 15.63,153.61 15.72,153.7 15.96,153.7 16.11,153.85 16.11,154.35 15.95,154.51 15.5,154.51 15.42,154.6 15.42,154.78 15.5,154.87 16.06,154.87 16.14,154.95 16.14,155.13 16.06,155.21 15.71,155.21 15.6,155.32 15.6,155.4 15.77,155.58 15.99,155.58 16.14,155.73 16.14,155.95 16.65,156.45 16.74,156.45 17.28,156.99 v1(17.28,157.24)
  BOTTOM w0.102: v2(47.91,155.68) 47.93,155.68 48.14,155.47 UV3.H11 ; v1(17.26,137.31) 17.25,137.31 17.25,137.32 17.25,137.96 17.48,138.19 17.49,138.19 17.52,138.22 17.82,138.22 18.51,138.9 18.51,139.16 UV5.N7 ; UV8.N7 18.73,158.88 18.73,158.53 18.57,158.38 18.07,158.38 17.86,158.16 17.34,158.16 17.24,158.07 17.24,157.28 v1(17.28,157.24)
FBA_MA13: length 86.5
  TOP w0.102: UV6.T3 15.99,139.28 15.17,139.28 14.91,139.03 14.79,139.03 14.54,139.28 14.45,139.28 14.29,139.13 14.29,139.03 14.55,138.77 14.55,138.66 14.41,138.52 14.3,138.52 14.03,138.79 13.96,138.79 13.81,138.64 13.81,138.52 13.93,138.39 13.93,138.25 13.85,138.16 13.74,138.16 13.56,138.33 13.47,138.33 13.28,138.15 v1(13.28,137.91) ; UV7.T3 15.85,159.1 15.62,159.33 14.3,159.33 13.81,158.83 13.81,158.55 13.19,157.93 v1(13.19,157.67)
  IN1 w0.216: v1(12.63,145.42) 11.77,145.42 11.58,145.61 11.58,145.93 11.86,146.21 14.23,146.21 14.86,145.58 15.63,145.58 15.97,145.24 15.97,143.99 16.97,142.99 19.72,142.99 19.87,142.83 20.2,142.83 20.72,143.35 21.73,143.35 22.35,143.97 22.35,144.52 22.72,144.88 23.18,144.88 23.23,144.93 26.62,144.93 27.19,144.36 31.21,144.36 35.85,149 41.89,149 42.2,149.3 45.42,149.3 46.15,148.57 v2(46.94,148.57)
  IN3 w0.114: v1(13.19,157.67) 13.19,157.09 12.1,156 12.1,150.34 12.37,150.08 12.37,147.8 12.63,147.54 v1(12.63,145.42) 12.43,145.42 12.32,145.53 12.32,146.45 12.24,146.53 12.12,146.53 12.03,146.45 12.03,145.57 11.93,145.46 11.93,145.14 12.01,145.06 12.19,145.06 12.3,144.94 12.3,144.79 12.19,144.68 12.02,144.68 11.93,144.59 11.93,139.55 13,138.48 13,138.31 12.84,138.16 12.84,137.86 12.93,137.77 13.14,137.77 v1(13.28,137.91)
  BOTTOM w0.102: v1(13.19,157.67) 13.19,157.11 13.27,157.03 13.27,157.01 13.45,156.84 13.48,156.84 14.41,155.9 16.11,155.9 UV8.T3 ; v2(46.94,148.57) 46.94,148.39 47.33,148 UV3.G20 ; UV5.T3 15.95,135.79 14.7,135.79 14.48,136.01 14.48,136.12 14.58,136.22 14.58,136.36 14.47,136.47 14.33,136.47 14.23,136.37 14.12,136.37 13.98,136.52 13.98,136.62 14.08,136.72 14.08,136.87 13.97,136.97 13.82,136.97 13.72,136.87 13.62,136.87 13.28,137.21 v1(13.28,137.91)
FBA_MA14: length 80.9
  TOP w0.102: v1(14.57,157.24) 14.25,157.24 14.09,157.08 14.09,156.89 14.45,156.53 14.61,156.53 14.73,156.65 14.87,156.65 14.98,156.54 14.98,156.4 14.84,156.26 14.84,156.14 15.08,155.9 16.11,155.9 UV7.T7 ; v1(14.62,137.35) 14.62,136.52 15.03,136.12 15.95,136.12 UV6.T7
  IN1 w0.102: v5(47.24,153.34) 47.25,153.34 47.15,153.24 47.15,153.11 46.41,152.36 45.82,152.36 45.64,152.54 45.64,153.03
  IN1 w0.216: 45.64,153.03 44.65,154.03 44.4,154.03 44.2,153.83 40.76,153.83 40.75,153.84 40.65,153.84 40.47,154.02 39.55,154.02 38.9,153.37 36.07,153.37 34.41,151.71 34.16,151.71 33.38,152.5 32.63,152.5 29.88,149.74 28.58,149.74 28.02,149.18 28.02,148.89 27.73,148.6 27.07,148.6 26.92,148.75 26.92,148.99 26.78,149.14 26.42,149.14 26.27,148.99 26.27,148.79 26.07,148.6 25.5,148.6 25.15,148.96 24.9,148.96 24.54,148.6 20.63,148.6 20.18,148.6 19.76,148.17 16.54,148.17 16.37,148 14.49,148 14,147.52 12.16,147.52 11.94,147.73 11.94,148.68 12.23,148.96 12.56,148.96 12.74,148.79 12.74,148.16 12.93,147.97 13.54,147.97 13.64,148.08 v1(13.64,148.08)
  IN3 w0.114: v1(14.62,137.35) 14.62,138.2 13.53,139.29 13.53,143.54 13.74,143.76 13.74,144.15 13.52,144.37 13.52,144.78 13.7,144.96 13.7,145.29 13.96,145.55 13.96,145.96 13.81,146.11 13.81,147.91 v1(13.64,148.08) 13.34,148.38 13.34,148.62 13.44,148.72 13.55,148.72 13.66,148.83 13.66,148.98 13.55,149.09 13.44,149.09 13.34,149.2 13.34,149.35 13.45,149.46 13.58,149.46 13.66,149.54 13.66,149.75 13.59,149.83 13.44,149.83 13.34,149.94 13.34,150.47 13.06,150.74 13.06,155.57 14.57,157.08 14.57,157.24 v1(14.57,157.24)
  BOTTOM w0.102: v5(47.24,153.34) 47.25,153.33 47.25,152.89 UV3.G14 ; v1(14.62,137.35) 14.62,138.15 15.63,139.16 UV5.T7 ; v1(14.57,157.24) 14.57,157.24 14.57,158.41 14.86,158.7 15.03,158.7 15.14,158.59 15.28,158.59 15.39,158.7 15.39,158.84 15.25,158.99 15.25,159.09 15.45,159.29 15.92,159.29 UV8.T7
FBA_MA15: length 83.4
  TOP w0.102: UV7.M7 19.12,156.09 19.12,156.25 18.59,156.78 18.59,156.81 18.57,156.83 18.57,157.3 19.12,157.85 v2(19.12,158.2) ; UV6.M7 18.97,136.3 18.97,136.65 18.64,136.98 18.64,137.31 18.89,137.56 19.2,137.56 v2(19.46,137.82)
  IN1 w0.084: 45.06,150.87 45.4,150.53 48.94,150.53 49.36,150.12 50.45,150.12 50.68,150.34 50.68,150.75 50.48,150.95 v2(50.04,150.95)
  IN1 w0.216: v1(20.65,146.98) 20.65,147.22 20.77,147.34 27.1,147.34 27.29,147.15 27.29,146.88 27.44,146.72 27.75,146.72 27.89,146.87 27.89,147.17 28.07,147.34 28.37,147.34 28.55,147.16 28.55,146.27 28.79,146.04 29.56,146.04 29.67,146.15 29.67,146.38 29.83,146.54 30.12,146.54 30.42,146.23 30.71,146.23 32.8,148.32 32.8,148.62 32.5,148.92 32.5,149.22 32.72,149.43 33.01,149.43 33.31,149.13 33.61,149.13 33.82,149.34 33.82,149.64 33.53,149.94 33.53,150.24 33.74,150.45 34.04,150.45 34.38,150.11 34.59,150.11 35.46,150.98 36.57,150.98 36.81,151.22 36.81,151.86 37.02,152.08 37.32,152.08 37.53,151.86 37.53,151.31 37.72,151.12 38.07,151.12 38.25,151.31 38.25,151.86 38.47,152.08 38.77,152.08 38.98,151.86 38.98,151.31 39.17,151.12 39.52,151.12 39.7,151.31 39.7,151.86 39.91,152.08 40.21,152.08 40.43,151.86 40.43,151.31 40.61,151.12 41.1,151.12 41.33,151.35 41.33,151.82 41.52,152.01 42.56,152.01 42.74,152.2 44.47,152.2 45.06,151.61 45.06,150.87
  IN3 w0.114: v2(19.12,158.2) 19.11,158.19 19.11,157.67 19.47,157.31 19.47,156.88 19.12,156.52 19.12,155.52 18.49,154.89 18.49,153.68 19.12,153.05 19.12,152.57 21.5,150.19 21.5,149.77 21.27,149.54 19.98,149.54 19.71,149.27 19.71,147.98 20.65,147.05 v1(20.65,146.98) 20.33,146.66 20.33,145.55 20.18,145.4 19.65,145.4 19.51,145.26 19.51,145.06 19.65,144.93 20.88,144.93 21.03,144.78 21.03,144.62 20.88,144.47 19.88,144.47 19.17,143.76 19.17,141.72 19.07,141.62 18.61,141.62 18.46,141.46 18.46,139.96 18.63,139.78 18.99,139.78 19.1,139.67 19.1,139.28 18.99,139.16 18.99,138.54 19.46,138.07 v2(19.46,137.82)
  BOTTOM w0.102: v2(19.12,158.2) 19.12,158.26 19.71,158.85 19.71,159.24 19.56,159.39 19.41,159.39 19.31,159.29 UV8.M7
  BOTTOM w0.114: v2(19.46,137.82) 19.46,137.9 19.27,138.08 19.27,138.1 19.07,138.3 19.07,138.4 19.18,138.5 19.18,138.59 19.08,138.69 19.08,138.83 19.14,138.9 19.14,138.93 19.31,139.1 UV5.M7
  BOTTOM w0.229: v2(50.04,150.95) 50.39,150.6 UV3.L17
FBA_ODTA0: length 65.1
  TOP w0.102: v1(20.88,137.53) 21.34,137.99 21.34,138.39 20.99,138.74 20.81,138.74 20.47,139.08 20.47,140.11 20.91,140.54 UV6.K1
  IN3 w0.084: 45.49,145.68 45.6,145.79 46.33,145.79 46.54,146 46.54,147.37 46.87,147.7 49.45,147.7 49.94,148.2 49.94,148.38 v2(49.78,148.54)
  IN3 w0.216: v1(20.88,137.53) 20.97,137.53 21.44,138 21.44,139.75 21.22,139.97 21.22,141.86 21.77,142.41 22.07,142.41 22.21,142.27 22.51,142.27 22.73,142.48 22.73,142.78 22.57,142.94 22.57,143.21 22.82,143.47 23.1,143.47 23.33,143.24 23.76,143.24 23.96,143.44 23.96,143.81 24.22,144.06 25.64,144.06 27.48,142.22 29.44,142.22 31.72,139.94 33.67,137.99 33.97,137.99 34.19,138.2 34.19,138.5 30.9,141.78 30.9,142.08 31.12,142.29 31.42,142.29 33.82,139.88 34.37,139.88 36.14,141.66 40.01,141.66 40.23,141.44 40.23,140.2 40.44,139.99 40.74,139.99 40.95,140.2 40.95,141.44 41.16,141.66 41.6,141.66 42.69,142.74 44.06,142.74 45.49,144.17 45.49,145.68
  BOTTOM w0.102: v2(49.78,148.54) 49.78,148.59 50.54,149.35 UV3.L18 ; v1(20.88,137.53) 20.47,137.12 20.47,134.8 UV5.K1
FBA_ODTA1: length 64
  TOP w0.102: v1(20.56,156.85) 20.42,156.99 20.42,157.68 20.5,157.75 20.5,160.29 UV7.K1
  IN3 w0.084: v2(49.07,152.2) 49.13,152.26 49.23,152.26 49.53,151.96 49.53,151.68 49.46,151.6 49.34,151.6 49.26,151.69 49.17,151.69 49.1,151.62 49.1,151.43 49.04,151.38 48.81,151.38 48.72,151.46 48.72,151.81 48.68,151.85 48.15,151.85 48.06,151.76 48.06,151.61 48.48,151.19 48.48,150.65 48.19,150.35 47.18,150.35 47.01,150.19 45.69,150.19 44.52,149.02
  IN3 w0.216: v1(20.56,156.85) 20.26,156.55 20.26,153.97 20.43,153.81 20.43,153.51 20.17,153.26 20.17,152.96 20.39,152.74 20.69,152.74 20.94,153 21.24,153 21.45,152.78 21.45,152.48 21.2,152.23 21.2,151.93 21.41,151.72 21.71,151.72 21.96,151.97 22.26,151.97 22.47,151.76 22.47,151.46 22.22,151.21 22.22,150.9 22.49,150.63 22.49,149.77 22.68,149.58 23.07,149.58 23.27,149.77 23.27,150.56 23.49,150.78 23.81,150.78 24.04,150.56 24.04,149.84 24.27,149.62 24.59,149.62 24.81,149.84 24.81,150.28 25.05,150.52 25.39,150.52 25.62,150.28 25.62,149.77 25.82,149.58 26.28,149.58 28.13,147.72 41.04,147.72 41.27,147.95 41.27,148.25 41.07,148.45 36.72,148.45 36.51,148.66 36.51,148.96 36.72,149.17 41.96,149.17 42.11,149.02 44.52,149.02
  BOTTOM w0.102: UV8.K1 20.72,154.3 20.47,154.55 20.47,156.76 v1(20.56,156.85) ; v2(49.07,152.2) 49.13,152.2 UV3.K16
FBA_RASA0#: length 62.9
  TOP w0.114: 21.71,139.16 21.71,138.76 21.86,138.61 21.99,138.61 22.18,138.8 22.33,138.8 22.48,138.64 22.48,138.26 v1(22.41,138.19)
  IN3 w0.084: v2(47.8,147.21) 48.12,146.89 48.12,146.14 47.89,145.91 47.56,145.91 47.33,145.68 47.33,144.44 47.08,144.18 47.08,144.18 46.75,144.18 46.52,143.95 46.52,143.21 46.33,143.03
  IN3 w0.216: 46.33,143.03 46.1,142.79 45.05,142.79 44.58,142.32 44.18,142.32 43.03,141.18 42.3,141.18 41.97,140.84 41.97,140.42 40.95,139.4 40.95,135.83 40.45,135.33 33.69,135.33 29.15,139.87 29.15,140.17 29.36,140.38 29.66,140.38 33.5,136.54 33.8,136.54 34.01,136.76 34.01,137.06 29.91,141.15 28.66,141.15 28.42,140.91 28.02,140.91 27.23,141.7 27.23,141.87 25.46,143.64 24.75,143.64 23.93,142.82 23.35,142.82 23.14,142.61 23.14,142.26 22.43,141.55 22.43,141.32 22.19,141.08 21.84,141.08 21.64,140.88 21.64,140.15 21.86,139.92 21.86,138.41 22.08,138.19 v1(22.41,138.19)
  BOTTOM w0.102: UV3.G22 47.38,146.8 v2(47.8,147.21)
  BOTTOM w0.114: 21.71,135.96 21.99,136.24 22.2,136.24 22.86,136.9 22.86,137.75 v1(22.41,138.19)
FBA_RASA1#: length 59.3
  TOP w0.114: 21.71,159.1 21.71,158.83 22.14,158.4 22.75,158.4 v1(22.89,158.26)
  IN3 w0.084: v2(46.99,151.04) 46.99,151.28 47.53,151.82 47.53,152.65 47.28,152.9 47.1,152.9 46.77,153.23 46.77,153.77 46.46,154.08 46.46,156.6 46.46,156.6 ; v1(22.89,158.26) 22.89,158.73 22.51,159.1 22.51,159.85 22.33,160.03 22.33,160.59
  IN3 w0.216: 46.46,156.6 46.41,156.65 46.41,157.72 46.44,157.75 46.44,158.57 45.25,159.76 45.25,160.29 45.46,160.5 46.57,160.5 46.72,160.65 46.72,161.07 46.57,161.23 45.79,161.23 45.58,161.44 45.58,162.46 44.51,163.54 44.51,163.99 44.83,164.31 44.83,164.53 44.36,165 44.14,165 43.68,164.53 43.38,164.53 43.17,164.75 43.17,165.05 43.5,165.38 43.5,165.68 43.29,165.89 42.99,165.89 42.65,165.56 42.35,165.56 42.14,165.77 42.14,166.07 42.48,166.41 42.48,166.71 41.29,167.89 31.85,167.89 30.52,166.55 29.64,166.55 29.43,166.34 29.43,165.81 29.27,165.66 28.85,165.66 28.7,165.81 28.7,166.34 28.49,166.55 27.64,166.55 27.26,166.17 27.26,165.54 25.28,163.56 24.48,163.56 24.33,163.41 24.33,163.24 24.12,163.02 23.82,163.02 23.6,163.24 23.6,163.51 23.45,163.66 23.1,163.66 22.94,163.51 22.94,162.29 22.79,162.14 22.38,162.14 22.13,161.88 22.13,161.09 22.33,160.89 22.33,160.59
  BOTTOM w0.114: v2(46.99,151.04) 46.99,150.96 47.02,150.93 47.02,150.72 UV3.G17
  BOTTOM w0.14: v1(22.89,158.26) 22.89,157.45 22.02,156.58 22.02,156.2 21.71,155.9
FBA_RST#: length 121.1
  TOP w0.102: UV6.T2 16.11,139.96 14.31,139.96 12.4,138.04 12.4,137.18 v1(13.16,136.42) ; UV7.T2 16.11,159.9 14.2,159.9 v1(13.04,158.73)
  TOP w0.114: v1(62.72,169.07) 62.81,169.07 63.65,169.91 64.4,169.91 RV9.1 ; RV15.1 14.19,130.54 14.08,130.65 v1(14.08,132.24) ; v1(19.86,167.29) 19.86,167.54 21.49,169.16 24.89,169.16 25.85,168.2 37.21,168.2 40.75,171.74 41.03,171.74 41.31,172.02 41.31,172.57 41.69,172.96 v1(41.69,172.98)
  IN1 w0.14: v1(13.04,158.73) 14.84,160.54 14.84,162.34 16.75,164.24 19.29,164.24 20.17,165.13 20.17,166.94 19.86,167.25 v1(19.86,167.29) ; v1(13.16,136.42) 13.57,136.01 13.57,132.75 v1(14.08,132.24)
  IN3 w0.114: v1(13.04,158.73) 12.48,159.29 11.51,159.29 9.72,157.5 9.72,136.74 10.36,136.1 12.84,136.1 v1(13.16,136.42) ; v1(62.72,169.07) 62.34,169.07 61.8,169.6 59.87,169.6 57.17,172.31 54.96,172.31 52.72,174.55 48.03,174.55 47.48,174 47.28,174 46.03,172.75 41.89,172.75 41.69,172.96 v1(41.69,172.98)
  BOTTOM w0.102: v1(13.04,158.73) 12.3,157.99 12.3,156.61 13.81,155.1 16.11,155.1 UV8.T2
  BOTTOM w0.114: UV5.T2 16.11,135.16 14.42,135.16 v1(13.16,136.42)
FBA_WEA0#: length 63.3
  TOP w0.102: v1(19.98,137.11) 19.98,137.1 20.15,137.26 20.15,138.16 20.4,138.41 20.4,138.82 20.11,139.11 UV6.L3
  IN3 w0.084: 44.69,148.16 44.76,148.16 45.55,148.95 46.16,148.95 46.49,149.28 50.12,149.28 50.65,148.75 50.65,146.37 49.31,145.02 48.15,145.02 47.75,144.62 v5(47.75,144.58)
  IN3 w0.114: v1(19.98,137.11) 19.92,137.17 19.92,138.06 19.38,138.6 19.38,138.99
  IN3 w0.216: 19.38,138.99 19.53,139.14 19.53,143.56 20.04,144.06 21.01,144.06 21.5,144.55 21.5,147.28 22.37,148.15 24.48,148.15 24.63,148 24.63,147.47 24.48,147.31 22.6,147.31 22.36,147.08 22.36,146.74 22.6,146.51 26.21,146.51 26.42,146.29 26.42,145.8 26.79,145.43 28.62,145.43 28.84,145.65 28.84,145.95 28.62,146.16 27.5,146.16 27.29,146.37 27.29,146.67 27.5,146.88 41.47,146.88 42.11,147.52 44.04,147.52 44.69,148.16
  BOTTOM w0.102: UV3.G25 47.37,144.2 v5(47.75,144.58) ; v1(19.98,137.11) 19.98,136.08 UV5.L3
FBA_WEA1#: length 57.3
  TOP w0.102: UV7.L3 20.11,158.97 19.77,158.63 19.77,158.47 v1(20.07,158.17)
  IN3 w0.216: v2(48.54,156.61) 50.03,158.11 50.03,159.21 50.55,159.72 50.55,160.13 50.35,160.33 50.35,163.15 48.1,165.4 46.1,165.4 42.72,168.78 41.8,168.78 41.59,168.99 41.59,169.55 41.44,169.7 41.02,169.7 40.87,169.55 40.87,168.99 40.66,168.78 40.36,168.78 40.14,168.99 40.14,169.32 39.99,169.47 39.57,169.47 39.42,169.32 39.42,168.99 39.21,168.78 30.85,168.78 30.21,169.42 27.41,169.42 25.13,167.14 23.98,167.14 22.31,165.46 20.51,165.46 17.95,162.89 17.95,161.72 18.7,160.97 18.7,159.54 v1(20.07,158.17)
  BOTTOM w0.102: v1(20.07,158.17) 20.22,158.02 20.22,157.44 20.21,157.43 20.21,157.43 20.11,157.33 20.11,155.9 UV8.L3 ; UV3.H10 48.14,156.21 v2(48.54,156.61)
FDO: length 12.5
  BOTTOM w0.114: UV3.R5 54.1,160.56 54.1,161.85 55.66,163.41 57.69,163.41 58.5,164.22 59.67,164.22 v3(60.03,164.57) 60.33,164.88 60.33,165.54 60.71,165.92 61.68,165.92 62.41,166.65 RV84.2
FN_LED#: length 210.8
  TOP w0.114: v1(190.88,103.27) 190.72,103.42 v4(190.26,103.42) 189.74,103.42 188.26,101.94 187.32,101.94 185.78,100.4 185.78,97.86 184.48,96.56 182.69,96.56 178.33,92.2 178.33,87.69 167.7,77.06 163.81,77.06 159.7,72.95 JKB.26
  IN3 w0.114: v1(109.71,152.67) 110.33,152.05 114.04,152.05 119.6,157.61 125.83,157.61 127.31,159.09 130.17,159.09 130.94,158.32 134.62,158.32 135.39,159.09 145.1,159.09 146.13,160.12 161.34,160.12 161.91,160.69 180.47,160.69 190.74,150.43 190.74,143.11 198.13,135.71 198.13,128.59 194.66,125.11 194.66,123.4 195.79,122.26 195.79,112.9 196.58,112.11 196.58,109.25 190.88,103.55 v1(190.88,103.27)
  BOTTOM w0.076: UC1.AC1 110.92,137.65 110.97,137.69 110.97,138.88 110.71,139.14 110.71,139.85 110.66,139.9
  BOTTOM w0.114: 110.66,139.9 110.66,141.63 111.37,142.34 111.37,146.96 110.97,147.36 110.97,150.54 110.74,150.77 RPC8.4 110.74,151.64 v1(109.71,152.67)
FSCE#: length 111.2
  TOP w0.114: v1(143.37,152.45) 143.37,151.89 143.8,151.46 143.8,139.72 144.51,139.02 144.51,137.99 v4(144.77,137.72) 145.89,136.61 145.89,118.52 143.36,116 134.68,116 134.32,116.36 133.77,116.36 RC311.1 ; UE1.101 190.26,129.67 v1(190.03,129.45)
  IN3 w0.114: v1(190.03,129.45) 189.68,129.45 188.49,130.63 188.49,133.4 187.1,134.79 187.1,136.98 184.94,139.14 183.29,139.14 175.1,147.33 175.1,148.44 174.54,149 173.88,149 173.63,148.75 167.1,148.75 165.85,150 161.59,150 158.51,153.07 150.73,153.07 150.54,153.27 143.82,153.27 143.37,152.82 v1(143.37,152.45)
GPD7: length 33.1
  TOP w0.114: RC351.2 v1(130.03,152.56) 129.16,151.69 v4(129.14,151.69)
  IN1 w0.076: v2(118,128.46) 118,128.46 118.4,128.87 118.6,128.87 119.01,129.28 119.01,129.4
  IN1 w0.14: 119.01,129.4 122.14,132.53 122.14,133.76 122.18,133.8 122.18,134.92 124.47,137.21 124.47,138.74 125.12,139.4 126.23,139.4 129.05,142.22 129.05,142.49 129.66,143.1 129.66,143.68 130.8,144.83 130.8,150.44 130.03,151.21 v1(130.03,152.56)
  BOTTOM w0.076: UC1.AT15 v2(118,128.46)
GPIO01: length 2.1
  TOP w0.114: TP120.1 127.88,162.48 UTPM1.30
GPIO03: length 1.9
  TOP w0.114: TP121.1 124.95,159.04 UTPM1.6
GPIO04: length 9.1
  TOP w0.114: UTPM1.13 128.88,157.13 127.5,155.75 126.87,155.75 126.42,155.3 122.9,155.3 121.91,156.29 TP124.1
GPIO5_AC_BATT: length 49.5
  TOP w0.114: v1(48.11,174) 48.19,174 48.62,174.43 48.62,175.5 RV113.2
  IN1 w0.14: v2(53.8,157.12) 54.21,157.54 54.21,158.4 55.48,159.67 57.74,159.67 59.56,161.49 62.73,161.49 63.09,161.13 63.09,159.69 v1(63.91,158.86)
  IN3 w0.114: v2(53.8,157.12) 53.82,157.12 54.29,157.59 54.29,158.99 53.65,159.62 53.65,163.18 51.52,165.31 51.52,171.41 50.67,172.26 50.39,172.26 48.65,174 v1(48.11,174)
  BOTTOM w0.114: v1(63.91,158.86) 64.01,158.96 68.05,158.96 68.33,159.24 69.55,159.24 69.96,158.83 v4(70.34,158.83) 70.64,158.83 72.62,160.81 DV2.2 72.62,162.65 RV111.2 ; UV3.T9 54.21,157.12 v2(53.8,157.12)
GPIO6: length 19.9
  TOP w0.114: v2(53.82,158.87) v3(53.82,159.65) 53.82,159.72 52.65,160.89 51.37,160.89 49.38,162.87 49.38,165.28 48.88,165.79 48.88,168.69 47.53,170.03 47.53,171.28 48.24,171.99 CV142.1 48.19,172.42 RV62.2
  BOTTOM w0.114: v2(53.82,158.87) 53.82,158.31 UV3.T8
GPIO8_ROMSO: length 1.4
  TOP w0.114: TPV3.1 52.12,156.97 v2(52.53,156.57)
  BOTTOM w0.114: v2(52.53,156.57) 52.89,156.2 UV3.P10
GPIO9_ROMSI: length 6.9
  BOTTOM w0.114: TPV4.1 50.81,166.1 50.81,164.65 52.58,162.88 52.58,160.96 UV3.P4
GPIO10_ROMSCK: length 4.4
  BOTTOM w0.102: TPV5.1 52.94,163.66 UV3.P2
GPIO15: length 50.8
  TOP w0.114: RV117.2 23.91,171.3 23.17,170.57 21.65,170.57 19.08,168 v1(19.08,167.36) 19.61,167.88 19.61,167.96 v4(20.23,168.57) 21.06,169.41 24.99,169.41 25.95,168.44 37.11,168.44 40.85,172.18 v1(40.85,172.22)
  IN1 w0.14: v1(40.85,172.22) 40.85,172.02 41.43,171.43 43.87,171.43 44.86,170.44 45.65,170.44 46.49,169.6 46.49,169.15 46.53,169.1 46.53,168.57 47.28,167.82 47.5,167.82 50.3,165.03 50.3,164.22 v2(52.14,162.38)
  BOTTOM w0.114: RV89.1 19.06,167.38 v1(19.08,167.36) ; v2(52.14,162.38) UV3.N1
GPIO19_CTF: length 65.8
  TOP w0.114: v2(51.03,162.81) 51.29,163.07 v1(54.39,163.07)
  IN1 w0.14: v1(54.39,163.07) 55.15,163.84 65.06,163.84 72.21,156.69 72.21,150.49 69.58,147.86 69.58,143.03 66.4,139.86 66.4,138.21 66.78,137.83 66.78,134.94 v1(66.05,134.21)
  BOTTOM w0.114: UV3.M2 51.34,162.5 v2(51.03,162.81) 51.03,163.46 49.16,165.34 49.16,166.17 RV74.2 ; v1(66.05,134.21) 65.65,134.21 v4(64.99,133.55) 64.79,133.34 64.79,133.04 63.29,131.54 63.29,130.15 62.59,129.45 60.89,129.45 60.46,129.01 RV86.1
GPIO20: length 53
  TOP w0.114: v1(40.93,172.98) 40.82,172.88 40.8,172.88 40.37,172.45 40.37,172.08 36.97,168.68 26.4,168.68 25.33,169.76 RV116.2 v4(24.06,170.39) 23.77,170.1 v1(22.54,170.1)
  IN3 w0.114: v1(40.93,172.98) 41.41,172.5 49.54,172.5 50.06,171.97 50.57,171.97 51.26,171.28 51.26,165.11 53.32,163.05 53.32,158.74 v2(52.55,157.96)
  BOTTOM w0.114: RV90.1 22.53,172.5 22.81,172.22 22.81,170.37 v1(22.54,170.1) ; UV3.P8 52.72,157.8 v2(52.55,157.96)
GPIO22_ROMCSB: length 2.1
  TOP w0.114: v2(52.68,157.33) 52.68,157.5 53.19,158.02 TPV6.1
  BOTTOM w0.114: v2(52.68,157.33) 52.55,157.33 52.08,157.8 UV3.N8
GPP_B18: length 28.2
  TOP w0.114: RC98.1 121.62,154.46 v1(121.88,154.21) 122.13,154.46 RC97.2
  IN1 w0.076: 119.62,134.4 119.3,134.08 119.3,133.7 119.05,133.45 117.78,133.45 v2(117.36,133.03)
  IN1 w0.14: 119.62,134.4 119.62,135.41 122.03,137.83 122.03,140.14 124.05,142.16 124.05,147.12 123.54,147.63 123.54,152.82 122.16,154.21 v1(121.88,154.21)
  BOTTOM w0.076: v2(117.36,133.03) 117,133.4 UC1.AR7
GPP_B22: length 27.2
  TOP w0.114: RC100.1 121.16,153.58 v1(121.84,152.9) 122.51,153.58 RC99.2
  IN1 w0.076: 119.12,134.59 118.83,134.3 116.4,134.3 v2(116.05,133.95)
  IN1 w0.14: v1(121.84,152.9) 122.58,152.9 123.28,152.2 123.28,146.21 123.08,146.02 123.08,141.61 121.76,140.29 121.76,137.88 119.12,135.24 119.12,134.59
  BOTTOM w0.076: UC1.AN5 115.7,134.3 v2(116.05,133.95)
GPP_B23: length 26.1
  TOP w0.114: v1(121.79,151.81) 121.79,152.11 122.36,152.69 RC101.2
  IN1 w0.14: v2(116.06,133) 115.66,133.4 115.66,134.11 116.07,134.51 116.6,134.51 117.23,135.14 117.23,135.67 117.75,136.19 119.33,136.19 120.42,137.29 120.42,138.06 121.23,138.87 121.23,140.87 122.55,142.19 122.55,149.88 122.34,150.09 122.34,151.26 v1(121.79,151.81)
  BOTTOM w0.076: v2(116.06,133) 115.47,133 115.05,133.43 UC1.AM7
