# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LX_1.35V: length 10.6
  IN3 w0.762: v1(166.75,172.47) 167,172.22 177.2,172.22
  vias: v1(166.11,172.51) v1(177.3,172.14) v1(177.97,172.14)
LX_CHG: length 9.1
  IN3 w0.762: 231.91,113.95 228.35,110.4 224.29,110.4
  vias: v1(222.71,110.4) v1(223.37,110.37) v1(231.96,114.23) v1(232.59,114.23) v4(229.3,105.81)
MAINPWON_EC: length 95.6
  TOP w0.114: v1(202.13,123.41) 202.05,123.49 197.83,123.49 197.22,122.88 196.21,122.88 195.69,122.37 UE1.79
  TOP w0.254: PR13.1 221.48,166.7 221.48,163.62 221.09,163.23 v1(221.09,161.7)
  IN1 w0.14: v1(202.13,123.41) 202.13,123.95 204.42,126.24 v1(211.19,126.24) v1(229.85,126.24)
  IN3 w0.254: v1(223.39,140) 223.56,140.18 223.56,159.23 v1(221.09,161.7)
  BOTTOM w0.114: v1(223.39,140) 220.72,140 220.48,140.24 213.47,140.24 211.77,138.55 211.77,129.91 211.19,129.33 v1(211.19,126.24)
  BOTTOM w0.254: v1(229.85,126.24) 229.85,126.15 230.26,125.74 PD2.2 ; PQ201.5 220.08,163.11 220.36,162.83 PR217.2 220.85,161.46 v1(221.09,161.7)
MCT1: length 12.9
  IN1 w0.508: v1(265.83,82.09) 265.83,83.23 265.07,83.99 262.25,83.99 261.74,84.5 v1(261.74,86.66)
  BOTTOM w0.508: TL1.22 266.47,83.2 266.94,82.73 RL10.2 265.88,82.04 v1(265.83,82.09) ; v1(261.74,86.66) DL3.2
MCT2: length 15.3
  IN1 w0.508: v1(270.38,82.04) 268.17,82.04 265.32,84.88 263.04,84.88 v1(262.83,85.09)
  BOTTOM w0.508: TL1.21 267.74,83.01 RL11.2 268.79,81.96 270.3,81.96 v1(270.38,82.04) ; DL4.2 262.36,84.61 v1(262.83,85.09)
MCT3: length 18.5
  IN1 w0.508: v1(273.17,82.6) 274.44,83.87 278.12,83.87 281.3,87.04 284.24,87.04 v1(284.29,87.09)
  BOTTOM w0.508: TL1.16 274.09,83.08 274.19,82.98 RL12.2 273.84,81.67 273.17,82.34 v1(273.17,82.6) ; DL5.2 284.6,87.8 284.29,87.5 v1(284.29,87.09)
MCT4: length 11.1
  IN1 w0.508: v1(281.3,85.01) 277.79,81.5 v1(277.79,81.25)
  BOTTOM w0.508: 281.3,86.18 v1(281.3,85.01) ; TL1.15 275.36,82.53 RL13.2 277.02,81.67 277.44,81.25 v1(277.79,81.25)
MDI_0+: length 25.4
  TOP w0.114: UL1.13 257.5,90.64 257.74,90.41 257.74,89.8 258.1,89.44 258.63,89.44 259.07,89.88 259.07,90.06 260.08,91.07 v1(264.12,91.07) 266.71,91.07 267.11,91.46 267.11,94.16 266.71,94.56 262.04,94.56 261.79,94.81 261.79,95.03 261.98,95.22 262.12,95.22 262.17,95.17 DL1.9 DL1.1 263.89,95.17 263.97,95.26 264.14,95.26 v1(264.29,95.1)
  BOTTOM w0.114: TL1.1 263.93,94.15 264.38,94.61 264.64,94.61 264.74,94.71 264.74,95.19 264.67,95.26 264.44,95.26 v1(264.29,95.1)
MDI_0-: length 25.5
  TOP w0.114: v1(265.24,95.26) 265.2,95.26 264.79,95.68 263.76,95.68 263.75,95.67 DL1.2 DL1.8 262.15,95.67 262.12,95.64 261.8,95.64 261.37,95.21 261.37,94.64 261.87,94.14 266.54,94.14 266.69,93.99 266.69,91.64 266.54,91.49 259.9,91.49 258.65,90.24 258.65,90.05 258.46,89.86 258.27,89.86 258.16,89.97 258.16,90.58 257.7,91.04 UL1.14
  BOTTOM w0.114: TL1.2 265.16,93.71 265.16,95.14 265.24,95.22 v1(265.24,95.26)
MDI_1+: length 26.3
  TOP w0.114: UL1.17 257.29,92.18 258.65,92.18 258.73,92.11 263.21,92.11 263.61,92.51 263.61,93.08 263.21,93.48 261,93.48 260.52,93.96 260.52,96.07 261.16,96.71 262.16,96.71 262.19,96.67 DL1.7 DL1.4 263.86,96.67 263.9,96.71 264.76,96.71 265.64,95.83 266.32,95.83 266.76,96.26 266.76,96.47 267,96.71 v1(267.92,96.71) 268.38,96.71 268.89,96.2 269.38,96.2 269.49,96.08 269.49,95.41 269.37,95.3 v1(269.23,95.3)
  BOTTOM w0.114: TL1.5 269.01,94.2 269.63,94.83 269.63,95.09 269.42,95.3 v1(269.23,95.3)
MDI_1-: length 26.4
  TOP w0.114: v1(270.07,95.25) 269.91,95.4 269.91,96.26 269.55,96.62 269.07,96.62 268.55,97.13 266.83,97.13 266.34,96.64 266.34,96.44 266.15,96.25 265.82,96.25 264.93,97.13 263.9,97.13 263.86,97.17 DL1.5 DL1.6 262.21,97.17 262.16,97.13 260.98,97.13 260.1,96.24 260.1,93.78 260.83,93.06 263.04,93.06 263.19,92.91 263.19,92.68 263.04,92.53 258.9,92.53 258.83,92.6 257.28,92.6 UL1.18
  BOTTOM w0.114: v1(270.07,95.25) 270.07,94.62 270.28,94.41 TL1.6
MDI_2+: length 25.9
  TOP w0.114: UL1.20 258.56,93.44 259.35,94.24 259.35,96.38 260.78,97.81 v1(264.78,97.81) 268.85,97.81 269.42,97.24 270.01,97.24 270.04,97.2 DL2.9 DL2.1 271.67,97.2 271.73,97.26 273.66,97.26 274.01,96.91 274.01,96.58 273.73,96.3 272.52,96.3 272.02,95.79 272.02,95.34 271.88,95.21 v1(271.58,95.21)
  BOTTOM w0.114: TL1.7 271.55,94.38 272.04,94.88 272.04,95.02 271.86,95.21 v1(271.58,95.21)
MDI_2-: length 25.9
  TOP w0.114: UL1.21 258.36,93.84 258.93,94.41 258.93,96.55 260.61,98.23 269.03,98.23 269.6,97.66 270.01,97.66 270.06,97.7 DL2.8 DL2.2 271.76,97.7 271.78,97.68 273.84,97.68 274.43,97.08 274.43,96.4 273.91,95.88 272.7,95.88 272.43,95.62 272.43,95.32 v1(272.58,95.17)
  BOTTOM w0.114: v1(272.58,95.17) 272.58,94.82 272.82,94.58 TL1.8
MDI_3+: length 26.5
  TOP w0.114: UL1.23 257.81,94.64 258.21,95.05 258.21,96.76 260.3,98.85 269.36,98.85 269.48,98.74 270.01,98.74 270.04,98.7 DL2.7 DL2.4 271.72,98.7 271.75,98.74 273.65,98.74 276.79,95.6 276.79,95.38 276.67,95.26 v1(276.41,95.26)
  BOTTOM w0.114: TL1.11 276.63,94.36 276.97,94.7 276.97,95.1 276.81,95.26 v1(276.41,95.26)
MDI_3-: length 26.6
  TOP w0.114: v1(277.38,95.27) 277.38,95.29 277.21,95.46 277.21,95.78 273.83,99.16 271.73,99.16 271.68,99.2 DL2.5 DL2.6 270.07,99.2 270.03,99.16 269.65,99.16 269.53,99.27 v1(261.6,99.27) 260.13,99.27 257.79,96.93 257.79,95.22 257.61,95.04 UL1.24
  BOTTOM w0.114: TL1.12 277.9,94.3 277.39,94.81 277.39,95.27 v1(277.38,95.27)
ME_FLASH: length 103.9
  TOP w0.114: UE1.104 v1(189.06,129.45) ; v1(144,152.45) 144.04,152.4 144.04,140.08 v4(144.52,139.6) 146.13,137.99 146.13,118.4 142.25,114.51 RC21.1
  IN3 w0.114: v1(189.06,129.45) 189.06,129.72 186.05,132.73 186.05,135.01 181.92,139.14 181.92,140.15 174.86,147.21 174.86,148.34 174.44,148.76 173.98,148.76 173.73,148.51 167,148.51 165.75,149.75 161.49,149.75 158.41,152.83 150.63,152.83 150.44,153.03 144.59,153.03 v1(144,152.45)
MIC_CLK_R: length 2.7
  TOP w0.114: v4(188.44,53.02) 188.49,53.02 188.54,53.07 RA7.2 189.34,53.61 188.83,54.13 UA1.40
MIC_HW_EN: length 24.6
  TOP w0.114: RC366.2 113.07,150.11 v1(112.9,150.29)
  BOTTOM w0.076: 116.88,138.22 116.83,138.17 116.83,137.84 116.63,137.64 116.63,136.01 116.38,135.76 116.07,135.76 115.83,135.52 115.83,134.94 115.42,134.53 115.42,134.3 115.13,134.01 114.83,134.01 114.6,133.78 114.6,132.38 114.27,132.05 113.94,132.05 113.66,131.77 113.66,131.57 UC1.AH11
  BOTTOM w0.114: v1(112.9,150.29) 112.9,148.44 112.77,148.32 v4(112.77,148.29) 113.45,147.61 113.45,142.36 116.03,139.79 116.41,139.79 116.88,139.31 116.88,138.22
MPLL_PVDD: length 23.2
  IN3 w0.381: v2(51.41,157.75) 51.92,158.27 51.92,160.03 52.76,160.87 52.76,163.05 49.71,166.1 49.71,167.44 50.4,168.13 50.4,169.65 48.9,171.15 48.17,171.15 v1(47.99,170.97)
  BOTTOM w0.381: v2(51.41,157.75) 51.34,157.75 51.33,157.76 50.77,157.76 UV3.L8
  BOTTOM w0.508: v1(47.99,170.97) 47.94,170.97 47.45,170.49 CV19.1 46.95,170.67 46.39,171.23 CV17.1 46.35,171.89 CV18.1 45.08,171.9 LV3.2
NTC_V_1: length 226.2
  TOP w0.254: PRT7.1 107.98,115.91 v1(108.19,116.11) ; v1(175.24,100.98) 177.92,103.67 184.3,103.67 190.85,110.21 193.22,110.21 v4(196.18,113.18) 196.31,113.3 198.56,113.3 200.31,115.06 v1(200.75,115.06) ; v1(228.85,168.56) PR12.1 227.69,168.28 PU1.8 226.23,168.28 225.99,168.52 PR10.2 PR11.2 224.8,169.7 PR9.1
  IN3 w0.254: v1(228.85,168.56) 224.12,163.84 224.12,133.85 222.32,132.05 211.96,132.05 202.65,122.74 202.65,117.18 201.26,115.79 201.26,115.57 v1(200.75,115.06) ; v1(175.24,100.98) 175.24,97.57 174.1,96.43 174.1,92.49 168.51,86.9 165.97,86.9 159.54,80.47 146.49,80.47 145.97,79.95 113.23,79.95 112.06,81.13 112.06,81.48 108.84,84.69 108.84,93.56 111.49,96.2 111.49,97.66 110.98,98.17 110.98,101.28 112.88,103.19 112.88,108.71 112.29,109.31 112.29,110.51 108.69,114.1 108.69,115.22 108.19,115.73 v1(108.19,116.11)
OCP_L: length 2.9
  TOP w0.114: RV114.2 RV61.2 46.26,174.57 v3(46.62,174.21) 46.84,173.98 RV62.1
ON/OFF#: length 182.9
  TOP w0.114: v1(193.52,137.71) 193.52,137.74 192.78,138.48 v4(192.65,138.48) 192.4,138.73 187.59,138.73 187.2,138.34 187.2,136.73 187.69,136.24 187.69,132.71 186.66,131.68 UE1.110 ; v1(267.7,158.33) 269.27,158.33 269.73,158.78 269.73,159.42 269.16,159.98 269.12,159.98 SW1.3 ; v1(282.81,113.02) 282.81,113.01 282.22,113.01 282.13,112.93 D16.4 D16.7 279.9,112.93 v1(279.79,113.04) ; J1.2 268.99,148.64 269.85,148.64 R71.2 270.49,150.27 D5.2 269.88,151.82 v1(269.91,151.85)
  IN1 w0.14: v1(279.79,113.04) 282.11,115.35 282.11,123.93 271.98,134.05 271.98,150.87 270.97,151.88 269.94,151.88 v1(269.91,151.85) 269.4,152.36 267.17,152.36 265.09,154.44 260.43,154.44 258.36,152.37 258.36,150.84 256.47,148.95 253.81,148.95 v1(252.84,147.99) ; v1(282.81,113.02) 283.19,113.39 283.19,114.81 283.22,114.84 283.22,121.42 283.65,121.85 JLINK.2
  BOTTOM w0.114: v1(252.84,147.99) 252.64,147.79 251.45,147.79 250.27,148.97 236.4,148.97 229.64,142.21 205.91,142.21 204.21,140.51 200.4,140.51 198.54,138.65 194.37,138.65 193.64,137.92 193.64,137.84 v1(193.52,137.71) ; v1(267.7,158.33) 267.7,158.12 269.93,155.89 269.93,152.94 269.91,152.91 v1(269.91,151.85)
ONEDOCK_DET#: length 255.8
  TOP w0.114: v1(277.36,121.08) 277.86,120.58 279.29,120.58 280.23,121.52 281.54,121.52 281.74,121.32 R98.2 283.66,120.81 JLINK.4 ; v1(249.7,134.91) 237.11,134.91 229.48,142.54 229.48,146.48 228.06,147.9 v1(228.06,148.56)
  IN1 w0.14: v1(228.06,148.56) 227.96,148.46 199.71,148.46 195.73,152.45 v1(194.43,152.45)
  IN3 w0.114: v1(99.18,140.75) 94.37,140.75 91.94,143.18 91.94,145.59 v1(95.88,149.53) 101.72,155.37 107.74,155.37 108.44,156.07 113.98,156.07 118.38,160.47 124.66,160.47 127.05,162.86 132.07,162.86 132.39,162.54 147.03,162.54 148.18,163.69 149.98,163.69 151.13,162.54 160.33,162.54 160.9,163.11 181.48,163.11 192.15,152.45 v1(194.43,152.45)
  BOTTOM w0.114: v1(99.18,140.75) 99.43,140.49 102.09,140.49 102.34,140.24 102.34,139.3 102.6,139.05 102.6,135.54 102.3,135.24 UC1.G4 ; RC368.1 96.26,152.27 95.5,151.51 95.5,149.91 v1(95.88,149.53) ; v1(277.36,121.08) 277.51,120.92 R88.2 277.49,120.29 R93.2 277.26,119.32 274.39,116.45 274.39,115.16 272.94,113.71 267.89,113.71 261.84,119.76 261.84,122.5 259.73,124.61 258.31,124.61 253.87,129.05 253.87,130.74 v1(249.7,134.91)
OPC_RCOMP: length 1.2
  TOP w0.254: v2(103.21,99.91) 103.14,99.98 RC56.2
  BOTTOM w0.203: UC1.H65 v2(103.21,99.91)
OPCE_RCOMP: length 2.3
  TOP w0.254: RC200.2 102.83,98.25 103.21,98.63 v2(103.21,98.9) 103.69,99.38 v4(103.75,99.38)
  BOTTOM w0.203: UC1.H66 v2(103.21,98.9)
OTP_N_002: length 2.7
  TOP w0.254: v4(229.39,167.65) PR12.2 226.69,167.65 PU1.7
OTP_N_003: length 2.8
  TOP w0.254: v4(222.34,165.36) 222.42,165.43 PR13.2 222.75,166.72 223.01,166.98 PU1.3
OTP_RESET: length 67.2
  TOP w0.114: v1(181.73,133.02) 182.66,132.09 UE1.120
  IN1 w0.14: v1(235.59,130.66) 232.23,127.3 227.96,127.3 227.7,127.55 227.7,128.96 224.48,132.18 215.34,132.18 211.83,135.69 203.12,135.69 200.01,132.58 188.63,132.58 188.23,132.18 182.57,132.18 v1(181.73,133.02)
  BOTTOM w0.254: v4(238.24,130.86) 237.53,130.15 PQ3.2 235.95,130.15 235.59,130.5 v1(235.59,130.66)
P2: length 66.1
  TOP w0.381: v1(272.42,106.89) 272.42,107 272.03,107.4 PR104.2 v4(271.46,105.84)
  IN3 w0.254: v1(272.42,106.89) 270.95,106.89 265.92,101.86 260.41,101.86 256.93,98.38 247.66,98.38 245.85,100.19 244.55,100.19 242.01,102.72 222.03,102.72 v1(219.84,104.91)
  BOTTOM w0.254: v1(219.84,104.91) 220.15,105.21 PR112.1
  BOTTOM w0.381: 270.85,107.91 270.49,108.26 269.08,108.26 267.94,109.4 PQ103.3
P3:
  vias: v4(269.04,102.71)
PBTN_OUT#: length 143.7
  TOP w0.114: v1(183.24,122.9) 183.68,122.46 189.75,122.46 192.46,125.17 UE1.86 194.84,125.17 TP129.1 195.42,125.65 195.45,125.62 198.24,125.62 198.65,125.22 200.04,125.22 RC379.2
  BOTTOM w0.076: 122.79,128.58 122.69,128.58 122.36,128.25 121.03,128.25 UC1.BA15
  BOTTOM w0.114: v1(183.24,122.9) 183.24,124.18 182.57,124.85 182.57,126.74 183.57,127.74 183.57,132.72 184.94,134.09 184.94,136.84 183.76,138.02 183.76,148.97 182.86,149.87 182.86,157.74 180.5,160.1 165.16,160.1 164.21,159.15 147.9,159.15 146.76,158 138.73,158 137.28,156.55 137.28,153.11 134.74,150.58 134.74,148.36 134.26,147.87 134.26,146.58 135.12,145.71 135.12,136.4 130.52,131.8 128.83,131.8 127.43,130.39 125.07,130.39 123.26,128.58 122.79,128.58
PC_BEEP: length 4.7
  TOP w0.114: UA1.10 189.82,58.86 190.92,59.96 190.92,60.72 191.26,61.06 CA24.2 191.43,61.06 191.61,60.88 191.61,60.37 191.97,60.02 v4(192.07,60.02)
PCH_BEEP: length 239
  TOP w0.114: v1(122.83,150.8) 122.83,150.36 123.22,149.97 RC300.1 RC95.1 ; v1(189.6,101.58) 189.73,101.45 189.73,97.25 184.64,92.16 183.27,92.16 181.67,90.56 181.67,87.55 178.22,84.1 178.22,83.54 176.25,81.57 175.74,81.57 170.01,75.84 v4(170.01,64.73) 170.01,62.58 DA1.3 171.08,61.51 173.44,61.51 174.06,62.13 174.06,64.98 174.31,65.24 184.87,65.24 187.6,67.96 192.34,67.96 193.02,67.28 193.02,64.33 CA23.1
  IN1 w0.14: v1(122.83,150.8) 122.82,150.78 122.82,142.08 121.5,140.76 121.5,138.82 120.65,137.97 120.65,137.08 118.57,135 v2(118.57,134.8)
  IN3 w0.114: v1(189.6,101.58) 189.56,101.62 189.56,103.26 193.53,107.23 193.53,119.31 191.43,121.41 191.43,123.49 194.26,126.32 194.26,133.47 192.92,134.81 192.92,135.73 192.16,136.49 192.16,138.3 187.57,142.89 187.57,149.84 v1(186.33,151.09)
  BOTTOM w0.076: UC1.AW5 118.84,134.53 v2(118.57,134.8)
  BOTTOM w0.114: v1(122.83,150.8) 124.12,149.5 124.79,149.5 126.61,151.32 126.61,152.39 126.89,152.67 127.7,152.67 128.26,152.12 130.31,152.12 134.04,155.85 134.04,156.77 138.32,161.05 146.39,161.05 146.9,161.56 162.95,161.56 163.9,162.51 167.43,162.51 168.47,163.55 180.46,163.55 185.27,158.74 185.27,152.15 v1(186.33,151.09)
PCH_CMOS_ON: length 93
  IN1 w0.14: v1(100.2,149.69) 99.98,149.69 98.62,151.05 86.61,151.05 84.7,149.15 84.7,147.24 80.65,143.19 70.65,143.19 67.94,140.48 67.94,135.44 70.14,133.25 70.14,130.14 69.59,129.59 v1(69.59,124.76)
  IN3 w0.114: v1(109.91,148.8) 110.57,148.8 111.68,147.68 v1(112.45,147.68)
  BOTTOM w0.076: 116.63,137.9 116.47,137.73 116.47,136.53 116.38,136.44 116.07,136.44 115.69,136.06 115.44,136.06 115.23,135.86 115.23,134.59 UC1.AM5
  BOTTOM w0.114: 116.63,137.9 116.63,139.18 116.32,139.5 115.67,139.5 113.2,141.97 113.2,147.14 112.65,147.68 v1(112.45,147.68) ; U4.4 64.09,122.97 64.09,124.54 64.55,125 69.35,125 v1(69.59,124.76) ; v1(100.2,149.69) 101.1,149.69 101.6,149.19 109.53,149.19 v1(109.91,148.8)
PCH_EDP_PWM: length 71.7
  TOP w0.114: v1(76.69,129.47) 76.69,125.95 73.06,122.32 67.72,122.32 65.84,120.44 62.29,120.44 61.48,121.25 60.38,121.25 59.67,120.54 59.67,120.39 56.94,117.66 56.61,117.66 55.82,116.87 55.82,116.14 JLCD.12
  IN3 w0.114: v2(107.23,131.42) 107.23,131.42 106.66,131.99 106.66,134.78 106.41,135.03 101.58,135.03 101.33,134.78 100.82,134.78 100.31,135.29 99.93,135.29 98.77,136.45 87.59,136.45 86.81,137.23 79.89,137.23 76.69,134.03 v1(76.69,129.47)
  BOTTOM w0.076: v2(107.23,131.42) 106.97,131.23 UC1.R11
PCH_ENVDD: length 57.1
  IN1 w0.254: v1(92.11,118.02) 95.1,121.01 95.1,122.08 96.74,123.72 100.07,123.72 100.69,124.34 101.51,124.34 101.8,124.63 101.8,124.96 102.09,125.25 103.97,125.25 104.37,124.86 106.39,124.86 106.79,125.25 107.04,125.25 107.58,125.79 107.58,128.33 107.63,128.39 107.63,129.49 108.26,130.12 v5(108.48,130.12)
  IN3 w0.254: v1(67.65,119.95) 67.82,119.95 68.31,120.43 73.83,120.43 74.39,119.86 76.45,119.86 76.95,119.36 82.79,119.36 85.91,116.24 87.23,116.24 88.75,117.76 91.85,117.76 v1(92.11,118.02)
  BOTTOM w0.254: v1(67.65,119.95) 66.66,118.96 R18.1 66.2,117.56 66.2,117.13 U3.4 ; UC1.U13 107.93,129.78 108.26,130.12 v5(108.48,130.12)
PCH_HDA_BCLK: length 137.5
  TOP w0.114: v1(133.85,109.91) 133.35,110.42 132.54,110.42 131.94,111.02 RPC2.2 ; v1(180.1,82.81) 180.1,82.32 177.97,80.19 176.32,80.19 171.44,75.31 171.44,70.39 174.92,66.91 184.24,66.91 186.92,69.59 195.24,69.59 195.65,69.18 v3(195.65,56.76) 195.1,56.21 194.82,56.21 194.82,56.2 193.01,56.2 CC538.1 191.92,56.13 191.06,56.13 190.33,56.86 UA1.5
  IN1 w0.14: v1(180.1,82.81) 180.1,82.8 179.59,82.28 166.71,82.28 165.13,83.86 v1(165.13,84.21)
  BOTTOM w0.114: v1(133.85,109.91) 134.74,109.02 134.74,93.68 136.69,91.73 145.05,91.73 146.41,90.36 146.41,87.05 147.56,85.9 162.11,85.9 163.79,84.21 v1(165.13,84.21)
PCH_HDA_RST#: length 130.1
  TOP w0.114: v1(178.46,82.77) 178.46,82.33 177.22,81.09 175.94,81.09 170.54,75.69 170.54,69.61 174.18,65.96 184.57,65.96 187.3,68.69 194.41,68.69 194.65,68.45 194.65,61.63 194.14,61.12 193.76,61.12 192.12,59.48 190.95,59.48 189.93,58.46 UA1.9 ; RPC2.1 131.44,112.52 131.08,112.16 v4(131.08,112.06) 131.08,111.28 132.45,109.91 v1(133.2,109.91)
  IN1 w0.14: v1(178.46,82.77) 166.99,82.77 v1(165.75,84.01)
  BOTTOM w0.114: v1(133.2,109.91) 134.32,108.8 134.32,93.5 136.52,91.31 144.87,91.31 145.99,90.19 145.99,86.87 147.39,85.48 161.93,85.48 163.64,83.77 165.51,83.77 v1(165.75,84.01)
PCH_HDA_SDIN0: length 157.1
  TOP w0.114: RA5.1 194.65,56.62 195.21,57.18 195.21,68.87 194.9,69.17 187.1,69.17 184.38,66.46 174.63,66.46 v4(171.95,69.13) 171.03,70.06 171.03,75.49 176.14,80.61 177.53,80.61 179.67,82.74 v1(179.67,83.96) ; RC301.1 RC297.1 134.09,115.22 v1(133.87,115.45)
  IN1 w0.14: v1(179.67,83.96) 177.99,85.63 v1(166.86,85.63)
  BOTTOM w0.076: 123.43,126.39 123.2,126.39 122.83,126.02 121.98,126.02 121.47,125.5 120.47,125.5 UC1.BA21
  BOTTOM w0.114: v1(166.86,85.63) 165.69,86.8 147.94,86.8 147.31,87.42 147.31,90.74 145.42,92.63 137.07,92.63 135.64,94.05 135.64,113.67 v1(133.87,115.45) 132.7,116.62 132.7,124.18 130.04,126.83 124.82,126.83 124.39,126.39 123.43,126.39
PCH_HDA_SDIN0_R: length 2.1
  TOP w0.114: RA5.2 190.69,57.26 UA1.6
PCH_HDA_SDOUT: length 138.3
  TOP w0.114: v1(180.58,83.35) 180.58,82.2 178.14,79.77 176.49,79.77 171.86,75.14 171.86,70.56 175,67.42 184.16,67.42 186.75,70.01 195.41,70.01 196.07,69.35 196.07,56.42 194.78,55.14 191.67,55.14 190.35,56.46 UA1.4 ; v1(134.53,109.91) 133.6,110.83 v4(132.71,110.83) 132.44,111.11 RPC2.3
  IN1 w0.14: v1(165.64,84.69) 166.12,85.17 177.61,85.17 179.43,83.35 v1(180.58,83.35)
  BOTTOM w0.114: v1(134.53,109.91) 135.16,109.28 135.16,93.85 136.87,92.15 145.22,92.15 146.83,90.54 146.83,87.22 147.74,86.32 163.13,86.32 164.75,84.69 v1(165.64,84.69)
PCH_HDA_SYNC: length 129.5
  TOP w0.114: v1(178.92,83.22) 179.05,83.09 179.05,82.58 177.32,80.85 176.04,80.85 170.78,75.59 170.78,69.71 174.28,66.21 184.47,66.21 187.2,68.93 194.69,68.93 194.93,68.69 194.93,61.3 194.49,60.87 193.86,60.87 192.21,59.21 191.05,59.21 190.42,58.59 190.42,58.37 190.11,58.06 UA1.8 ; RPC2.4 132.94,113.1 v4(133.98,112.06) 135.21,110.83 v1(135.21,109.91)
  IN1 w0.14: v1(178.92,83.22) 177.45,84.69 v1(166.3,84.69)
  BOTTOM w0.114: v1(166.3,84.69) 165.61,85.38 164.57,85.38 163.39,86.56 147.84,86.56 147.07,87.32 147.07,90.64 145.32,92.39 136.97,92.39 135.4,93.95 135.4,109.72 v1(135.21,109.91)
PCH_INTRUDER#: length 28.3
  TOP w0.114: v1(130.16,143.54) 130.16,144.11 130.72,144.67 RC16.2
  IN3 w0.076: v2(116.73,127.55) 117.13,127.95 118.98,127.95
  IN3 w0.114: 118.98,127.95 119.26,127.95 120.17,128.86 120.17,130 120.61,130.44 120.61,131.7 123.36,134.45 123.36,135.17 124.3,136.12 124.3,138.71 125.6,140.01 127.32,140.01 128.61,141.3 130.19,141.3 130.78,141.88 130.78,143.25 130.49,143.54 v1(130.16,143.54)
  BOTTOM w0.076: UC1.AP16 v2(116.73,127.55)
PCH_JTAG_TCK: length 13.2
  BOTTOM w0.076: UC1.B56 99.23,104.95 99.01,104.95 98.9,104.89 98.63,104.89 98.49,105.04 97.93,105.04 97.74,104.84 97.07,104.84 96.84,104.61
  BOTTOM w0.114: T9.1 89.04,108.28 89.04,108.15 89.43,107.77 RC372.1 89.86,107.74 90.16,108.03 91.43,108.03 94.86,104.61 96.84,104.61
PCH_JTAG_TDI: length 23.5
  TOP w0.114: T10.1 85.69,111.4 86.05,111.04 86.05,110.18 85.64,109.77 RC373.1 87.98,107.41 95.17,107.41 95.34,107.59 98.54,107.59 98.82,107.31 98.82,105.91 97.8,104.89 v2(97.8,104.19)
  BOTTOM w0.076: UC1.D59 100.41,104.02 100.15,104.1 100.03,104.1 99.55,104.24 99.3,104.24 99.21,104.2 99.02,104.2 98.93,104.24 98.57,104.24 98.43,104.1 97.89,104.1 v2(97.8,104.19)
PCH_JTAG_TDO: length 10.6
  BOTTOM w0.076: UC1.A56 98.75,105.2 97.87,105.2 97.67,105 96.98,105 96.83,104.85
  BOTTOM w0.114: 96.83,104.85 94.96,104.85 91.53,108.28 90.42,108.28 T11.1
PCH_JTAG_TMS: length 21.3
  TOP w0.114: T12.1 RC374.1 86.17,108.45 87.47,107.16 95.29,107.16 95.47,107.34 98.44,107.34 98.6,107.18 98.6,106.01 97.21,104.63 v2(97.21,104.2)
  BOTTOM w0.076: UC1.C59 99.78,103.99 99.53,104.07 99.35,104.07 99.16,104.01 99.01,104.01 98.9,104.07 98.63,104.07 98.4,103.84 97.57,103.84 v2(97.21,104.2)
PCH_JTAG_TRST#: length 9
  TOP w0.114: v2(97.56,102.18) 97.56,102.85 99.9,105.19 101.58,105.19 T8.1
  BOTTOM w0.076: UC1.C61 99.7,102.3 99.64,102.3 99.63,102.28 99.02,102.28 98.99,102.27 98.57,102.27 98.3,102.55 97.93,102.55 v2(97.56,102.18)
PCH_JTAGX: length 9.9
  BOTTOM w0.076: UC1.A59 98.66,103.68 97.5,103.68 97.34,103.84 96.93,103.84 96.65,104.13
  BOTTOM w0.114: 96.65,104.13 94.66,104.13 92.34,106.44 91.41,106.44 90.87,106.98 T13.1
PCH_OPIRCOMP: length 1.5
  TOP w0.254: RC55.2 118.61,127.7 v2(118.61,127.55)
  BOTTOM w0.254: v2(118.61,127.55) 118.29,127.98 UC1.AU16
PCH_PCI_CLK_R: length 11.2
  TOP w0.114: RC24.1 126.51,134.56 v1(125.4,135.67)
  BOTTOM w0.076: UC1.AW9 119.73,132.43 120.92,132.43
  BOTTOM w0.114: 120.92,132.43 121.57,133.08 122.07,133.08 123.85,134.86 125,134.86 125.4,135.26 v1(125.4,135.67)
PCH_PWROK: length 97.5
  TOP w0.114: RC41.1 142.09,128.81 142.48,129.19 143.93,129.19 v1(144.21,128.91) ; v1(190.15,127.9) 191.06,128.8 UE1.99
  IN3 w0.114: v1(174.23,148.24) 174.62,147.85 174.62,147.11 181.68,140.05 181.68,139.04 185.18,135.54 185.18,133.26 188.25,130.19 188.25,128.65 189.01,127.9 v1(190.15,127.9)
  BOTTOM w0.114: v1(144.21,128.91) 144.21,129.53 146.47,131.8 146.47,150.41 147.21,151.15 147.21,152.27 148.96,154.02 148.96,155.73 149.22,155.98 152.9,155.98 153.54,156.62 174.48,156.62 175.43,155.67 175.43,149.45 v1(174.23,148.24)
PCH_RTCRST#: length 32.8
  TOP w0.114: RC12.2 135.15,135.99 CC1.1 135.45,136.43 135.49,136.47 135.49,138.27 135.38,138.38 v4(130.24,138.38) 129.77,138.38 129.28,137.88 125.44,137.88 v1(124.94,137.38)
  IN3 w0.076: v2(115.46,127.55) 115.84,127.17 118.75,127.17 120.37,128.79 120.37,129.12
  IN3 w0.114: 120.37,129.12 120.37,129.92 120.81,130.36 120.81,131.53 123.76,134.47 123.76,134.87 124.8,135.91 124.8,137.25 v1(124.94,137.38)
  BOTTOM w0.076: UC1.AM16 v2(115.46,127.55)
  BOTTOM w0.114: JCMOS1.1 125.65,138.1 v1(124.94,137.38)
PCH_RTCX1: length 37.1
  TOP w0.076: 119.42,124.66 119.22,124.66 118.83,124.27 115.86,124.27 115.09,125.03 115.09,126.26 v2(115.46,126.63)
  TOP w0.254: 119.42,124.66 120.06,124.66 120.31,124.83 120.82,125.8 120.82,128.14 121.77,130.16 122.64,131.03 122.73,131.22 122.73,132.9 122,134.12 120.92,135.2 118.94,136.29 118.31,136.66 117.98,137.13 117.98,137.71 117.65,138.32 117.65,138.7 117.96,139.38 118.2,139.62 121.14,140.55 122.78,142.18 v4(122.78,142.54) 122.87,143.15 123.04,143.57 123.32,143.85 RC13.1 124.26,143.85 CC3.1 124.68,144.06 125.76,144.06 125.89,143.94 YC1.1
  BOTTOM w0.076: UC1.AM18 v2(115.46,126.63)
PCH_RTCX2: length 36
  TOP w0.076: 119.35,125.01 118.76,124.43 115.97,124.43 115.46,124.94 v2(115.46,125.72)
  TOP w0.254: YC1.2 125.89,144.85 125.76,144.72 124.63,144.72 CC4.1 124.14,144.76 RC13.2 122.86,144.76 v4(122.51,144.41) 122.51,144.31 121.8,142.17 120.39,140.76 119.55,140.43 117.98,139.93 117.63,139.58 117.26,138.87 117.26,138.3 117.57,137.58 117.57,136.98 118.21,136.2 118.89,135.83 120.57,135 121.46,134.11 122.37,132.76 122.37,131.29 122.34,131.22 121.38,130.26 120.44,128.12 120.44,125.86 120.07,125.14 119.89,125.01 119.35,125.01
  BOTTOM w0.076: UC1.AM20 v2(115.46,125.72)
PCH_SLP_LAN#: length 233.7
  TOP w0.114: RPC18.6 129.59,150.9 129.25,150.57 129.25,150.26 130.5,149.02 v1(132.48,149.02) ; v1(200.29,112.28) 200.29,112.46 202.61,114.78 202.61,116.68 203.24,117.32 203.24,125.67 202.63,126.28 200.25,126.28 199.99,126.03 199.99,125.73 199.74,125.47 198.82,125.47 198.43,125.87 196.56,125.87 196.08,126.35 194.96,126.35 194.59,125.98 194.59,125.89 194.27,125.57 UE1.87 192.52,125.57 189.65,122.7 184.2,122.7 v1(184,122.9) ; v1(253.05,87.22) 253.21,87.37 RL26.1
  IN1 w0.14: v1(200.29,112.28) 200.68,111.89 210.76,111.89 212.42,110.23 215.2,110.23 218.64,106.8 219.88,106.8 220.97,105.7 220.97,103.04 221.88,102.13 227.46,102.13 234.18,95.41 245.7,95.41 248.93,92.19 248.93,91.72 249.87,90.78 249.87,89.26 251.91,87.22 v1(253.05,87.22)
  BOTTOM w0.076: 122.61,129.14 122.15,128.68 121.68,128.68 121.57,128.79 120.1,128.79 119.77,128.63 119.77,128.63 119.61,128.47 UC1.AW15
  BOTTOM w0.114: v1(184,122.9) 184,124.05 182.81,125.24 182.81,126.64 183.81,127.64 183.81,132.62 185.18,133.99 185.18,136.94 184.06,138.06 184.06,149.01 183.1,149.97 183.1,157.84 180.6,160.34 165.06,160.34 164.11,159.39 147.8,159.39 146.66,158.24 138.63,158.24 137.01,156.63 137.01,153.19 133.11,149.29 132.75,149.29 v1(132.48,149.02) 132.37,148.91 131.9,148.91 131.38,148.38 131.38,138.82 130.62,138.06 130.62,134.88 126.62,130.88 124.87,130.88 123.14,129.14 122.61,129.14
PCH_SLP_WLAN#: length 125.5
  TOP w0.114: v1(179.19,124.89) 179.7,124.89 180.18,124.4 183.68,124.4 184.14,123.94 188.58,123.94 189.21,124.57 189.21,125.53 190.82,127.15 191.25,127.15 192.43,125.97 UE1.88 ; RPC6.3 135.23,148.63 135.36,148.5 135.36,147.86 135.49,147.73 137.09,147.73 137.33,147.98 v4(137.33,148.05) 137.33,148.61 v1(137.22,148.73)
  IN1 w0.14: v1(175.58,141.58) 175.58,142.01 175.48,142.11 175.48,149.22 171.26,153.44 171.26,154.81 170.68,155.39 169.11,155.39 168.18,156.32 153.72,156.32 153.15,155.75 148.4,155.75 148,155.34 143.86,155.34 142.23,153.72 142.23,151.19 139.77,148.73 v1(137.22,148.73)
  BOTTOM w0.076: UC1.BB17 121.52,127.43 123.62,127.43 125.04,128.85 125.19,128.85 125.39,129.05
  BOTTOM w0.114: v1(137.22,148.73) 137.22,145.27 136.48,144.53 136.48,135.83 131.1,130.44 129.4,130.44 128.01,129.05 125.39,129.05 ; v1(179.19,124.89) 178.68,125.4 178.68,136.63 177.61,137.69 177.61,139.54 v1(175.58,141.58)
PCH_SMB_CLK: length 21.3
  TOP w0.114: RC375.1 105.49,145.85 v1(106.15,145.85) 107.53,147.23 108.69,147.23 v4(109.09,147.62) 109.09,148.12 108.19,149.02 QC1.6
  IN1 w0.14: v2(107.23,133.96) 107.03,133.96 106.76,134.22 106.76,135.31 106.39,135.69 106.39,135.76 104.97,137.18 104.97,140.45 106.39,141.87 106.39,142.7 105.7,143.39 105.7,145.4 v1(106.15,145.85)
  BOTTOM w0.076: UC1.R7 v2(107.23,133.96)
PCH_SMB_DATA: length 19.6
  TOP w0.114: QC1.3 105.99,147.26 106.13,147.12 v1(106.13,146.56) 105.77,146.56 105.47,146.87 105.14,146.87 104.59,146.32 RC376.1
  IN1 w0.076: 106.12,135.24 106.53,134.83 106.53,133.79 107,133.32 v2(107.23,133.32)
  IN1 w0.14: v1(106.13,146.56) 105.44,145.87 105.44,143.28 106.12,142.59 106.12,141.98 104.74,140.6 104.74,137.09 106.12,135.71 106.12,135.24
  BOTTOM w0.076: UC1.R8 v2(107.23,133.32)
PCH_SML0_CLK: length 311.1
  TOP w0.114: UL1.28 255.24,96.29 255.42,96.47 255.42,97 v1(255.86,97.44) ; v2(107.23,132.69) 107.24,132.69 107.63,133.08 107.63,134.83 107.3,135.16 107.02,135.16 106.74,135.44 106.74,136.35 106.28,136.81 106.28,138.21 108.17,140.1 v1(108.3,140.1) 108.3,140.99 108.81,141.51 108.81,143.5 108.2,144.12 108.12,144.12 RC92.1
  IN1 w0.14: v1(184,93.34) 184.2,93.14 185.95,93.14 189.12,96.31 189.12,98.21 197.39,106.48 198.74,106.48 200.86,108.6 211.32,108.6 214.56,105.36 214.56,104.19 219.51,99.23 225.25,99.23 225.62,98.86 226.57,98.86 226.75,99.05 227.76,99.05 v1(228.21,98.6)
  IN3 w0.114: v1(255.86,97.44) 255.42,97 255.42,96.44 255.1,96.11 249.18,96.11 248.54,96.76 246.29,96.76 244.83,98.23 243.72,98.23 242.99,98.95 240.61,98.95 238.23,101.33 230.95,101.33 v1(228.21,98.6)
  BOTTOM w0.076: UC1.R9 v2(107.23,132.69)
  BOTTOM w0.114: v1(184,93.34) 182.65,94.68 176.7,94.68 174.35,92.34 174.35,90.36 166.55,82.56 160.19,82.56 159.81,82.18 127.58,82.18 126.24,80.84 109.06,80.84 v4(108.32,81.58) 107.02,82.88 102.08,82.88 101.04,81.84 100.58,81.84 99.97,81.22 90.95,81.22 84.37,87.81 84.37,99.31 84.98,99.92 84.98,100.51 84.39,101.09 84.39,115.5 82.33,117.56 82.33,121.6 78.07,125.86 78.07,139.39 85.07,146.39 91.6,146.39 94.23,149.02 98.44,149.02 100.64,146.82 100.64,143.67 101.61,142.7 105.61,142.7 108.07,140.24 108.16,140.24 v1(108.3,140.1)
PCH_SML0_DAT: length 300.4
  TOP w0.114: RC93.1 108.63,144.09 109.05,143.66 109.05,141.34 108.71,140.99 108.71,139.87 v2(108.31,139.48) ; v1(254.11,96.83) 254.04,96.76 UL1.31
  IN1 w0.14: v1(184.03,94.26) 184.39,93.9 186.34,93.9 188.86,96.42 188.86,98.32 197.28,106.74 198.63,106.74 200.75,108.86 211.43,108.86 214.83,105.47 214.83,104.3 219.62,99.5 225.36,99.5 225.73,99.13 226.21,99.13 v1(226.69,99.61)
  IN3 w0.114: v1(254.11,96.83) 253.29,97.65 246.12,97.65 245.04,98.73 243.93,98.73 243.2,99.46 240.79,99.46 238.43,101.82 228.89,101.82 v1(226.69,99.61)
  BOTTOM w0.076: UC1.W2 108.93,136.56 109.07,136.71 109.07,136.71 109.08,136.71 109.19,136.96 109.19,137.29 109.03,137.45 109.03,138.75 v2(108.31,139.48)
  BOTTOM w0.114: v2(108.31,139.48) 107.76,140.02 107.76,140.1 105.41,142.46 101.51,142.46 100.4,143.57 100.4,146.72 98.34,148.77 94.42,148.77 91.79,146.14 85.17,146.14 78.31,139.29 78.31,125.96 82.57,121.7 82.57,117.66 84.63,115.6 84.63,101.21 85.22,100.62 85.22,99.8 84.65,99.23 84.65,87.87 91.05,81.46 98.66,81.46 99.41,82.22 v4(99.47,82.22) 101.07,82.22 101.98,83.12 107.47,83.12 109.51,81.08 126.14,81.08 127.48,82.42 159.71,82.42 160.09,82.8 166.45,82.8 174.11,90.46 174.11,92.44 176.6,94.93 183.37,94.93 v1(184.03,94.26)
PCH_SML1CLK: length 20.5
  TOP w0.114: RC377.1 103.7,146.12 104.38,146.8 v1(104.38,147.63) 104.38,147.99 105.01,148.62 105.01,149.41 v4(104.89,149.53) 104.77,149.4 QC2.6
  IN1 w0.14: v2(107.6,139) 107.3,139.3 107.3,146.41 106.38,147.33 104.68,147.33 v1(104.38,147.63)
  BOTTOM w0.076: v2(107.6,139) 108.01,139 108.66,138.35 108.66,136.96 108.72,136.83 108.72,136.7 108.65,136.47 108.65,136.34 108.73,136.12 108.73,135.97 UC1.W3
PCH_SML1DATA: length 19.4
  TOP w0.114: RC378.1 102.81,145.93 v1(103.88,147) 103.42,147.45 102.37,147.45 102.05,147.77 QC2.3
  IN1 w0.14: v1(103.88,147) 103.93,147.05 106.28,147.05 107.04,146.29 107.04,138.99 107.49,138.54 v2(107.98,138.54)
  BOTTOM w0.076: v2(107.98,138.54) 108.5,138.02 108.5,136.93 108.54,136.81 108.54,136.69 108.48,136.48 108.48,136.33 108.53,136.17 108.53,135.71 UC1.V3
PCH_SPI_CLK: length 14.5
  TOP w0.114: RC365.2 129.69,139.82 128.44,139.82 128.08,140.18 124.55,140.18 122.86,138.49 119.47,138.49 v2(119.45,138.48)
  BOTTOM w0.076: v2(119.45,138.48) 119.39,138.48 118.57,137.66 118.57,137.32 118.64,137.25 118.64,136.95 118.93,136.66 118.93,136.15 UC1.AV2
PCH_SRTCRST#: length 29
  TOP w0.114: RC14.2 CC5.1 134.55,137.44 134.1,137.88 v4(132.05,137.88) 129.98,137.88 129.48,137.39 v1(125.57,137.39)
  IN3 w0.076: 120.57,129.18 120.57,128.76 118.79,126.98 116.44,126.98 v2(116.09,126.63)
  IN3 w0.114: 120.57,129.18 120.57,129.84 121.01,130.28 121.36,130.28 122.42,131.34 122.42,132.36 124.62,134.55 125.13,134.55 125.95,135.38 125.95,136.68 125.57,137.06 v1(125.57,137.39)
  BOTTOM w0.076: UC1.AN18 v2(116.09,126.63)
  BOTTOM w0.114: JME1.1 125.8,136.83 125.57,137.06 v1(125.57,137.39)
PCH_SYSPWROK: length 256
  TOP w0.114: CC527.2 100.35,132.35 v2(96.96,135.74) ; UE1.82 194.37,123.57 194.88,124.08 202.52,124.08 202.73,123.88 202.73,117.54 202.1,116.91 202.1,115.01 199.41,112.31 v1(199.2,112.31)
  IN1 w0.14: v2(96.96,135.74) 96.65,136.05 88.79,136.05 88.16,136.68 83.39,136.68 82.37,135.67 82.37,134.73 80.57,132.93 80.57,131.37 74.3,125.11 74.3,118.41 73.84,117.95 73.84,115.35 74.41,114.78 74.41,111.5 75.62,110.29 76.36,110.29 78.18,108.47 78.18,95.99 80.84,93.34 80.84,78.43 v1(81.64,77.63)
  BOTTOM w0.076: UC1.B6 99.5,134.48 98.22,134.48 v2(96.96,135.74)
  BOTTOM w0.114: v1(81.64,77.63) 85.42,77.63 87.82,75.23 94.23,75.23 95.56,73.9 101.3,73.9 102.88,72.32 108.52,72.32 v4(109.91,73.71) 111.22,75.02 140.38,75.02 141.86,76.5 161.66,76.5 162.6,77.44 168.39,77.44 173.5,82.55 177.44,82.55 178.55,83.66 179.22,83.66 179.47,83.41 179.88,83.41 180.71,84.25 181.86,84.25 188.56,90.95 188.56,97.66 195.47,104.57 195.47,108.05 196.32,108.9 196.32,111.67 197.23,112.57 199,112.57 199.2,112.37 v1(199.2,112.31)
PCH_TSOFF#: length 180.7
  TOP w0.114: D25.1 251.82,149.28 v1(251.82,148.62) ; RPC10.3 110.54,154.34 110.29,154.09 110.29,152.62 v1(109.71,152.04)
  IN3 w0.114: v1(109.71,152.04) 109.95,151.8 114.13,151.8 119.7,157.37 125.93,157.37 126.49,157.93 130.09,157.93 130.24,158.08 134.72,158.08 135.36,158.72 145.07,158.72 146.23,159.88 161.44,159.88 162.01,160.45 180.37,160.45 190.49,150.33 190.49,148.63 v1(190.23,148.37)
  BOTTOM w0.076: 110.51,139.72 110.51,139.06 110.69,138.88 110.69,137.87 110.61,137.79 110.61,137.53 110.67,137.47 110.67,136.84 110.64,136.8 110.64,136.69 110.67,136.66 110.67,135.91 110.8,135.78 110.99,135.78 111.58,135.19 UC1.AD4
  BOTTOM w0.114: v1(251.82,148.62) 251,149.45 236.2,149.45 229.44,142.69 205.84,142.69 v4(204.72,143.81) 200.09,148.44 195.25,148.44 194.74,147.93 190.67,147.93 v1(190.23,148.37) ; v1(109.71,152.04) 109.71,151.19 110.73,150.17 110.73,147.86 110.09,147.23 110.09,146.08 110.81,145.36 110.81,142.4 110.41,142 110.41,139.82 110.51,139.72
PCH_XTAL24_IN: length 14.7
  BOTTOM w0.114: YC2.3 89.56,115.35 90.91,115.35 CC7.1 91.4,115.32 91.93,115.32 RC30.2 92.34,115.48 92.65,115.48 93.83,116.66 97.12,116.66 98.44,115.34 99.94,115.34 99.97,115.36 100.27,115.36 100.29,115.34 100.53,115.34 100.56,115.36 100.96,115.36 101.51,115.91 UC1.E37
PCH_XTAL24_OUT: length 13.7
  BOTTOM w0.114: YC2.1 90.29,115.84 91.03,115.84 CC6.1 91.32,115.83 91.78,115.83 RC30.1 92.59,116.11 93.67,117.19 97.35,117.19 98.67,115.87 99.59,115.87 99.64,115.93 99.88,115.93 99.94,115.87 100.24,115.87 100.29,115.93 100.59,115.93 100.62,115.9 100.86,115.9 101.03,116.07 101.03,116.55 UC1.E35
PCIE1_PTX_DRX_N0: length 10.5
  BOTTOM w0.076: UC1.B23 99.31,123.51 99.31,123.42 99.01,123.12 97.87,123.12 96.95,122.21 96.95,122.2 96.84,122.09 96.82,122.09 96.77,122.05 96.76,122.05
  BOTTOM w0.114: CC86.2 90.35,121.49 92.57,121.49 93.13,122.05 v1(96.5,122.05) 96.76,122.05
PCIE1_PTX_DRX_P0: length 10.4
  BOTTOM w0.076: 96.76,122.28 96.78,122.28 97.8,123.29 98.95,123.29 99.15,123.49 99.15,123.56 99.08,123.63 UC1.A23
  BOTTOM w0.114: CC87.2 90.41,121.72 92.48,121.72 93.03,122.28 v1(94.72,122.28) 96.76,122.28
PCIE2_PTX_DRX_N1: length 9.5
  BOTTOM w0.076: 96.71,123.12 96.73,123.12 96.76,123.09 96.89,123.09 97.71,123.9 98.25,123.9 98.41,124.06 98.92,124.06 99.02,124.03 99.21,124.03 99.3,124.06 99.54,124.06 99.77,123.99 100.03,124.1 100.44,124.05 100.62,123.87 100.62,123.75 UC1.D23
  BOTTOM w0.114: CC88.2 92.44,123.12 v1(95.75,123.12) 96.71,123.12
PCIE2_PTX_DRX_P1: length 9.5
  BOTTOM w0.076: UC1.C23 100.36,123.63 100.46,123.72 100.46,123.8 100.36,123.9 100.05,123.93 99.78,123.81 99.52,123.9 99.35,123.9 99.16,123.84 99.01,123.84 98.9,123.9 98.48,123.9 98.32,123.73 97.77,123.73 96.96,122.92 96.76,122.92 96.73,122.89 96.71,122.89
  BOTTOM w0.114: CC89.2 92.38,122.89 v1(93.46,122.89) 96.71,122.89
PCIE3_CRX_DTX_N: length 204.6
  IN1 w0.076: 103.16,134.73 103.17,134.72 103.17,134.66 103.59,134.24 103.59,134 104.34,133.25 104.34,130.05 104.05,129.75 103.66,129.75 103.41,129.5 103.41,128.29 102.93,127.81 102.93,127.68 103.06,127.55 v2(103.19,127.55)
  IN1 w0.14: v1(258.22,161.38) 258.38,161.38 258.66,161.66 258.66,162.01 258.08,162.59 244.4,162.59 228.78,146.97 198.69,146.97 195.04,150.62 190.78,150.62 178.77,162.62 175.3,162.62 174.81,163.11 163.43,163.11 162.86,162.53 149.27,162.53 148.46,163.34 127.73,163.34 126,161.61 119.87,161.61 112.99,154.73 108.75,154.73 99.93,145.91 99.93,138.59 102.64,135.88 102.64,135.25 103.16,134.73
  BOTTOM w0.076: v2(103.19,127.55) 103.07,127.67 103.07,127.93 103.15,128 UC1.H16
  BOTTOM w0.114: v1(258.22,161.38) 258.38,161.38 258.65,161.65 258.65,161.76 258.45,161.96 JWLBT.43
PCIE3_CRX_DTX_P: length 204.6
  IN1 w0.076: v2(102.55,127.56) 102.76,127.77 102.76,127.88 103.25,128.36 103.25,129.57 103.59,129.92 103.98,129.92 104.18,130.12 104.18,133.18 103.42,133.93 103.42,134.18 103.06,134.54 102.99,134.54 102.98,134.55
  IN1 w0.14: 102.98,134.55 102.39,135.15 102.39,135.77 99.68,138.48 99.68,146.02 108.64,154.98 112.88,154.98 119.76,161.86 125.89,161.86 127.63,163.6 148.66,163.6 149.47,162.78 162.75,162.78 163.33,163.36 174.92,163.36 175.4,162.88 178.88,162.88 190.88,150.87 195.15,150.87 198.8,147.23 228.68,147.23 244.3,162.85 258.18,162.85 258.92,162.11 258.92,161.47 v1(259.01,161.37)
  BOTTOM w0.076: v2(102.55,127.56) 102.81,127.8 UC1.G16
  BOTTOM w0.114: JWLBT.41 258.95,161.97 258.88,161.9 258.88,161.5 v1(259.01,161.37)
PCIE3_CTX_C_DRX_N: length 214.5
  TOP w0.114: v2(97.39,127.16) 97.31,127.16 97.14,127.33 97.14,127.54 97.29,127.69 97.49,127.69 97.92,128.12 98.08,128.12 CC18.1
  IN1 w0.076: v2(97.39,127.16) 97.25,127.16 97.15,127.26 97.15,127.44 97.26,127.55 98.44,127.55 98.86,127.13 100.72,127.13 100.87,126.98 103.44,126.98 104.12,127.67 104.12,128.45 104.85,129.18 104.85,134.17 103.92,135.1 103.92,135.16 103.91,135.18
  IN1 w0.14: 103.91,135.18 103.67,135.41 103.67,136.56 101.91,138.31 101.48,138.31 100.82,138.97 100.82,145.7 109.07,153.96 113.48,153.96 120.23,160.7 126.36,160.7 127.29,161.63 131.72,161.63 132.56,162.48 145.28,162.48 146,161.75 163.22,161.75 163.8,162.33 174.49,162.33 174.98,161.84 178.45,161.84 191.13,149.17 195.4,149.17 198.37,146.2 229.1,146.2 243.47,160.57 254.6,160.57 254.75,160.42 255.16,160.42 255.31,160.57 255.73,160.57 255.87,160.42 256.29,160.42 256.44,160.57 256.86,160.57 257,160.42 257.42,160.42 257.56,160.57 257.98,160.57 258.13,160.42 258.55,160.42 258.69,160.57 259.94,160.57 260.11,160.4 260.11,160.16 259.92,159.97 v1(259.64,159.97)
  BOTTOM w0.114: v1(259.64,159.97) 259.92,159.97 260.14,160.19 260.14,161.82 259.95,162.01 JWLBT.37
PCIE3_CTX_C_DRX_P: length 214.4
  TOP w0.114: CC19.1 98.07,128.35 97.82,128.35 97.39,127.92 97.19,127.92 96.91,127.63 96.91,127.27 v5(96.79,127.15)
  IN1 w0.076: 103.73,135 103.74,134.98 103.8,134.98 104.68,134.11 104.68,129.25 103.96,128.52 103.96,127.74 103.37,127.15 100.94,127.15 100.79,127.3 98.93,127.3 98.51,127.72 97.19,127.72 96.98,127.51 96.98,127.35 v5(96.79,127.15)
  IN1 w0.14: 103.73,135 103.42,135.31 103.42,136.45 101.81,138.06 101.37,138.06 100.57,138.87 100.57,145.81 108.97,154.21 113.38,154.21 120.12,160.95 126.25,160.95 127.19,161.89 131.61,161.89 132.46,162.73 145.38,162.73 146.11,162.01 163.12,162.01 163.7,162.59 174.6,162.59 175.09,162.1 178.56,162.1 191.23,149.42 195.5,149.42 198.47,146.45 229,146.45 243.37,160.82 260.05,160.82 260.37,160.5 260.37,160.11 v1(260.52,159.96)
  BOTTOM w0.114: v1(260.52,159.96) 260.37,160.11 260.37,161.92 260.45,162 JWLBT.35
PCIE3_CTX_DRX_N: length 3.2
  TOP w0.114: CC18.2 99.75,128.22 99.87,128.22 100.08,128 100.08,127.84 100.42,127.5 100.88,127.5 100.98,127.6 101.26,127.6 v2(101.3,127.56)
  BOTTOM w0.076: UC1.D17 100.9,127.46 101.05,127.61 101.25,127.61 v2(101.3,127.56)
PCIE3_CTX_DRX_P: length 3.3
  TOP w0.114: v2(100.9,127.96) 100.9,127.85 100.79,127.73 100.51,127.73 100.31,127.93 100.31,128.1 99.96,128.45 99.56,128.45 CC19.2
  BOTTOM w0.076: UC1.C17 100.28,127.46 100.78,127.96 v2(100.9,127.96)
PCIE3_PTX_DRX_N2: length 9.8
  BOTTOM w0.076: UC1.D24 100.18,123.07 99.88,123.36 99.49,123.36 99.1,122.96 98.09,122.96 97.4,122.26 97.35,122.26 97.34,122.25
  BOTTOM w0.114: 97.34,122.25 95.56,120.48 v1(93.95,120.48) 93.08,120.48 92.99,120.57 92.32,120.57 CC90.2
PCIE3_PTX_DRX_P2: length 9.8
  BOTTOM w0.076: UC1.C24 99.76,123.12 99.69,123.19 99.56,123.19 99.17,122.8 98.66,122.8 98.59,122.72 98.4,122.72 98.33,122.8 98.16,122.8 97.91,122.55 97.91,122.5 97.91,122.44 97.75,122.28 97.64,122.28 97.51,122.15 97.51,122.1 97.5,122.09
  BOTTOM w0.114: 97.5,122.09 97.03,121.62 97.03,121.54 97.03,121.45 96.79,121.21 96.7,121.21 96.62,121.21 96.38,120.97 96.38,120.88 96.38,120.8 96.13,120.55 96.05,120.55 95.96,120.55 95.66,120.25 v1(95.44,120.25) 94.97,120.25 94.88,120.16 94.5,120.16 94.41,120.25 92.99,120.25 92.9,120.34 92.2,120.34 92.08,120.22 CC23.2
PCIE4_CRX_DTX_N: length 255.5
  TOP w0.114: CL2.1 248.11,94.34 247.92,94.34 244.14,98.12 241.17,98.12 238.87,100.41 230.2,100.41 227.49,103.12 210.99,103.12 208.33,105.78 208.33,106.3 208.17,106.46 v1(207.97,106.46)
  IN1 w0.076: v2(102.32,128.46) 102.21,128.46 102.05,128.31 102.05,128.11 101.88,127.94 101.44,127.94 101.06,128.31 98.69,128.31 98.65,128.26 98.63,128.26
  IN1 w0.14: v1(207.97,106.46) 208.16,106.46 208.3,106.32 208.3,105.87 206.34,103.92 200.93,103.92 192.89,95.88 192.89,89.38 172.76,69.25 146.47,69.25 145.77,69.95 132.4,69.95 130.18,72.17 119.26,72.17 119.21,72.21 111.17,72.21 108.67,74.71 107.28,74.71 105.42,76.57 105.42,77.34 104.76,78 104.76,78.62 104.17,79.21 102.9,79.21 101.35,80.75 98,80.75 97.39,80.14 95.7,80.14 88.69,87.16 88.69,97.08 88.4,97.36 88.4,100.69 87.89,101.2 87.23,101.2 86.53,101.9 86.53,110.98 84.4,113.11 84.4,115.66 83.5,116.57 83.5,119.82 84.06,120.39 84.06,122.34 84.63,122.91 85.63,122.91 86.37,123.65 86.37,124.08 88.5,126.21 88.52,126.21 89.58,127.27 91.28,127.27 92.1,126.44 95.4,126.44 95.89,126.93 95.89,127.79 96.37,128.26 98.63,128.26
  BOTTOM w0.076: UC1.G15 102.55,128.92 102.32,128.69 v2(102.32,128.46)
PCIE4_CRX_DTX_N_C: length 2
  TOP w0.114: CL2.2 249.68,94.34 250.57,94.34 250.66,94.24 UL1.39
PCIE4_CRX_DTX_P: length 255.5
  TOP w0.114: v1(208.73,106.46) 208.55,106.28 208.55,105.88 211.09,103.35 227.59,103.35 230.29,100.64 238.97,100.64 241.27,98.34 244.24,98.34 248.01,94.57 248.11,94.57 CL1.1
  IN1 w0.076: v2(101.74,128.46) 101.89,128.31 101.89,128.18 101.81,128.1 101.5,128.1 101.13,128.47 98.69,128.47 98.65,128.52 98.63,128.52
  IN1 w0.14: v1(208.73,106.46) 208.55,106.28 208.55,105.77 206.45,103.66 201.03,103.66 193.15,95.78 193.15,89.28 172.86,68.99 146.37,68.99 145.67,69.69 132.3,69.69 130.08,71.91 119.15,71.91 119.11,71.96 111.06,71.96 108.57,74.45 107.17,74.45 105.16,76.46 105.16,77.24 104.5,77.9 104.5,78.52 104.06,78.96 102.79,78.96 101.25,80.5 98.11,80.5 97.5,79.89 95.59,79.89 88.43,87.05 88.43,96.97 88.14,97.26 88.14,100.59 87.79,100.95 87.13,100.95 86.28,101.79 86.28,110.87 84.15,113 84.15,115.55 83.24,116.46 83.24,119.93 83.81,120.49 83.81,122.45 84.52,123.16 85.52,123.16 86.11,123.75 86.11,124.18 88.39,126.46 88.41,126.46 89.47,127.52 91.38,127.52 92.21,126.7 95.3,126.7 95.64,127.04 95.64,127.89 96.26,128.52 98.63,128.52
  BOTTOM w0.076: v2(101.74,128.46) 101.81,128.46 102.16,128.81 UC1.F15
PCIE4_CRX_DTX_P_C: length 2
  TOP w0.114: CL1.2 249.69,94.57 250.56,94.57 250.64,94.64 UL1.38
PCIE4_CTX_C_DRX_N: length 235.4
  TOP w0.114: v1(206.48,106.46) 206.78,106.16 206.78,105.96 210.35,102.4 227.19,102.4 229.9,99.69 238.56,99.69 241.53,96.72 244.52,96.72 248.11,93.13 250.57,93.13 250.65,93.04 UL1.42
  IN1 w0.14: v1(206.48,106.46) 206.72,106.22 206.72,105.79 205.63,104.69 200.61,104.69 192.12,96.21 192.12,89.7 174.58,72.17 164.19,72.17 161.58,74.78 141.38,74.78 139.86,73.26 136.92,73.26 135.22,74.96 111.9,74.96 103.39,83.47 102.37,83.47 100.83,85.01 94.12,85.01 91.32,87.81 91.32,101.85 89.45,103.71 89.45,111.57 86.78,114.24 86.78,116.48 91.17,120.86 91.17,125.47 90.88,125.76 90.66,125.76 v1(90.41,126.02)
  BOTTOM w0.114: CC92.1 90.84,125.82 90.6,125.82 v1(90.41,126.02)
PCIE4_CTX_C_DRX_P: length 235.4
  TOP w0.114: UL1.41 250.62,93.44 250.53,93.36 248.2,93.36 244.61,96.95 241.62,96.95 238.65,99.92 229.99,99.92 227.29,102.62 210.44,102.62 207.01,106.06 207.01,106.22 v1(207.25,106.46)
  IN1 w0.14: v1(207.25,106.46) 206.98,106.19 206.98,105.68 205.73,104.44 200.71,104.44 192.37,96.1 192.37,89.6 174.69,71.91 164.09,71.91 161.48,74.53 141.48,74.53 139.96,73 136.82,73 135.11,74.71 111.8,74.71 103.29,83.22 102.26,83.22 100.73,84.76 94.02,84.76 91.07,87.71 91.07,101.74 89.2,103.61 89.2,111.47 86.53,114.14 86.53,116.58 90.91,120.97 90.91,125.37 90.77,125.51 90.53,125.51 v1(90.41,125.38)
  BOTTOM w0.114: v1(90.41,125.38) 90.61,125.59 90.83,125.59 CC93.1
PCIE4_CTX_DRX_N: length 8.3
  BOTTOM w0.076: 97.47,126.74 97.49,126.74 97.52,126.7 97.82,126.7 98.18,126.35 98.32,126.35 98.52,126.54 98.98,126.54 99.18,126.44 99.31,126.32 99.31,126.19 99.39,126.11 UC1.B19
  BOTTOM w0.114: 97.47,126.74 v1(95.96,126.74) 93.6,126.74 92.71,125.84 92.39,125.84 CC92.2
PCIE4_CTX_DRX_P: length 8.3
  BOTTOM w0.076: 97.47,126.51 97.49,126.51 97.52,126.54 97.76,126.54 98.11,126.18 98.39,126.18 98.59,126.38 98.94,126.38 99.09,126.31 99.14,126.25 99.14,126.17 99.08,126.11 UC1.A19
  BOTTOM w0.114: CC93.2 92.44,125.61 92.8,125.61 93.7,126.51 v1(93.96,126.51) 97.47,126.51
PCIE4_PTX_DRX_N3: length 11.3
  BOTTOM w0.076: UC1.A25 98.84,122.56 99.02,122.56 99.15,122.43 99.15,122.35 99.04,122.24 98.9,122.24 98.36,121.7 98.31,121.7 98.3,121.69
  BOTTOM w0.114: 98.3,121.69 98.05,121.44 98.05,121.16 97.75,120.86 97.47,120.86 95.69,119.08 v1(94,119.08) 90.38,119.08 CC24.2
PCIE4_PTX_DRX_P3: length 11.3
  BOTTOM w0.076: UC1.B25 99.32,122.38 99.32,122.29 99.11,122.08 98.97,122.08 98.47,121.58 98.47,121.54 98.46,121.53
  BOTTOM w0.114: CC91.2 90.38,118.85 v1(95.54,118.85) 95.79,118.85 97.57,120.63 97.85,120.63 98.28,121.06 98.28,121.35 98.46,121.53
PCIE6_CRX_DTX_N: length 153.7
  TOP w0.114: JCR.1 164.45,55.1 164.61,55.26 164.61,55.42 164.19,55.84 v1(164.19,56.06) 164.19,58.47 163.84,58.82 158.38,64.27 143.96,64.27 142.67,65.56 142.67,70.95 143.65,71.93 143.8,71.93 144.08,72.2 v1(144.08,72.22)
  IN1 w0.076: v2(102.56,126.63) 102.4,126.63 102.32,126.56 102.32,126.32 102.07,126.07 100.2,126.07 100.16,126.03 100.14,126.03
  IN1 w0.14: 100.14,126.03 98.45,126.03 98.08,126.4 97.21,126.4 96.48,125.67 91.71,125.67 90.91,126.47 89.87,126.47 89.27,125.87 89.27,121.84 85.05,117.61 85.05,117.25 86,116.29 86,113.71 88.08,111.63 88.08,109.39 88.68,108.79 88.68,103.39 90.37,101.7 90.37,87.66 93.91,84.12 97.9,84.12 99.43,82.58 103.19,82.58 112,73.76 118.31,73.76 118.49,73.95 130.6,73.95 132.56,71.98 143.86,71.98 144.08,72.2 v1(144.08,72.22)
  BOTTOM w0.076: UC1.G18 102.81,126.87 102.62,126.69 v2(102.56,126.63)
PCIE6_CRX_DTX_P: length 153.7
  TOP w0.114: JCR.2 164.95,55.11 164.83,55.22 164.83,55.52 164.41,55.94 164.41,58.56 163.93,59.04 158.47,64.5 v1(144.42,64.5) 144.05,64.5 142.9,65.66 142.9,70.86 143.74,71.7 143.96,71.7 v1(144.08,71.58)
  IN1 w0.076: v2(101.92,126.63) 102.05,126.63 102.16,126.53 102.16,126.39 102,126.23 100.2,126.23 100.16,126.28 100.14,126.28
  IN1 w0.14: 100.14,126.28 98.55,126.28 98.18,126.65 97.11,126.65 96.38,125.92 91.82,125.92 91.02,126.72 89.77,126.72 89.02,125.97 89.02,121.94 84.79,117.72 84.79,117.14 85.74,116.19 85.74,113.61 87.83,111.52 87.83,109.28 88.42,108.69 88.42,103.29 90.12,101.59 90.12,87.55 93.81,83.87 97.79,83.87 99.33,82.33 103.08,82.33 111.9,73.51 118.42,73.51 118.6,73.69 130.49,73.69 132.46,71.73 143.93,71.73 v1(144.08,71.58)
  BOTTOM w0.076: v2(101.92,126.63) 102.16,126.87 UC1.F18
PCIE6_CTX_C_DRX_N: length 142.6
  TOP w0.114: v1(145.03,71.29) 145.03,71.12 144.86,70.95 143.8,70.95 143.39,70.54 143.39,66.12 144.51,65 158.91,65 165.28,58.62 165.28,58.2 v1(165.28,58.2) 165.28,58.2 165.28,57.42 166.19,56.52 166.19,55.47 165.95,55.23 JCR.4
  IN1 w0.14: v1(145.03,71.29) 145.03,71.13 144.89,70.99 132.46,70.99 130.39,73.06 118.75,73.06 118.68,72.99 111.56,72.99 109,75.55 108.31,75.55 105.54,78.31 105.54,79 104.15,80.4 103.59,80.4 102.42,81.57 97.44,81.57 96.91,81.03 95.91,81.03 89.46,87.48 89.46,97.52 89.19,97.79 89.19,101.35 88.5,102.04 87.6,102.04 87.31,102.33 87.31,111.3 85.18,113.43 85.18,115.99 84.27,116.9 84.27,119.5 84.83,120.06 86.1,120.06 87.24,121.2 87.24,123.58 87.79,124.13 88.1,124.13 v1(88.37,123.86)
  BOTTOM w0.114: v1(88.37,123.86) 88.57,124.05 88.82,124.05 CC20.1
PCIE6_CTX_C_DRX_P: length 142.6
  TOP w0.114: v1(145.05,70.56) 144.89,70.72 143.9,70.72 143.62,70.45 143.62,66.21 144.61,65.23 159,65.23 165.51,58.71 165.51,57.51 166.41,56.61 v1(166.41,56.27) 166.41,55.38 166.41,55.21 166.45,55.18 JCR.5
  IN1 w0.14: v1(145.05,70.56) 144.87,70.73 132.35,70.73 130.28,72.8 118.85,72.8 118.78,72.73 111.45,72.73 108.89,75.29 108.2,75.29 105.29,78.21 105.29,78.9 104.04,80.14 103.48,80.14 102.31,81.31 97.55,81.31 97.01,80.78 95.8,80.78 89.21,87.37 89.21,97.42 88.94,97.69 88.94,101.24 88.39,101.78 87.5,101.78 87.05,102.23 87.05,111.2 84.92,113.32 84.92,115.89 84.02,116.79 84.02,119.61 84.73,120.32 85.99,120.32 86.99,121.31 86.99,123.68 87.68,124.38 88.26,124.38 v1(88.37,124.49)
  BOTTOM w0.114: v1(88.37,124.49) 88.59,124.28 88.79,124.28 CC21.1
PCIE6_CTX_DRX_N: length 11.6
  BOTTOM w0.076: 96.84,125.6 96.86,125.6 96.89,125.64 97.03,125.64 97.26,125.41 97.87,125.41 98.06,125.6 99.2,125.6 99.53,125.27 99.92,125.27 100.19,125.54 UC1.D20
  BOTTOM w0.114: CC20.2 90.29,123.97 93.03,123.97 94.66,125.6 v1(96.59,125.6) 96.84,125.6
PCIE6_CTX_DRX_P: length 11.5
  BOTTOM w0.076: 96.84,125.83 96.86,125.83 96.89,125.8 97.1,125.8 97.32,125.57 97.8,125.57 97.99,125.76 99.27,125.76 99.56,125.47 99.69,125.47 UC1.C20
  BOTTOM w0.114: 96.84,125.83 v1(95.06,125.83) 94.56,125.83 94.23,125.5 94.05,125.5 93.81,125.26 93.81,125.08 93.57,124.84 93.39,124.84 93.15,124.59 93.15,124.42 92.93,124.2 92.28,124.2 92.15,124.33 91.81,124.33 91.68,124.2 91.34,124.2 91.21,124.33 90.87,124.33 90.74,124.2 90.16,124.2 90.05,124.32 CC21.2
PCIE_CRX_C_GTX_N0: length 6.7
  BOTTOM w0.114: UV3.AG31 63.51,140.43 63.51,139.03 63.79,138.75 63.79,136.62 63.59,136.42 63.44,136.27 63.44,136.26 v1(63.28,136.1) 63.28,136.11 63.12,135.95 63.12,135.43 63,135.3 62.61,135.3 62.47,135.15 CV133.2
PCIE_CRX_C_GTX_N1: length 8.5
  BOTTOM w0.084: 62.95,139.9 62.95,139.91 62.96,139.92 62.98,139.92 62.98,140.14 62.98,140.16 62.93,140.28 arc(62.84,140.42) 62.81,140.58 62.81,140.73 62.89,140.92 62.89,141.06 arc(62.89,141.1) 62.87,141.14 62.87,141.14 62.78,141.36 62.78,141.56 UV3.AF28
  BOTTOM w0.114: 62.95,139.9 62.95,139.27 62.89,139.21 62.89,136.75 61.92,135.78 v1(61.54,135.78) 61.24,135.78 60.94,135.48 60.94,135.23 CV135.2
PCIE_CRX_C_GTX_N2: length 14.1
  TOP w0.114: CV137.2 68.69,132.82 68.69,133.82 67.84,134.67 67.84,136.87 62.48,142.23 62.48,142.82 62.29,143 v2(62.15,143)
  BOTTOM w0.114: v2(62.15,143) 62.54,143.39 UV3.AF26
PCIE_CRX_C_GTX_N3: length 14.5
  TOP w0.114: CV139.2 66.61,132.78 66.61,135.54 63.4,138.76 62.23,138.76 61.35,139.64 61.35,140.08 60.77,140.65 60.77,142.76 v2(60.54,143)
  BOTTOM w0.114: UV3.AD26 v2(60.54,143)
PCIE_CRX_C_GTX_P0: length 6.7
  BOTTOM w0.114: CV132.2 63.35,134.86 63.35,135.86 64.01,136.52 v1(64.01,137.14) 64.01,138.84 63.74,139.12 63.74,140.59 UV3.AH30
