# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on TOP (solid shape): 154.82,61.27 154.82,59.16 155.3,58.68 155.3,56.62 155.07,56.39 154.16,56.39 153.88,56.67 153.88,61.35 153.96,61.42 154.67,61.42
+5VS on TOP: 219.77,132.7 220.35,132.7 220.35,132.14 221.11,132.14 221.11,132.7 221.57,132.7 221.57,132.14 222.33,132.14 222.33,132.7 223.63,132.7 223.86,132.47 223.86,130.69 223.63,130.46 219.82,130.46 219.67,130.61 219.67,132.59
+5VS on TOP: 175.64,55.53 176.44,55.53 177,54.97 177,54.19 177.3,53.88 179.77,53.88 179.78,53.9 179.78,55.48 179.72,55.54 177.9,55.54 176.91,56.53 175.57,56.53 174.25,55.21 174.25,54.85 174.43,54.67 174.66,54.67 174.77,54.78 174.89,54.78
+5VS on BOTTOM: 254.25,75.99 254.11,75.85 250.81,75.85 250.68,75.72 250.68,74.38 250.35,74.05 246.56,74.05 246.36,74.25 246.36,75.6 245.23,76.73 245.23,80.69 245.48,80.95 246.63,80.95 247.01,80.56 250.69,80.56 250.94,80.82 254.12,80.82 254.25,80.69
+5VS on IN1: 171.15,54.31 171.13,54.34 152.2,54.34 151.76,54.78 151.76,56.43 151.79,56.47 151.79,57.09 152.43,57.73 155.94,57.73 155.97,57.7 171.06,57.7 196.59,83.23 225.93,83.23 226.31,82.85 226.31,78.91 225.8,78.41 197.6,78.41 176.78,57.58 176.78,55.98 175.11,54.31
+5VS on IN2: 246.49,74.2 251.06,74.2 253.22,76.36 257.54,76.36 262.12,80.94 262.12,81.58 261.87,81.83 258.06,81.83 257.68,82.22 257.68,82.6 256.91,83.36 256.91,85.77 257.68,86.53 258.18,86.53 259.58,87.93 259.58,90.47 260.09,90.98 261.89,90.98 262.12,91.21 262.12,102.28 260.48,103.92 232.14,103.92 228.97,107.08 228.97,113.71 228.34,114.35 228.34,116.63 227.7,117.27 224.77,117.27 224.39,117.65 224.39,132.33 223.21,133.51 219.82,133.51 219.44,133.13 219.44,119.31 220.97,117.78 220.97,115.62 221.99,114.6 222.24,114.6 222.37,114.47 222.37,105.94 229.6,98.71 243.82,98.71 250.31,92.22 250.31,86.66 248.14,84.49 223.76,84.49 222.74,83.47 222.74,77.76 223.5,76.99 244.96,76.99 246.11,75.85 246.11,74.58
+5VS_CLASSD on TOP: 175.2,52.06 175.2,52.57 175.43,52.8 175.43,54.76 175.83,55.15 176.28,55.15 176.74,54.69 176.74,53.96 177.07,53.63 178.24,53.63 178.44,53.42 178.44,52.84 178.24,52.64 176.16,52.64 176.03,52.51 176.03,51.87 175.88,51.72 175.55,51.72
+5VS_CLASSD on IN1: 178.98,56.06 178.98,57.64 179.74,58.4 180.3,58.4 181.39,59.49 182.35,59.49 182.4,59.54 183.19,59.54 184.36,60.71 192.77,60.71 193.17,61.12 193.17,62.62 192.64,63.15 187.97,63.15 187.94,63.18 183.19,63.18 177.68,57.66 177.68,56.04 177.38,55.73 176.97,55.73 175.47,54.24 175.47,51.95 175.51,51.91 175.51,51.73 175.57,51.67 176.26,51.67 176.56,51.98 176.56,53.65
+5VS_HDMI on TOP (solid shape): 282.45,54.19 282.45,51.34 282.15,51.04 280.88,51.04 280.37,51.54 280.37,54.19 280.63,54.44 282.2,54.44
+5VS_HDMI on BOTTOM: 282.48,51.87 283.14,51.21 283.55,51.21 283.8,51.47 283.8,52.18 284.08,52.46 285.25,52.46 285.49,52.22 285.49,50.97 284.21,49.69 281.18,49.69 281.06,49.82 281.06,54.74 281.18,54.87 282.28,54.87 282.48,54.67
+5VS_HDMI on IN2: 280.98,54.72 288.4,54.72 288.98,54.13 288.98,52.03 288.47,51.52 281.13,51.52 280.47,52.18 280.47,54.21
+5VS_HDMI_F on BOTTOM: 280.02,49.31 284.21,49.31 284.46,49.05 284.46,43.09 284.08,42.7 280.02,42.7 279.64,43.09 279.64,48.93
+5VS_LS on TOP (solid shape): 222.88,134.92 222.88,132.89 219.83,132.89 219.07,133.65 219.07,134.92 219.19,135.05 222.75,135.05
+V1.00AP on TOP (solid shape): 145.66,168.7 145.66,166.81 145.62,166.77 145.62,165.06 145.15,164.6 140.77,164.6 139.98,163.81 138.37,163.81 138.37,164.34 138.38,164.35 138.91,164.35 138.91,166.29 138.9,166.3 138.36,166.3 138.35,166.31 138.35,166.8 138.38,166.84 138.38,167.65 139.82,169.08 145.28,169.08
+V1.00AP on BOTTOM (solid shape): 146.33,170.16 146.33,167.71 145.82,167.2 145.82,164.84 145.5,164.52 141.08,164.52 140.73,164.17 140.06,164.17 139.66,163.77 138.39,163.77 138.36,163.8 138.36,164.32 138.37,164.33 138.91,164.33 138.91,166.3 138.9,166.31 138.45,166.31 138.36,166.4 138.36,168.04 139.54,169.22 139.54,170.01 140.17,170.63 145.86,170.63
+VCC_AMPHYPLL on TOP: 85.29,133.35 85.46,133.17 85.46,131.69 85.24,131.47 83.69,131.47 83.15,132 83.15,133.35 83.28,133.47 83.74,133.47 83.86,133.35
+VCC_AMPHYPLL on IN3: 102.82,128.72 102.67,128.86 100.5,128.86 98.51,130.86 97.65,130.86 97.29,131.22 95.74,131.22 95.28,131.68 83.6,131.68 83.1,132.18 83.1,133.24 83.33,133.47 83.77,133.47 84.09,133.15 95.33,133.15 95.99,132.49 97.64,132.49 97.66,132.48 100.23,132.48 101.82,130.89 102.1,130.89 102.71,130.28 102.71,130 103.01,129.7 103.9,129.7 104.03,129.57 104.03,129.08 103.67,128.72
+VCC_CORE on TOP (solid shape): 78.6,91.15 78.6,87.51 75.63,84.53 70.3,84.53 69.94,84.89 69.94,91.7 70.37,92.13 77.62,92.13
+VCC_CORE on BOTTOM (solid shape): 74.06,91.27 77.99,91.27 78.53,90.73 78.53,80.89 78.11,80.47 74.41,80.47 74.38,80.44 74.03,80.44 73.78,80.69 73.78,82.09 73.77,82.09 73.65,82.2 72.89,82.2 72.76,82.07 72.76,80.69 72.51,80.44 71.15,80.44 70.24,81.35 70.24,90.62 71.3,91.69 73.63,91.69
+VCC_CORE on IN1 (solid shape): 77.94,91.13 77.94,87.15 77.47,86.68 71.34,86.68 70.52,87.51 70.52,91.09 71.41,91.99 77.08,91.99
+VCC_CORE on IN3 (solid shape): 78.48,91.01 78.48,87.22 77.67,86.42 70.91,86.42 70.61,86.72 70.61,91.2 71.14,91.74 77.74,91.74
+VCC_CORE on TOP: outline of 83 points within 90.79,110.27 115.68,122.71
+VCC_CORE on BOTTOM: 113.14,119.54 114.66,119.54 115.68,118.52 115.68,115.35 113.9,113.57 113.14,113.57 112.76,113.95 112.76,119.16
+VCC_CORE on BOTTOM: 103.74,112.3 102.22,113.82 102.22,119.79 102.34,119.92 102.98,119.92 102.98,119.79 103.23,119.54 105.01,119.54 105.12,119.43 105.12,112.44 104.98,112.3
+VCC_CORE on IN1: 103.23,119.54 111.54,119.54 112.37,118.7 115.5,118.7 115.68,118.52 115.68,115.35 112.96,112.63 103.35,112.63 103.02,112.3 100.06,112.3 99.3,111.54 98.03,111.54 97.9,111.67 97.9,114.46 98.15,114.71 99.42,114.71 100.06,114.08 101.96,114.08 102.22,114.33 102.22,115.98 101.71,116.49 98.03,116.49 97.64,116.87 97.64,119.67 97.9,119.92 102.85,119.92
+VCC_CORE on IN2: 71.29,86.43 70.59,87.13 70.59,91.69 71.07,92.17 75.61,92.17 78.1,94.66 78.1,111.04 87.62,120.57 99.81,120.57 100.58,121.33 112.77,121.33 113.28,120.82 113.28,110.54 112.9,110.16 102.86,110.16 91.31,98.6 91.31,87.8 90.04,86.53 77.25,86.53 77.15,86.43
+VCC_CORE on VCC: 58.5,85.88 58.67,92.14 57.77,98.33 74.64,98.33 76.95,100.65 76.95,102.3 77.72,103.07 77.72,103.78 76.95,104.55 76.95,112.84 84.41,120.3 92.54,120.3 94.08,121.84 98.57,121.84 100.47,119.93 101.19,119.93 101.69,120.43 115.64,120.44 115.69,120.39 115.69,114.65 115.51,114.47 115.13,114.47 114.99,114.33 114.81,114.33 114.66,114.18 114.66,112.91 114.43,112.68 113.02,112.68 113.01,112.68 112.8,112.68 112.8,112.68 111.75,112.68 111.74,112.68 111.53,112.68 111.53,112.68 103.38,112.68 102.72,112.02 102.72,110.25 102.49,110.01 101.31,110.01 100.94,110.41 97.93,110.41 97.4,109.88 97.4,108.91 97.8,108.5 98.31,108.5 98.54,108.27 98.54,107.72 98.44,107.62 97.8,107.62 97.4,107.21 97.4,105.56 96.39,104.55 96.39,103.83 96.77,103.45 96.77,99.59 91.11,93.94 83.06,85.88
+VCC_DSW3P3 on TOP: 111.98,127.4 111.73,127.66 111.21,127.66 111.2,127.66 111.11,127.66 111.04,127.73 111.04,128.11 111.17,128.24 111.55,128.24 112.44,129.13 112.54,129.13 113.28,128.39 113.28,127.63 113.05,127.4
+VCC_DSW3P3 on TOP: 90.28,141.26 92.56,141.26 93.96,139.86 94.09,139.86 94.34,139.61 96.25,139.61 96.5,139.35 96.5,138.84 96.37,138.72 93.96,138.72 93.33,139.35 92.94,139.73 90.51,139.73 90.15,140.09 90.15,141.13
+VCC_DSW3P3 on IN2: 116.26,135.28 116.26,141.36 114.58,143.05 99.38,143.05 97.4,141.07 94.89,141.07 94.79,140.97 94.79,140.97 94.79,139.09 94.94,138.93 98.14,138.93 101.39,142.18 112.95,142.18 114.26,140.88 114.26,132.69 112.35,130.78 112.35,127.86 112.66,127.55 113.15,127.55 113.33,127.73 113.33,129.13 115.33,131.14 115.33,131.92 116.1,132.69 116.1,135.11
+VCC_GT on BOTTOM (solid shape): 90.04,70.9 90.62,70.9 90.95,71.23 98.15,71.23 98.4,70.98 98.4,63.95 97.95,63.5 90.58,63.5 90.11,63.97 90.11,65.24 90.14,65.27 89.82,65.59 89.48,65.59 89.32,65.43 89.32,64.09 88.86,63.63 86.51,63.63 86.17,63.97 86.17,68.14 86.76,68.74 86.76,70.91 87.08,71.23 89.7,71.23
+VCC_GT on IN1 (solid shape): 98.56,70.83 98.56,67.09 98.23,66.76 89.81,66.76 88.84,67.73 88.84,70.24 89.23,70.64 92.3,70.64 92.95,71.28 98.11,71.28
+VCC_GT on IN3 (solid shape): 98.83,70.74 98.83,67.28 98.45,66.91 89.95,66.91 88.77,68.09 88.77,70.28 89.02,70.53 92.01,70.53 92.71,71.23 98.34,71.23
+VCC_GT on TOP: outline of 110 points within 88.75,66.96 114.67,112.22 ; 2 cut-outs
+VCC_GT on BOTTOM: 104.64,96.41 103.87,97.19 103.87,100.62 102.72,101.76 102.72,111.79 103.11,112.17 105.04,112.17 105.12,112.09 105.12,104.72 105.15,104.72 105.81,104.06 109.64,104.06 109.7,104.11 111.73,104.11 112.57,103.27 112.57,102.38 110.98,100.8 110.98,96.55 110.93,96.5 110.93,95.87 110.23,95.17 110.23,85.01 109.72,84.5 105.4,84.5 104.64,85.26
+VCC_GT on IN1: 112.53,103.18 110.98,101.63 110.98,96.55 110.47,96.04 105.01,96.04 103.87,97.19 103.87,100.62 102.72,101.76 102.72,108.32 103.9,109.5 112.26,109.5 112.53,109.23
+VCC_GT on IN2: 90.16,66.47 88.64,67.99 88.64,83.74 88.7,83.74 92,87.04 92,98.41 102.1,108.5 102.35,108.5 103.62,109.77 112.16,109.77 112.51,109.42 112.51,97.96 110.23,95.68 110.23,73.07 103.62,66.47
+VCC_GT on VCC: 86.71,66.72 86.33,67.1 84.04,67.1 83.43,67.72 83.42,85.53 91.47,93.58 97.27,99.38 97.27,103.66 96.89,104.04 96.89,104.34 97.91,105.35 97.91,107 98.01,107.11 98.65,107.11 99.05,107.51 99.05,108.48 98.52,109.01 98.01,109.01 97.91,109.12 97.91,109.67 98.14,109.9 100.72,109.9 101.09,109.51 102.7,109.51 103.23,110.04 103.23,111.81 103.59,112.17 111.54,112.17 112.12,111.59 112.12,109.4 112.76,108.77 112.76,102.88 111.49,101.61 111.49,95.51 109.2,93.23 109.2,85.14 112.5,81.84 112.5,78.29 113.14,77.65 113.14,77.02 113.15,69.51 113.15,67.4 112.47,66.72
+VCC_IO on TOP: 85.82,94.64 87.52,94.64 87.78,94.38 87.78,92.78 87.72,92.73 85.84,92.73 85.74,92.83 85.74,94.56
+VCC_IO on TOP: 124.19,102.14 116.95,109.38 115.7,109.38 115.46,109.62 115.46,111.07 115.26,111.27 114.13,111.27 114.03,111.37 114.03,112.82 114.25,113.05 114.25,113.84 114.33,113.91 115.07,113.91 115.3,114.15 115.3,114.62 115.91,115.22 115.91,117.81 116.03,117.94 116.87,117.94 117.1,118.17 117.1,118.62 116.95,118.78 115.75,118.78 115.5,119.03 115.42,119.03 115.04,119.41 113.93,119.41 113.68,119.65 112.49,119.65 112.41,119.73 112.41,120.71 112.54,120.83 116.49,120.83 117.48,119.84 118.6,119.84 118.62,119.87 118.9,119.87 119.29,119.49 119.72,119.49 122,117.2 122,114.46 122.66,113.8 129.95,113.8 130.52,113.23 130.52,111.55 132.57,109.51 135.62,109.51 136,109.89 136,112.81 136.63,113.44 142.48,113.44 147.05,118.02 147.05,138.73 145.28,140.5 145.28,140.51 145.03,140.76 145.03,149.14 144.26,149.91 144.26,156.89 144.39,157.02 144.39,157.65 144.52,157.78 144.77,157.78 144.9,157.91 144.9,159.05 144.77,159.18 144.52,159.18 144.39,159.3 144.39,159.81 144.52,159.94 145.33,159.94 147.5,157.77 147.5,152.77 147.44,152.71 147.44,151.81 149.84,149.41 149.84,148.13 151.12,146.85 151.12,114.95 138.31,102.14 ; 1 cut-out
+VCC_IO on TOP: 87.62,108.89 87.62,109.44 88.51,110.33 98.87,110.33 99.87,109.34 100.35,109.34 100.96,109.95 102.02,109.95 102.25,109.72 102.25,108.96 101.8,108.5 101.21,108.5 100.96,108.25 88.26,108.25
+VCC_IO on BOTTOM: 88.94,110.23 89.22,109.95 89.22,109.32 88.94,109.04 88.31,109.04 86.96,107.69 86.96,101.75 87.55,101.16 87.55,99.94 87.24,99.64 87.24,97.07 86.61,96.44 86.61,95.52 86.81,95.32 87.09,95.32 87.44,94.97 87.44,94.23 87.22,94 86.73,94 86.56,93.82 86.56,93.21 86.43,93.09 85.77,93.09 85.57,93.29 85.57,98.83 86.05,99.31 86.05,101.06 85.46,101.65 85.46,108.25 87.44,110.23
+VCC_IO on BOTTOM: 112.9,120.87 115.08,120.87 115.72,120.24 115.72,119.35 115.51,119.15 115.08,119.15 114.62,119.6 112.87,119.6 112.74,119.73 112.74,120.72
+VCC_IO on IN1: 113.39,120.94 115.17,120.94 115.68,120.43 115.68,119.16 115.55,119.03 115.42,119.03 115.41,119.02 112.79,119.02 112.24,119.58 112.24,120.01 113.18,120.95 113.19,120.94
+VCC_IO on IN1: 114.92,114.1 115.5,114.1 115.65,113.95 115.65,112.73 114.19,111.27 114.19,111.27 112.63,109.71 103.82,109.71 102.99,108.89 102.98,108.9 102.24,108.9 102.23,108.89 100.88,108.89 100.25,109.52 100.25,111.45 100.68,111.88 102.86,111.88 103.42,112.44 113.28,112.44 114.92,114.08
+VCC_IO on IN3: 115.81,112.68 114.68,111.55 111.17,111.55 110.05,112.67 110.05,120.21 110.71,120.87 115.56,120.87 115.81,120.63
+VCC_IO_AP on TOP: 138.92,160.31 143.54,160.31 144.26,159.58 144.26,157.26 144.01,157 140.2,157 139.82,156.62 139.82,155.24 139.69,155.11 138.8,155.11 138.68,155.24 138.68,157.27 138.67,157.27 138.67,160.05
+VCC_IO_AP_GATE on TOP: 145.28,160.7 144.8,160.7 144.59,160.9 144.59,161.51 144.65,161.56 145.43,161.56 145.59,161.72 145.59,162.15 145.69,162.25 146.07,162.25 146.17,162.15 146.17,161.13 146.45,160.85 147.06,160.85 147.21,160.7 147.21,160.24 147.69,159.76 148.53,159.76 148.76,159.53 148.76,158.67 148.61,158.52 147.47,158.52
+VCC_MPHYGT on TOP: 90.37,148.84 89.88,148.84 89.86,148.86 89.86,149.37 89.83,149.4 89.1,149.4 89.07,149.37 89.07,148.84 88.66,148.84 88.66,149.37 88.64,149.4 87.9,149.4 87.9,148.84 87.27,148.84 86.74,149.37 85.31,149.37 82.92,146.97 82.92,136.65 82.57,136.3 82.57,134.86 82.92,134.51 82.92,131.88 83.56,131.24 85.08,131.24 85.46,130.86 85.46,129.84 85.22,129.59 82.09,129.59 80.89,128.4 80.89,124.56 80.87,124.53 77.62,124.53 77.34,124.81 77.34,148.56 82.87,154.1 89.81,154.1 90.37,153.54
+VCC_MPHYGT on TOP: 106.52,129.46 106.83,129.15 106.83,127.15 106.95,127.02 106.95,126.36 106.93,126.34 106.14,126.34 106.04,126.44 106.04,127.1 105.45,127.68 104.26,127.68 104.13,127.81 104.13,129.31 104.29,129.46
+VCC_MPHYGT on BOTTOM: 105.7,129.57 106.79,129.57 106.92,129.45 106.92,127.92 106.9,127.91 106.9,127.12 106.52,126.74 105.81,126.74 105.52,127.03 105.52,128.2 105.24,128.48 105.24,129.12
+VCC_MPHYGT on IN2: 106.92,126.27 108.19,126.27 108.32,126.13 108.32,124.71 108.68,124.35 110.98,124.35 112.13,125.51 112.25,125.51 112.38,125.38 112.38,122.34 111.88,121.84 100.45,121.84 99.56,120.95 87.72,120.95 86.51,119.73 82.24,119.73 81.3,120.67 81.3,121.61 81.34,121.65 81.34,122.49 79.85,123.97 79.85,125.58 79.93,125.66 80.4,125.66 80.41,125.65 80.56,125.65 81.45,124.76 86.08,124.76 86.52,124.31 87.74,123.1 89.01,123.1 89.52,122.59 98.89,122.59 99.89,123.59 101.96,123.59 102.22,123.85 105.76,123.85 106.8,124.89 106.8,125.27 106.79,125.27 106.79,126.14
+VCC_MPHYGT on IN2: 105.39,128.3 105.87,127.82 105.87,127.54 106.29,127.12 106.57,127.12 106.66,127.21 106.66,128.94 106.66,128.94 106.66,129.34 106.42,129.59 105.53,129.59 104.89,130.22 104.89,132.89 104.64,133.14 101.97,133.14 101.97,133.14 101.59,133.14 101.58,133.14 94.73,133.14 94.71,133.12 92.68,133.12 89.1,136.7 80.21,136.7 79.24,135.73 79.24,134.59 79.6,134.23 87.29,134.23 89.48,132.05 89.48,131.16 91.45,129.19 94.47,129.19 94.49,129.17 96.27,129.17 97.14,128.3 98.53,128.3 98.66,128.18 101.2,128.18 101.58,127.79 103.5,127.79 104.01,128.3
+VCC_MPHYGT on IN3: 105.14,126.65 104.76,127.03 104.5,127.03 103.85,127.69 103.85,128.66 104.17,128.99 104.17,129.45 104.16,129.45 104.16,129.67 103.99,129.84 103.23,129.84 103.07,130.01 103.07,130.2 100.51,132.75 96.12,132.75 95.52,133.35 86.16,133.35 85.55,133.96 85.55,134.69 85.35,134.89 85.35,135.28 85.11,135.52 81.7,135.52 80.28,134.09 79.57,134.09 79.32,134.35 79.32,134.97 79.56,135.21 79.56,135.44 80.36,136.24 86.06,136.24 86.15,136.15 86.15,136.06 87.8,134.41 96.61,134.41 96.76,134.27 99.55,134.27 100.03,133.79 103.98,133.79 104.55,133.22 104.55,132.37 104.72,132.2 104.72,130.02 105.38,129.36 105.38,129.33 106.47,129.33 107.08,128.72 107.08,127.2 106.53,126.65
+VCC_SA on TOP (solid shape): 78.47,109.51 78.47,105.32 78.21,105.06 74.91,105.06 74.66,105.32 74.66,109.25 75.13,109.73 78.25,109.73
+VCC_SA on BOTTOM (solid shape): 73.06,110.76 77.04,110.76 77.34,110.47 77.34,104.84 77.1,104.6 74.23,104.6 72.47,102.84 70.22,102.84 69.63,103.43 69.63,105.69 69.77,105.83 70.88,105.83 71.03,105.98 71.03,106.39 70.79,106.62 69.62,106.62 69.24,107 69.24,109.28 69.5,109.54 70.16,109.54 70.46,109.85 70.46,110.71 70.88,111.13 72.69,111.13
+VCC_SA on IN1 (solid shape): 76.72,109.24 76.72,106.73 76.13,106.14 75.5,106.14 75.14,106.5 75.14,109.24 75.63,109.72 76.23,109.72
+VCC_SA on IN2 (solid shape): 76.77,109.47 76.77,106.33 76.49,106.05 75.34,106.05 74.98,106.41 74.98,109.45 75.43,109.9 76.34,109.9
+VCC_SA on IN3 (solid shape): 76.68,109.35 76.68,106.41 76.36,106.09 75.48,106.09 75,106.57 75,109.22 75.43,109.65 76.38,109.65
+VCC_SA on TOP: 101.96,123.86 103.61,123.86 103.7,123.77 103.7,123.24 103.78,123.16 104.31,123.16 104.38,123.1 111.11,123.1 111.36,122.84 112.12,122.84 112.25,122.97 113.27,122.97 113.39,123.1 113.39,123.48 113.52,123.6 113.77,123.6 113.9,123.48 113.9,122.59 113.27,121.95 112.17,121.95 112.15,121.93 112.02,121.93 111.68,121.59 111.68,120.59 111.65,120.57 106.04,120.57 105.86,120.75 105.86,121.43 105.73,121.56 105.2,121.56 105.02,121.38 105.02,120.98 105,120.95 104.59,120.95 104.39,120.75 104.39,119.93 104.23,119.78 103.55,119.78 103.47,119.86 103.47,120.25 103.42,120.3 102.85,120.3 102.72,120.43 102.72,120.68 102.34,121.06 102.34,121.7 101.58,122.46 101.58,123.48
+VCC_SA on BOTTOM: 103.36,119.67 102.22,120.81 102.22,123.22 103.11,124.11 103.49,124.11 103.5,124.1 105,124.1 105.12,123.97 105.12,120.06 104.73,119.67
+VCC_SA on BOTTOM: 113.52,123.6 114.15,123.6 114.28,123.48 114.28,122.46 114.03,122.21 113.52,122.21 113.39,122.33 113.39,123.48
+VCC_SA on IN1: 103.95,123.35 110.47,123.35 110.85,123.73 113.9,123.73 114.28,123.35 114.28,122.33 111.61,119.67 103.36,119.67 102.34,120.68 102.34,122.46 102.47,122.59 102.72,122.59 103.45,123.31 103.92,123.31
+VCC_SA on IN2: 113.84,122.35 113.53,122.35 113.28,122.09 112.77,122.09 112.64,122.22 112.64,123.85 112.74,123.95 113.78,123.95 113.94,123.8 113.94,122.45
+VCC_SA on VCC: 57.64,98.84 56.42,102.77 54.77,106.53 65.4,117.17 65.4,117.27 67.15,117.27 69.21,119.32 69.21,127.19 70.57,128.56 70.72,128.7 78.45,136.43 83.18,136.43 83.18,135.91 82.8,135.53 82.8,134.82 83.71,133.9 85.1,133.9 86.76,132.25 104.21,132.25 104.51,131.95 104.51,131.44 104.97,130.98 105.35,130.98 105.53,130.8 105.53,129.28 105.78,129.03 105.78,124.07 106.24,123.62 112.69,123.62 113.02,123.95 113.02,124.58 113.2,124.76 113.99,124.76 114.15,124.59 114.15,121.44 114.14,121.42 114.15,121.32 114.15,121.3 113.8,120.95 101.48,120.94 100.98,120.44 100.68,120.44 98.78,122.35 93.87,122.35 92.33,120.81 84.2,120.81 76.45,113.05 76.45,104.34 77.21,103.57 77.21,103.28 76.45,102.51 76.45,100.86 74.43,98.84 ; 2 cut-outs
+VCC_ST on TOP: 77.56,121.41 77.84,121.13 78.28,121.13 78.55,121.41 78.55,121.74 78.73,121.92 79.09,121.92 79.34,121.66 79.34,120.29 78.89,119.83 78.02,119.83 77.89,119.96 77.89,120.49 77.01,121.38 77.01,122.78 77.06,122.83 77.46,122.83 77.56,122.73
+VCC_ST on IN2: 100.57,126.4 104.88,126.4 105.01,126.27 105.01,125.76 104.88,125.64 104.38,125.64 104.37,125.64 103.7,125.64 103.32,126.02 98.87,126.02 98.53,125.67 93.74,125.67 92.35,127.07 92.35,127.66 92.5,127.81 93.73,127.81 93.83,127.71 93.83,127.29 94.18,126.94 98.42,126.94 98.65,126.72 98.65,126.7 98.7,126.65 100.31,126.65
+VCC_STG on TOP: 77.31,117.52 80.21,117.52 80.31,117.42 80.31,112.77 80.21,112.67 79.47,112.67 79.06,113.08 79.06,114.8 78.53,115.34 78.53,115.95 78.05,116.43 77.23,116.43 77.16,116.51 77.16,117.37
+VCC_STG on TOP: 85.87,94.74 87.52,94.74 88.77,95.98 88.77,98.27 88.44,98.6 88.44,100.48 88.16,100.76 86.1,100.76 86.02,100.68 86.02,99.67 86.05,99.64 86.89,99.64 87.17,99.36 87.44,99.36 87.65,99.16 87.65,96.97 86.99,96.31 85.97,96.31 85.77,96.11 85.77,94.84
+VCC_STG on IN2: 98.91,125.89 102.88,125.89 102.96,125.8 102.96,125.24 102.72,125 102.71,125 102.57,124.86 101.01,124.86 100.62,125.25 99.68,125.25 98.41,123.98 97.77,123.98 97.14,124.62 91.8,124.62 89.52,126.91 80.83,126.91 79.75,125.83 79.75,123.82 81.04,122.53 81.04,116.05 80.08,115.08 78.76,115.08 78.55,115.29 78.55,115.72 78.33,115.95 78.33,120.42 79.14,121.23 79.14,122.19 78.07,123.26 78.07,127.45 79.34,128.72 86.36,128.72 87.04,128.05 90.99,128.05 93.59,125.44 98.47,125.44
+VCC_STG on IN3: 79.34,113.25 79.82,113.25 86.05,107.03 86.05,105.66 87.24,104.47 87.57,104.47 88.08,103.96 88.08,99.59 87.88,99.39 87.19,99.39 86.73,99.84 86.4,99.84 84.73,101.52 84.73,106.5 79.11,112.11 79.11,113.03
GND on TOP (solid shape): 66.61,60.06 66.61,56.49 66.41,56.29 62.7,56.29 62.46,56.53 62.46,60 62.77,60.31 66.36,60.31
GND on TOP (solid shape): 111.22,158.64 111.22,157.63 110.96,157.37 108.19,157.37 107.97,157.59 107.97,158.51 108.31,158.85 111,158.85
GND on TOP (solid shape): 155.45,172.81 155.45,171.46 155.24,171.25 154.2,171.25 153.96,171.49 153.96,172.79 154.14,172.96 155.29,172.96
GND on TOP (solid shape): 164.1,167.18 164.1,165.56 163.78,165.25 162.3,165.25 161.83,165.72 161.83,166.8 162.43,167.39 163.89,167.39
GND on TOP (solid shape): 194.32,173.32 194.32,169.76 194.08,169.51 193.49,169.51 193.34,169.67 193.34,173.1 193.79,173.56 194.09,173.56
GND on TOP (solid shape): 207.16,161.04 207.16,156.33 206.19,155.37 205.75,155.37 204.69,156.43 204.69,161.35 205.13,161.79 206.4,161.79
GND on TOP (solid shape): 220.61,112.75 220.61,110.62 220.38,110.38 218.44,110.38 218.13,110.7 218.13,112.77 218.29,112.93 220.43,112.93
GND on TOP (solid shape): 264.01,147.17 264.01,141.84 263.89,141.71 258.55,141.71 258.43,141.84 258.43,147.3 258.55,147.43 263.76,147.43
GND on TOP (solid shape): 275.13,104.56 275.13,104.06 274.73,103.66 273.33,103.66 273.22,103.78 273.22,104.46 273.62,104.86 274.83,104.86
GND on TOP (solid shape): 144.11,164.36 144.11,162.94 144.04,162.86 140.75,162.86 140.66,162.95 140.66,164.03 141.07,164.44 144.03,164.44
GND on TOP (solid shape): 171.73,166.34 171.73,165.6 171.1,164.97 168.79,164.97 168.46,165.3 168.46,166.15 168.74,166.43 171.65,166.43
GND on TOP (solid shape): 196.02,54.34 196.02,53.35 195.84,53.17 194.72,53.17 194.52,53.37 194.52,54.26 194.57,54.31 195.43,54.31 195.61,54.49 195.87,54.49
GND on TOP (solid shape): 11.36,162.58 13.1,162.58 13.28,162.4 13.28,160.04 13.13,159.89 10.76,159.89 10.35,160.31 10.35,161.88 11.06,162.59 11.35,162.59
GND on TOP (solid shape): 213.19,169.48 213.19,166.28 210.83,163.91 208.82,163.91 208.13,164.61 208.13,164.62 207.79,164.96 207.79,169.63 208.37,170.21 212.46,170.21
GND on TOP (solid shape): 285.97,111.14 285.97,108.66 285.87,108.56 282.87,108.56 282.58,108.85 281.77,108.85 281.58,109.04 281.58,110.64 281.9,110.97 283.45,110.97 283.73,111.25 285.87,111.25
GND on TOP (solid shape): 191.67,175.5 191.67,171.06 191.34,170.73 188.81,170.73 188.17,171.37 187.59,171.37 187.2,171.76 187.2,173.91 187.53,174.24 188.19,174.24 188.39,174.45 188.39,175.68 188.53,175.82 191.36,175.82
GND on TOP (solid shape): 201.71,172.83 201.71,170.92 199.49,168.7 197.55,168.7 197.22,169.03 197.22,172.64 197.38,172.79 199.14,172.79 199.15,172.8 199.43,172.8 200.14,173.51 201.03,173.51
GND on TOP (solid shape): 76.5,65.53 76.5,64.87 76.26,64.63 70.84,64.63 70.69,64.77 70.69,64.96 70.86,65.12 70.86,65.17 70.85,65.18 71.6,65.92 76.1,65.92
GND on TOP (solid shape): 80.75,109.51 80.75,104.3 79.54,103.09 76.74,103.09 76.69,103.04 74.83,103.04 74.7,103.17 74.7,104.34 74.78,104.43 78.47,104.43 79.1,105.06 79.1,109.63 79.23,109.76 80.5,109.76
GND on TOP (solid shape): 178.04,168.4 178.04,167.55 177.96,167.47 177.12,167.47 176.91,167.26 176.91,166.7 176.78,166.56 176.1,166.56 176.02,166.64 176.02,167.8 175.88,167.94 175.88,168.18 176.2,168.5 177.94,168.5
GND on TOP (solid shape): 180.46,165.87 181.11,165.87 181.19,165.78 181.19,165.08 180.87,164.76 180.62,164.76 180.51,164.65 178.7,164.65 178.55,164.81 178.55,165.89 178.63,165.97 179.71,165.97 179.82,166.09 180.24,166.09
GND on TOP (solid shape): 82.89,51.55 84.19,51.55 84.19,51.64 84.43,51.64 84.54,51.53 84.54,50.86 84.46,50.78 84.19,50.78 84.19,50.89 82.89,50.89 82.89,50.78 82.71,50.78 82.62,50.87 82.62,51.55 82.74,51.67 82.89,51.67
GND on TOP (solid shape): 120.31,173.34 120.31,172.84 120.23,172.76 118.8,172.76 118.69,172.65 118.69,169.84 118.49,169.64 115.57,169.64 115.31,169.91 115.31,173.13 115.39,173.22 118.63,173.22 118.65,173.24 119.51,173.24 119.71,173.43 120.23,173.43
GND on TOP (solid shape): 150.81,176.02 150.81,173.24 151.35,172.71 151.35,168.96 151.07,168.69 148.43,168.69 148.24,168.88 148.24,169.92 147.61,170.54 147.61,172.69 146.76,173.54 145.95,173.54 145.63,173.86 145.63,175.64 146.27,176.28 150.55,176.28
GND on TOP (solid shape): 72.7,96.29 74.71,96.29 74.88,96.12 74.88,95.45 74.47,95.04 67.86,95.04 67.72,95.18 67.72,95.35 67.69,95.9 67.59,96.45 67.59,96.49 67.8,96.7 72.3,96.7
GND on TOP (solid shape): 69.58,91.81 69.58,84.73 69.51,84.66 68.83,84.66 67.05,86.44 66.35,86.44 65.9,86.89 65.9,88.73 67.12,89.95 67.12,90.47 67.12,90.48 67.47,91.29 67.67,92.14 67.67,92.16 67.74,92.22 69.17,92.22
GND on TOP (solid shape): 171.88,177.38 171.88,177.37 174.85,177.37 174.85,176.73 172.04,176.73 171.88,176.56 171.88,176 171.61,175.73 169.39,175.73 169.17,175.51 169.17,175.37 168.76,174.96 167,174.96 166.03,173.99 166.01,173.99 165.19,173.17 165.19,169.69 164.64,169.13 155.85,169.13 155.54,169.44 155.54,170.43 157.22,172.11 157.22,175.81 157.57,176.17 161.49,176.17 161.66,176.34 161.66,177.37 163.97,177.37 164.08,177.48 171.78,177.48
GND on TOP (solid shape): 298.39,65.82 290.42,65.82 289.84,65.24 289.84,64.82 289.95,64.3 290.3,63.9 290.3,63.1 290.22,63.1 290.22,63.02 289.9,62.71 289.58,63.02 289.58,63.1 287.15,63.1 286.71,63.55 282.06,63.55 281.55,64.05 281.55,67.86 281.89,68.21 296.75,68.21 297.55,69.01 297.55,70.04 298.39,70.04
GND on TOP (solid shape): 62.53,102.07 62.56,102.07 62.57,102.06 62.8,101.99 63.03,102.07 63.23,102.07 63.24,102.06 63.44,102.01 63.63,102.07 65.46,102.07 65.84,101.68 65.84,100.3 65.23,99.68 65.19,99.7 62.91,100.36 60.59,99.9 60.55,99.88 60.38,100.05 60.38,102.18 60.8,102.59 62.01,102.59
GND on TOP (solid shape): outline of 93 points within 59.68,72.01 66.68,83.83
GND on TOP (solid shape): outline of 115 points within 284.37,37.33 299.57,52.47
GND on TOP (solid shape): 285.75,100.16 285.78,100.16 285.92,100.03 285.92,100 285.94,99.98 285.94,97.77 285.92,97.75 285.92,96.23 298.01,96.23 298.04,96.2 298.04,94.45 297.9,94.1 297.55,93.96 296.11,93.96 296.1,93.96 295.54,93.96 295.53,93.95 293.84,92.01 295.7,90.24 297.55,90.24 297.9,90.1 298.04,89.75 298.04,88.66 297.92,88.53 297.92,88.04 297.42,88.04 297.34,87.96 295.88,87.96 295.78,88.06 295.58,88.32 295.72,88.62 295.6,88.99 295.35,89.29 295.09,89.55 294.71,89.68 294.34,89.86 287.88,89.86 283.39,94.34 283.39,95.54 284.08,96.23 285.28,96.23 285.28,97.57 283.64,97.57 283.12,98.1 283.12,99.92 283.37,100.18 285.74,100.18
GND on TOP (solid shape): outline of 183 points within 283.24,15.46 298.02,28.11
GND on TOP (solid shape): outline of 241 points within 83.3,158.67 109.09,175.18
GND on TOP (solid shape): outline of 810 points within 175.31,123.81 298.42,177.37
GND on TOP (solid shape): outline of 1022 points within 196.38,0.63 298.42,79.68
GND on TOP (solid shape): outline of 176 points within 0.64,45.14 161.21,177.37
GND on BOTTOM (solid shape): 77.26,104.24 77.26,103.37 76.9,103.01 74.52,103.01 74.23,103.31 74.23,104.03 74.61,104.42 77.08,104.42
GND on BOTTOM (solid shape): 98.75,62.62 98.75,58.71 98.31,58.27 95.29,58.27 94.51,59.05 94.51,62.95 94.68,63.12 98.25,63.12
GND on BOTTOM (solid shape): 100.57,71.62 100.57,67.95 100.37,67.75 99.1,67.75 98.81,68.04 98.81,71.61 99.04,71.84 100.35,71.84
GND on BOTTOM (solid shape): 181.35,170.89 181.35,169.65 181.19,169.49 179.98,169.49 179.82,169.66 179.82,170.85 180.02,171.05 181.19,171.05
GND on BOTTOM (solid shape): 192.22,162.73 192.22,161.54 191.89,161.21 187.7,161.21 187.44,161.46 187.44,162.73 187.65,162.94 192.02,162.94
GND on BOTTOM (solid shape): 217.34,106.4 217.34,105.6 217.05,105.31 216.08,105.31 215.83,105.56 215.83,106.36 215.95,106.49 217.25,106.49
GND on BOTTOM (solid shape): 227.54,121.89 227.54,116.64 227.12,116.22 226.09,116.22 225.73,116.58 225.73,121.68 226.27,122.22 227.21,122.22
GND on BOTTOM (solid shape): 64.84,66.24 64.84,64.97 64.76,64.9 63.39,64.9 63.3,64.99 63.3,65.39 63.39,65.48 63.39,66.18 63.54,66.33 64.74,66.33
GND on BOTTOM (solid shape): 85.82,64.01 85.82,62.13 82.94,59.25 82,59.25 81.85,59.4 81.85,60.26 80.91,61.2 80.91,64.27 81.2,64.56 85.27,64.56
GND on BOTTOM (solid shape): 145.19,164.26 145.19,163.19 144.92,162.92 140.03,162.92 139.93,163.02 139.93,163.86 140.12,164.05 140.79,164.05 141.14,164.4 145.05,164.4
GND on BOTTOM (solid shape): 201.37,176.1 201.37,175.34 201.2,175.17 199.14,175.17 198.62,175.69 198.62,176.24 198.87,176.5 200.97,176.5
GND on BOTTOM (solid shape): 266.16,103.36 266.16,101.57 266.03,101.44 263.29,101.44 263.18,101.55 263.18,103.34 263.39,103.55 265.97,103.55
GND on BOTTOM (solid shape): 282.39,14.77 283.62,14.77 283.74,14.65 283.74,14.52 283.66,14.43 282.26,14.43 281.87,14.82 281.87,14.98 281.9,15.02 282.14,15.02
GND on BOTTOM (solid shape): 171.89,166.28 171.89,165.52 171.57,165.2 170.86,165.2 170.62,164.96 168.8,164.96 168.65,165.11 168.65,166.25 168.83,166.43 171.74,166.43
GND on BOTTOM (solid shape): 108.24,172.17 108.24,167.55 108.06,167.37 106.93,167.37 106.44,167.86 106.44,169.78 106.04,170.17 105.71,170.17 105.63,170.25 105.63,172.13 105.99,172.49 107.92,172.49
GND on BOTTOM (solid shape): 166.08,168.29 166.65,168.29 166.87,168.07 166.87,163.75 166.62,163.5 166.11,163.5 166.06,163.54 162.56,163.54 162.26,163.84 162.26,167.98 162.6,168.32 166.05,168.32
GND on BOTTOM (solid shape): 174.31,74.77 179.85,74.77 180.05,74.57 180.05,73.43 178.33,71.7 178.33,68.83 178.07,68.58 168.9,68.58 168.29,69.19 168.29,71.57 172.18,75.46 173.63,75.46
GND on BOTTOM (solid shape): 206.96,160.89 206.96,155.81 206.64,155.49 205.12,155.49 204.91,155.7 204.91,156.82 204.64,157.09 204.64,160.32 204.79,160.46 204.79,161 204.95,161.17 206.68,161.17
GND on BOTTOM (solid shape): 237,121.42 237,119.04 236.67,118.71 235.48,118.71 235.23,118.46 235.23,117.54 235.14,117.45 233.01,117.45 232.78,117.69 232.78,121.57 233.17,121.97 236.45,121.97
GND on BOTTOM (solid shape): 77.1,112.23 77.1,111.26 76.78,110.94 73.22,110.94 72.82,111.35 71.6,111.35 71.49,111.45 71.49,111.99 71.77,112.27 74.84,112.27 75.09,112.52 76.8,112.52
GND on BOTTOM (solid shape): 110.99,158.87 111.22,158.64 111.22,157.3 111.06,157.14 108.3,157.14 108.03,157.41 108.03,158.34 108.11,158.42 109.57,158.42 110.03,158.88 110.99,158.88
GND on BOTTOM (solid shape): 197.86,162.23 197.86,159.93 198.36,159.43 198.36,158.48 198.09,158.21 196.94,158.21 196.56,158.59 196.29,158.86 196.29,162.02 196.68,162.41 197.67,162.41
GND on BOTTOM (solid shape): 210.56,154.74 210.56,151.28 210.13,150.85 209.35,150.85 208.02,152.19 208.02,154.73 208.27,154.99 210.32,154.99
GND on BOTTOM (solid shape): 258.91,122.94 258.91,119.73 259.59,119.05 259.59,116.98 259.07,116.46 256.41,116.46 254.72,118.15 253.29,118.15 252.94,118.5 252.94,120.24 253.24,120.53 253.24,125.34 253.57,125.67 256.18,125.67
GND on BOTTOM (solid shape): 62.83,101.76 62.83,101.54 63,101.37 63.82,101.37 63.96,101.23 63.96,99.13 63.71,98.88 60.74,98.88 60.39,99.23 60.39,101.98 60.95,102.55 62.05,102.55
GND on BOTTOM (solid shape): 194.32,173.23 194.32,169.66 194.07,169.4 193.64,169.4 193.41,169.63 193.41,172.82 193.46,172.87 193.46,173.3 193.76,173.59 193.96,173.59
GND on BOTTOM (solid shape): 219.75,157.94 219.75,151.35 219.44,151.04 217.79,151.04 217.66,151.18 217.66,153.09 218.16,153.6 218.16,154.86 218.56,155.25 218.56,156.64 218.55,156.64 218.16,157.02 218.16,157.91 218.48,158.22 219.47,158.22
GND on BOTTOM (solid shape): 93.64,72.9 93.64,71.69 93.43,71.48 90.89,71.48 90.45,71.04 90.17,71.04 89.74,71.48 86.8,71.48 86.44,71.12 86.44,68.74 86.06,68.36 84.97,68.36 84.89,68.43 84.89,71.48 86.89,73.47 93.07,73.47
GND on BOTTOM (solid shape): 190.76,175.75 190.76,174.88 190.29,174.41 190.29,171.87 190.15,171.73 188.53,171.73 188.39,171.86 188.39,174.85 188.06,175.18 186.66,175.18 186.53,175.31 186.53,175.84 186.65,175.96 190.56,175.96
GND on BOTTOM (solid shape): 62.41,83.24 63.64,83.24 63.82,83.06 63.82,79.74 63.53,79.45 62.24,79.45 62.14,79.35 62.14,77.92 62.38,77.67 63.48,77.67 63.76,77.4 63.76,73.59 63.6,73.42 63.6,72.44 63.6,72.44 63.18,72.02 60.73,72.02 60.15,72.6 60.15,79.85 60.53,80.23 60.53,83.42 60.93,83.82 61.83,83.82
GND on BOTTOM (solid shape): 85.97,74.85 85.97,72.94 85.47,72.44 85.46,72.44 85.07,72.05 84.59,71.57 83.26,71.57 82.99,71.69 82.71,71.57 82.65,71.57 80.02,74.2 80.02,74.87 80.76,75.61 85.21,75.61
GND on BOTTOM (solid shape): 172.29,177.37 174.85,177.37 174.85,176.73 172.69,176.73 172.35,176.4 172.35,176 172.25,175.9 169.17,175.9 168.9,175.62 168.9,174.83 168.76,174.69 166.18,174.69 166.13,174.75 166.13,174.76 164.77,176.11 164.24,176.11 164.05,176.31 164.05,176.32 163.64,176.73 161.66,176.73 161.66,177.37 164.05,177.37 164.05,177.46 164.08,177.49 172.16,177.49
GND on BOTTOM (solid shape): 199.88,172.37 200.31,172.37 200.32,172.36 202.23,172.36 202.28,172.31 202.28,171.9 202.2,171.83 200.49,171.83 200.39,171.72 200.39,169.74 200.32,169.68 200.32,169.68 200.22,169.58 199.74,169.58 198.62,168.46 196.91,168.46 196.8,168.56 196.8,171.48 196.89,171.57 196.89,172.13 197.58,172.82 199.43,172.82
GND on BOTTOM (solid shape): 90.61,51.34 90.61,50.28 90.73,50.15 92.33,50.15 92.64,50.47 92.64,51.46 92.92,51.74 96.39,51.74 96.8,51.33 96.8,51 96.9,50.9 99.54,50.9 100.19,50.25 100.19,48.31 99.81,47.93 84.32,47.93 84.2,48.05 84.2,48.46 84.98,49.25 84.98,49.82 85.23,50.06 86.31,50.06 86.64,50.39 86.64,51.55 86.88,51.79 90.15,51.79
GND on BOTTOM (solid shape): 209.41,171.07 209.41,169.46 209.59,169.28 209.76,169.28 209.86,169.19 209.86,167.45 210.27,167.04 213.9,167.04 213.94,167 213.94,166.48 213.9,166.44 213.82,166.44 213.82,166.44 212.18,166.44 212.05,166.31 212.05,165.22 211.95,165.12 211.57,165.12 211.06,164.61 210.41,164.61 209.94,164.14 209.5,164.14 209.22,164.42 209.22,164.9 209.05,165.08 208.05,165.08 207.84,165.29 207.84,171.01 208.05,171.22 209.26,171.22
GND on BOTTOM (solid shape): 150.49,177.33 150.49,172.26 150.48,172.26 150.48,170.61 150.61,170.48 151.38,170.48 151.42,170.43 151.42,170.3 151.38,170.25 150.69,170.25 150.68,170.25 150.59,170.25 150.48,170.14 150.48,168.96 150.56,168.88 150.74,168.88 150.74,168.88 151.46,168.88 151.59,168.75 151.59,168.06 151.39,167.85 150.23,167.85 150.17,167.91 150.17,168.65 150.18,168.66 150.18,168.8 150.11,168.87 148.57,168.87 148.57,168.88 148.51,168.94 148.51,171.94 148.51,171.94 148.51,172.76 146.02,175.25 146.02,175.64 145.69,175.96 145.69,176.9 146.26,177.47 150.34,177.47
GND on BOTTOM (solid shape): 76.47,65.19 76.47,64.84 76.19,64.56 76.19,62.76 76.57,62.38 76.57,59.53 75.9,58.87 75.9,57.5 76.04,57.37 76.04,56.42 75.93,56.31 74.83,56.31 74.6,56.53 74.6,56.64 74.44,56.8 74.44,59.83 73.75,60.52 73.75,61.51 73.83,61.59 73.83,61.88 72.2,63.51 71.46,63.51 70.87,64.09 70.87,64.12 70.72,64.28 70.72,64.98 70.86,65.12 70.86,65.3 70.87,65.31 70.87,65.97 71.03,66.12 75.54,66.12
GND on BOTTOM (solid shape): 67.39,96.98 67.57,96.93 67.75,96.98 68.28,96.98 68.43,96.83 68.43,96.42 68.7,96.14 71.15,96.14 71.39,96.38 74.58,96.38 74.77,96.19 74.76,96.17 74.76,95.44 74.61,95.29 74.3,95.29 73.44,94.43 73.2,94.19 73.2,92.43 72.8,92.04 71.04,92.04 69.98,90.97 69.98,86.72 69.41,86.16 66.99,86.16 66.13,87.02 66.13,88.59 67.05,89.51 67.05,96.92 67.11,96.98
GND on BOTTOM (solid shape): 99.93,169.23 99.93,167.08 101.47,165.54 101.47,164.62 101.32,164.47 100.44,164.47 100.07,164.84 99.51,164.84 98.6,163.93 98.6,162.78 98.42,162.6 93.98,162.6 93.76,162.81 93.76,163.86 93.58,164.04 93.2,164.04 92.47,164.77 88.65,164.77 88.35,165.07 88.35,165.91 89.54,167.1 89.54,167.62 89.77,167.85 92.91,167.85 93.03,167.98 93.03,169.01 93.28,169.25 97.71,169.25 97.96,169 97.96,168.16 98.16,167.95 98.36,167.95 98.41,167.95 98.57,167.95 98.85,168.23 98.85,169.26 98.95,169.35 99.81,169.35
GND on BOTTOM (solid shape): 285.28,100.49 285.6,100.81 285.92,100.49 285.92,99.95 285.94,99.92 285.94,97.79 285.92,97.77 285.92,96.12 286.15,96.12 286.15,96.12 291.01,96.12 291.03,96.15 297.56,96.15 297.6,96.12 297.92,96.12 297.92,95.8 297.92,95.79 297.92,94.45 297.92,94.44 297.81,94.19 297.56,94.09 297.49,94.01 295.17,94.01 294.9,93.92 294.64,93.78 294.02,93.16 293.9,92.94 293.81,92.7 293.81,91.5 293.88,91.32 293.96,91.14 294.46,90.65 294.46,90.55 295.04,90.23 295.7,90.12 297.55,90.12 297.81,90.01 297.92,89.75 297.92,88.69 297.28,88.69 297.28,89.48 295.7,89.48 294.82,89.63 294.04,90.08 292.16,90.08 291.55,89.47 288.14,89.47 286.01,91.6 286.01,95.24 285.77,95.48 285.28,95.48 285.28,97.08 284.89,97.47 283.55,97.47 283.13,97.89 283.13,100.05 283.31,100.23 285.28,100.23
GND on BOTTOM (solid shape): outline of 219 points within 285.06,37.89 299.46,52.29
GND on BOTTOM (solid shape): outline of 315 points within 279.39,15.89 297.92,28.11
GND on BOTTOM (solid shape): outline of 466 points within 281.17,55.55 298.27,69.97
GND on BOTTOM (solid shape): outline of 533 points within 175.31,111.58 298.54,177.37
GND on BOTTOM (solid shape): outline of 766 points within 181.68,0.63 298.42,78.66
GND on BOTTOM (solid shape): outline of 1345 points within 0.64,45.14 161.21,177.37
GND on GND1 (solid shape): outline of 134762 points within 0.51,0.51 299.59,177.49
GND on IN1 (solid shape): 181.36,170.88 181.36,169.65 181.21,169.5 179.95,169.5 179.81,169.65 179.81,170.9 179.95,171.05 181.19,171.05
GND on IN1 (solid shape): 174.85,176.73 172.18,176.73 171.97,176.53 169.5,176.53 169.46,176.49 164.45,176.49 164.2,176.73 161.66,176.73 161.66,177.37 174.85,177.37
GND on IN1 (solid shape): 101.23,166.42 101.23,164.91 100.9,164.58 100.32,164.58 100.03,164.88 99.43,164.88 99.22,164.67 99.22,164.25 98.61,163.64 94.24,163.64 93.59,164.28 88.62,164.28 88.3,164.61 88.3,166.36 89.83,167.89 98.61,167.89 98.91,168.18 99.46,168.18
GND on IN1 (solid shape): 297.36,95.5 297.36,94.95 297.01,94.6 296.23,94.6 295.7,94.65 295.17,94.6 294.14,94.6 293.3,93.76 293.3,92.97 293.15,92.1 293.3,91.23 293.3,90.18 293.02,89.9 287.18,89.9 286.24,90.84 286.24,96.11 296.76,96.11
GND on IN1 (solid shape): 285.28,100.49 285.6,100.81 285.92,100.49 285.92,96.12 297.92,96.12 297.92,94.45 297.81,94.19 297.55,94.09 295.7,94.09 293.72,92.1 295.7,90.12 297.55,90.12 297.81,90.01 297.92,89.75 297.92,88.04 295.89,88.04 295.57,88.35 295.89,88.67 297.28,88.67 297.28,89.48 295.7,89.48 293.08,92.1 295.7,94.72 297.28,94.72 297.28,95.48 285.28,95.48 285.28,97.53 283.53,97.53 282.97,98.09 282.97,99.31 283.66,100 284.95,100 285.28,100.33
GND on IN1 (solid shape): outline of 264 points within 283.71,37.89 299.46,69.97
GND on IN1 (solid shape): outline of 81 points within 175.31,108.31 298.42,177.37
GND on IN1 (solid shape): outline of 94 points within 196.38,0.63 298.42,73.96
GND on IN1 (solid shape): outline of 164 points within 0.64,45.14 161.21,177.37
GND on IN2 (solid shape): 174.85,176.73 172.28,176.73 171.31,175.76 165.14,175.76 164.18,176.73 161.66,176.73 161.66,177.37 174.85,177.37
GND on IN2 (solid shape): 181.35,170.95 181.35,169.62 181.24,169.5 179.97,169.5 179.81,169.66 179.81,170.81 180.05,171.06 181.25,171.06
GND on IN2 (solid shape): 101.48,167.63 101.48,165.08 101.03,164.63 100.23,164.63 99.99,164.88 99.43,164.88 99.13,164.58 99.13,164.22 98.93,164.02 93.91,164.02 93.62,164.32 89.41,164.32 88.7,165.04 88.7,166.74 89.85,167.9 98.65,167.9 98.95,168.2 100.91,168.2
GND on IN2 (solid shape): 285.28,100.49 285.6,100.81 285.92,100.49 285.92,96.12 297.92,96.12 297.92,94.45 297.81,94.19 297.55,94.09 295.7,94.09 293.72,92.1 295.7,90.12 297.55,90.12 297.81,90.01 297.92,89.75 297.92,88.04 295.89,88.04 295.57,88.35 295.89,88.67 297.28,88.67 297.28,89.48 295.7,89.48 295.07,89.56 294.47,89.78 288.13,89.78 283.08,94.84 283.08,99.74 283.82,100.49
GND on IN2 (solid shape): outline of 86 points within 175.31,108.32 298.42,177.37
GND on IN2 (solid shape): outline of 96 points within 196.38,0.63 298.42,73.96
GND on IN2 (solid shape): outline of 159 points within 0.64,45.14 161.21,177.37
GND on VCC (solid shape): 174.85,176.73 172.2,176.73 172,176.53 169.51,176.53 169.49,176.5 164.59,176.5 164.36,176.73 161.66,176.73 161.66,177.37 174.85,177.37
GND on VCC (solid shape): outline of 147 points within 284.73,40.31 299.57,51.99
GND on VCC (solid shape): 285.39,100.73 285.73,100.78 285.92,100.49 285.92,96.12 297.92,96.12 297.92,94.45 297.81,94.19 297.55,94.09 295.7,94.09 293.72,92.1 295.7,90.12 297.55,90.12 297.81,90.01 297.92,89.75 297.92,88.04 297.55,88.04 297.55,88.95 297.53,88.95 297.28,89.2 297.28,89.48 297.17,89.48 296.94,89.71 294.63,89.71 293.14,92.65 295.7,94.72 297.28,94.72 297.28,95.48 285.28,95.48 285.28,97.2 285.03,97.46 283.71,97.46 282.95,98.22 282.95,99.74 283.96,100.76 284.85,100.76 284.88,100.73
GND on VCC (solid shape): 287.66,28 287.63,27.56 287.31,26.3 288.37,25.57 297.29,25.57 297.92,24.94 297.92,19.06 297.29,18.44 288.37,18.44 287.31,17.7 287.63,16.44 287.66,16 287.21,15.96 286.71,17.92 288.37,19.07 297.02,19.07 297.28,19.33 297.28,24.67 297.02,24.93 288.37,24.93 286.71,26.08 287.21,28.04
GND on VCC (solid shape): outline of 82 points within 175.31,108.33 298.42,177.37
GND on VCC (solid shape): outline of 105 points within 196.38,0.63 298.42,74.09
GND on VCC (solid shape): outline of 162 points within 0.64,45.14 161.21,177.37
GND on IN3 (solid shape): 181.35,170.93 181.35,169.62 181.23,169.5 179.93,169.5 179.81,169.62 179.81,170.93 179.94,171.06 181.22,171.06
GND on IN3 (solid shape): 174.85,176.73 171.75,176.73 171.52,176.5 169.46,176.5 169.42,176.46 164.52,176.46 164.25,176.73 161.66,176.73 161.66,177.37 174.85,177.37
GND on IN3 (solid shape): 285.28,100.49 285.6,100.81 285.92,100.49 285.92,96.12 297.92,96.12 297.92,94.45 297.81,94.19 297.55,94.09 295.7,94.09 293.72,92.1 295.7,90.12 297.55,90.12 297.81,90.01 297.92,89.75 297.92,88.04 295.89,88.04 295.57,88.35 295.89,88.67 297.28,88.67 297.28,89.48 295.7,89.48 295.1,89.55 294.52,89.76 288.03,89.76 283.08,94.71 283.08,99.74 283.84,100.5 284.22,100.5 284.23,100.49
GND on IN3 (solid shape): outline of 146 points within 281.04,56.74 298.27,69.97
GND on IN3 (solid shape): outline of 191 points within 83.56,159.05 98.14,171.37
GND on IN3 (solid shape): outline of 218 points within 284.96,15.74 297.92,28.11
GND on IN3 (solid shape): outline of 223 points within 284.78,37.89 299.46,52.29
GND on IN3 (solid shape): outline of 102 points within 196.38,0.63 298.42,73.96
GND on IN3 (solid shape): outline of 575 points within 175.31,108.3 298.42,177.37
GND on IN3 (solid shape): outline of 172 points within 0.64,45.14 161.21,177.37
GND on GND2 (solid shape): outline of 135855 points within 0.51,0.51 299.59,177.49
GND on TOP: 85.71,50.2 98.91,50.2 99.3,49.82 99.3,48.18 99.05,47.94 99.05,47.93 85.2,47.93 85.07,48.05 85.07,48.29 85.33,48.55 85.33,49.82
GND on TOP: 257.29,100 254.88,102.41 251.2,102.41 250.18,103.42 245.36,103.42 244.72,104.06 244.72,110.54 245.48,111.3 259.33,111.3 260.09,112.06 260.09,116.25 258.82,117.52 251.83,117.52 251.58,117.78 251.58,120.06 251.83,120.32 257.17,120.32 259.2,118.28 261.49,118.28 266.06,113.71 266.06,110.03 266.44,109.65 267.45,109.65 267.71,109.9 268.34,109.9 269.49,108.76 269.49,105.08 272.03,102.54 275.84,102.54 276.6,101.77 276.6,100.38 276.22,100
GND on TOP: 118.53,103.78 119.5,102.81 119.5,94.25 118.94,93.7 115.46,93.7 115.08,94.08 115.08,96.95 114.52,97.51 112.54,97.51 111.88,98.17 111.6,98.17 111.6,100.38 111.83,100.6 111.83,102.76 112.54,103.48 112.54,103.63 112.62,103.7 113.43,103.7 113.53,103.6 113.53,102.81 113.43,102.71 113.18,102.71 112.97,102.51 112.97,101.52 113,101.49 114.95,101.49 115.08,101.62 115.08,106.47 116.35,107.74 118.23,107.74 118.53,107.44
GND on TOP: 184.03,68.51 184.01,68.53 174.7,68.53 172.22,71.01 172.22,71.81 171.69,71.81 171.3,72.19 171.3,74.99 172.24,75.93 173.46,75.93 174.15,75.24 185.61,75.24 185.63,75.22 185.99,75.22 186.65,74.56 186.65,69.98 185.17,68.51
GND on TOP: 232.02,129.33 233.29,129.33 233.67,128.95 248.15,128.95 248.66,128.44 248.66,124.13 244.09,119.55 240.4,119.55 235.83,124.13 232.02,124.13 231.51,124.63 231.51,128.82
GND on TOP: 144.2,69.5 145.4,69.5 145.9,68.99 145.9,68 146.31,67.6 147.91,67.6 150.04,69.73 167.29,69.73 167.6,69.43 167.6,68.1 165.92,66.43 165.72,66.43 165.49,66.2 144.43,66.2 143.91,66.72 143.91,69.21
GND on TOP: 99.94,48.05 132.83,48.05 133.47,48.69 133.47,55.67 133.22,55.93 128.01,55.93 125.85,58.09 125.85,61.64 125.47,62.02 117.65,62.02 115.61,64.05 100.96,64.05 98.54,66.47 90.67,66.47 90.16,65.96 90.16,62.78 89.65,62.28 80.26,62.28 76.45,58.47 76.45,54.66 77.46,53.64 80.38,53.64 80.64,53.89 80.64,55.55 81.02,55.93 85.34,55.93 85.59,55.67 85.59,53.39 85.84,53.13 87.75,53.13 89.02,51.86 91.56,51.86 91.81,51.61 91.81,50.59 91.94,50.47 99.05,50.47 99.69,49.83 99.69,48.31
GND on TOP: 66.57,170.55 66.57,168.19 67.08,167.69 71.24,167.69 71.99,168.43 71.99,172.25 71.23,173 66.4,173 65.51,172.12 65.51,171.61
GND on TOP: 136.14,135.89 136.82,135.89 137.08,135.63 137.08,131.86 136.86,131.64 133.93,131.64 133.7,131.42 127.7,131.42 127.55,131.57 127.55,132.13 127.63,132.2 133.52,132.2 134.33,133.02 134.33,134.82 134.36,134.84 134.82,134.84 135.04,135.07 135.04,135.28 135.25,135.48 135.73,135.48
GND on TOP: 140.32,156.62 143.76,156.62 144,156.38 144.01,156.38 144.01,155.36 143.49,154.85 143.25,154.6 142.87,154.6 141.6,153.34 141.6,152.31 141.34,152.05 140.32,152.05 140.31,152.05 139.58,152.05 139.31,152.32 139.31,154.24 140.06,154.99 140.06,156.37
GND on TOP: 186.96,168.27 195.22,168.27 197.58,165.91 204.28,165.91 204.67,165.53 204.67,162.5 204.44,162.28 198.32,162.28 197.66,161.62 197.66,160.07 198.47,159.25 198.47,158.42 198.27,158.21 191.81,158.21 189.78,160.24 187.65,160.24 186.73,161.16 186.73,168.04
GND on TOP: 127.24,161.7 130.41,161.7 130.54,161.58 130.54,161.32 131.3,161.32 131.43,161.2 131.43,160.94 131.3,160.81 130.66,160.81 130.54,160.69 130.54,157.02 130.17,157.02 130.16,157.03 130.16,157.77 130.03,157.89 127.24,157.89 127.11,157.77 127.11,157.04 127.12,157.03 127.12,156.28 126.26,155.42 123.51,155.42 123.44,155.49 123.44,156.28 123.92,156.76 125.6,156.76 126.79,157.96 126.79,161.67 126.73,161.73 126.73,162.47 126.85,162.59 126.98,162.59 127.11,162.47 127.11,161.83
GND on TOP: 99.3,82.96 100.82,82.96 101.07,82.71 101.07,75.6 100.82,75.34 97.26,75.34 96.88,75.72 96.88,80.55
GND on TOP: 225.56,121.63 226.19,122.26 235.15,122.26 242.44,114.97 242.44,102.03 241.55,101.14 230.75,101.14 228.08,103.81 225.16,103.81 224.27,104.69 224.27,107.23 221.86,109.65 221.86,112.82 220.72,113.97 220.72,116.12 221.61,117.01 225.04,117.01 225.56,117.54
GND on TOP: 114.92,119.29 115.3,118.9 115.4,118.9 115.65,118.65 116.85,118.65 116.95,118.55 116.95,118.27 116.69,118.02 113.65,118.02 113.39,118.27 112.88,118.27 112.5,118.65 112.5,119.34 112.69,119.53 113.51,119.53 113.75,119.29
GND on TOP: 84.37,136.85 86.61,136.85 86.86,137.1 86.86,138.53 86.73,138.65 85.57,138.65 85.08,138.17 85.08,137.89 84.98,137.79 84.35,137.79 84.24,137.69 84.24,136.98
GND on TOP: 92.31,114.08 97.39,114.08 97.9,113.57 98.66,113.57 98.79,113.7 99.8,113.7 99.8,113.19 99.68,113.06 97.77,113.06 97.39,112.68 97.39,112.33 97.42,112.33 97.77,111.97 97.77,110.58 97.59,110.4 93.33,110.4 93.2,110.52 93.2,111.67 92.95,111.92 92.95,112.43 92.18,113.19 92.18,113.95
GND on TOP: 9.64,155.88 10.66,154.86 10.66,141.14 9.26,139.75 9.26,134.29 8.88,133.9 2.15,133.9 1.64,134.41 1.64,163.75 1.65,163.76 1.65,164.13 1.88,164.36 9.15,164.36 9.64,163.87
GND on TOP: 164.13,156.43 172.8,156.43 173.65,157.28 173.65,162.01 173.2,162.45 164.15,162.45 163.95,162.25 163.95,156.61
GND on TOP: 124.62,147.1 127.03,147.1 127.67,146.46 127.67,141.92 127.2,141.45 124.55,141.45 124.11,141.89 124.11,143.03 124.24,143.16 124.62,143.16 124.75,143.03 124.75,142.4 124.87,142.27 127.03,142.27 127.16,142.4 127.16,146.21 127.03,146.34 124.87,146.34 124.75,146.21 124.75,145.7 124.62,145.57 124.24,145.57 124.11,145.7 124.11,146.59
GND on TOP: 51.12,125.7 51.94,124.89 51.94,124.38 52.32,124 52.32,123.59 49.4,120.67 48.53,120.67 47.44,121.76 47.44,122.17 49.47,124.2 49.47,124.33 50.84,125.7
GND on TOP: 171.94,122.71 171.94,115.22 172.19,114.97 173.08,114.97 173.34,115.22 173.34,117.9 173.2,118.04 173.2,119.2 173.21,119.2 173.34,119.32 173.34,122.71 173.21,122.84 172.07,122.84
GND on TOP: 101.21,129.71 103.12,129.71 103.95,128.88 103.95,127.1 103.83,126.97 103.73,126.97 103.55,126.79 103.55,126.41 103.45,126.31 102.86,126.31 102.76,126.41 102.61,126.41 102.6,126.42 101.81,126.42 101.41,126.82 101.41,127.61 100.96,128.06 100.96,129.46
GND on TOP: 110.09,118.27 111.11,118.27 111.14,118.23 111.14,113.1 110.98,112.94 110.09,112.94 109.96,113.06 109.96,113.7 109.96,113.7 109.96,114.41 109.85,114.52 107.28,114.52 107.17,114.41 107.17,112.94 107.04,112.81 106.03,112.81 105.9,112.94 105.9,118.02 106.15,118.27 107.17,118.27 107.3,118.14 107.3,117.38 107.68,117 109.2,117 109.33,117.13 109.84,117.13 109.96,117.25 109.96,118.14 ; 1 cut-out
GND on TOP: 152.14,97.84 157.85,97.84 158.49,97.2 158.49,91.36 158.11,90.98 139.44,90.98 132.2,98.22 124.71,98.22 124.58,98.34 124.58,99.11 124.83,99.36 126.74,99.36 126.99,99.61 126.99,100.38 126.74,100.63 126.74,101.65 126.99,101.9 138.68,101.9 146.8,110.03 149.47,110.03 149.85,109.65 149.85,100.12
GND on TOP: 74.77,121.95 74.53,121.95 74.28,121.7 74.28,120.81 74.15,120.68 72.98,120.68 72.81,120.85 72.81,121.51 73.39,122.08 75.81,124.5 76.45,124.5 76.5,124.51 76.57,124.43 76.57,123.77 75.58,122.78 75.15,122.78 75.08,122.7 75.08,122.26
GND on TOP: 150.52,153.69 150.52,152.11 150.63,152 154.91,152 155.03,152.11 155.03,153.59 154.84,153.78 150.6,153.78
GND on TOP: 62.21,113.07 62.71,113.57 62.72,113.57 62.97,113.82 64.37,113.82 64.5,113.7 64.5,112.94 63.35,111.79 63.35,109.66 62.91,109.22 58.72,109.22 58.16,109.77 58.16,109.9 58.2,109.9 58.58,110.28 58.58,111.89 59.28,112.59 59.28,112.88 59.77,113.38 60.35,113.38 60.66,113.07
GND on TOP: 172.83,129.7 174.73,129.7 174.86,129.57 174.86,128.43 174.73,128.3 174.73,124.5 174.49,124.25 173.2,124.25 172.7,124.75 172.07,124.75 171.94,124.87 171.94,126.91 172.07,127.03 172.57,127.03 172.7,127.16 172.7,129.57
