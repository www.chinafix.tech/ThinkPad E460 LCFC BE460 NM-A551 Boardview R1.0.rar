# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPP_C2: length 15.4
  TOP w0.076: 106.1,136.61 106.1,136.53 106.46,136.18 106.46,135.44 106.86,135.03 106.86,132.41 v2(107.23,132.05)
  TOP w0.114: RC307.1 106.92,141.87 106.3,141.26 105.01,141.26 ; RC306.1 104.38,142.58 104.38,142.21 v1(104.56,142.02) 104.56,141.7 105.01,141.26 ; 105.01,141.26 105.01,138.72 105.26,138.46 105.26,137.45 106.1,136.61
  BOTTOM w0.076: UC1.R10 v2(107.23,132.05)
GPP_C5: length 8.1
  TOP w0.114: RC84.2 RC83.2 105.26,142.58 v2(105.26,142.02)
  BOTTOM w0.076: 108.69,138.57 108.86,138.41 108.86,137.4 108.93,137.33 UC1.W1
  BOTTOM w0.114: v2(105.26,142.02) 105.26,142 v4(107.33,139.94) 108.69,138.57
GPP_E0: length 12.1
  TOP w0.114: RC388.2 v1(101.62,145.54)
  IN1 w0.14: v1(101.62,145.54) 102.18,145.54 102.99,144.72 102.99,141.19 v1(103.4,140.79)
  BOTTOM w0.114: v1(103.4,140.79) 102.58,139.97 102.58,139.47 102.84,139.21 102.84,137.49 103.27,137.05 103.27,136.4 UC1.H2
GPU_VR_HOT#: length 234.2
  TOP w0.114: v1(199,114.78) 199,114.68 v4(198.11,113.79) 196.74,113.79 RE9.1 195.5,115.03 195.5,115.5 194.56,116.44 194.56,116.91 194.3,117.17 UE1.66 ; v1(47.28,174.45) 47.48,174.45 RV113.1 47.62,175.58 47.62,175.86 47.48,176 RV114.1
  IN1 w0.14: v1(194.49,154.8) 194.35,154.94 194.35,175.76 193.82,176.3 v1(193.52,176.3)
  IN3 w0.114: v1(199,114.78) 198.49,114.27 197.99,114.27 197.52,114.74 197.52,121.09 198.45,122.02 198.45,123.63 200.22,125.39 200.22,128.01 199.58,128.65 199.58,136.31 193.17,142.72 193.17,144.5 195.22,146.55 195.22,150.88 195.11,151 195.11,154.18 v1(194.49,154.8) ; 63.98,171.85 63.98,171.47 62.86,170.35 59.53,170.35 57.33,172.55 55.1,172.55 52.86,174.79 47.79,174.79 47.45,174.45 v1(47.28,174.45)
  IN3 w0.14: v1(193.52,176.3) 193.41,176.2 172.2,176.2 171.57,175.56 165.47,175.56 164.97,176.07 125.85,176.07 v1(124.06,174.28) 121.89,176.45 89.91,176.45 87.17,173.71 82.34,173.71 81.65,173.02 65.14,173.02 63.98,171.85
  BOTTOM w0.254: PR610.1 123.13,175.05 123.91,174.28 v1(124.06,174.28)
GREEN_LED: length 14.4
  TOP w0.114: v4(285.29,83.76) 285.3,83.76 RL16.2
  TOP w0.254: RL16.2 v1(286.34,84.87)
  IN1 w0.254: v1(286.34,84.87) 286.34,74.89 286.9,74.32 JRJ451.9
GSENSE_INT: length 3.8
  TOP w0.114: RG2.2 177.08,105.81 177.08,106.32 v4(177.46,106.7) 177.61,106.85 UGSEN1.11
GSENSE_INT2: length 3.7
  TOP w0.114: TG1.1 176.09,105.89 178.05,107.85 UGSEN1.9
H_CPUPWRGD: length 8.9
  BOTTOM w0.076: 98.39,97.87 98.71,98.2 UC1.A68
  BOTTOM w0.114: T59.1 92.06,95.16 93.87,96.96 97.25,96.96 98.16,97.87 98.39,97.87
H_HDMI_TX0+: length 179.9
  TOP w0.114: CRE1.1 239.98,86.31 239.82,86.31 v1(239.61,86.52)
  IN3 w0.114: v1(96.37,108.01) 96.16,107.81 96.16,107.61 95.89,107.34 95.47,107.34 95.19,107.06 95.19,106.75 95.87,106.07 95.87,101.99 96.83,101.03 96.83,97.14 98.99,94.98 98.99,93.94 101.76,91.16 101.76,84.43 105.19,81 105.19,80.46 110.59,75.05 125.96,75.05 126.64,74.37 141.32,74.37 142.01,75.06 164.22,75.06 169.31,80.15 183.11,80.15 189.26,86.3 233.82,86.3 234.35,85.77 238.47,85.77 239.06,86.36 239.44,86.36 v1(239.61,86.52)
  BOTTOM w0.076: UC1.B50 99.19,108.76 98.94,108.51 98.53,108.51 98.39,108.65 96.37,108.65 96.1,108.38 96.1,108.28 v1(96.37,108.01)
H_HDMI_TX0-: length 179.9
  TOP w0.114: CRE3.1 240.32,85.96 240.2,86.08 239.8,86.08 v1(239.61,85.88)
  IN3 w0.114: v1(239.61,85.88) 239.34,86.15 239.14,86.15 238.56,85.57 234.26,85.57 233.73,86.1 189.35,86.1 183.2,79.95 169.39,79.95 164.3,74.85 142.09,74.85 141.4,74.16 126.56,74.16 125.87,74.85 110.51,74.85 104.99,80.37 104.99,80.92 101.56,84.35 101.56,91.08 98.79,93.85 98.79,94.89 96.63,97.05 96.63,100.94 95.66,101.91 95.66,105.99 94.98,106.66 94.98,107.14 95.39,107.55 95.81,107.55 95.96,107.69 95.96,107.69 95.96,107.79 v1(95.73,108.01)
  BOTTOM w0.076: v1(95.73,108.01) 95.94,108.22 95.94,108.45 96.3,108.81 98.46,108.81 98.6,108.68 98.7,108.68 UC1.A50
H_HDMI_TX1+: length 177.1
  TOP w0.114: v1(236.79,87.27) 236.96,87.1 237.12,87.1 238.1,88.09 240.18,88.09 240.32,88.22 CRE5.1
  IN3 w0.114: v1(236.79,87.27) 236.58,87.07 235.35,87.07 235.29,87.13 188.92,87.13 182.99,81.2 169.19,81.2 163.88,75.88 141.67,75.88 140.98,75.19 126.99,75.19 126.3,75.88 110.93,75.88 106.18,80.63 106.18,81.3 103.86,83.62 103.86,88.94 102.6,90.2 102.6,91.6 99.83,94.37 99.83,95.97 97.66,98.14 97.66,101.39 96.76,102.29 96.76,104.44 97.91,105.6 97.91,106.18 97.4,106.7 97.4,106.83 v2(97.47,106.9)
  BOTTOM w0.076: v2(97.47,106.9) 97.28,107.09 97.28,107.16 97.4,107.28 98.49,107.28 98.56,107.2 98.92,107.2 99.02,107.24 99.21,107.24 99.3,107.2 99.55,107.2 100.03,107.34 100.15,107.34 100.41,107.42 UC1.D52
H_HDMI_TX1-: length 177
  TOP w0.114: CRE7.1 239.99,87.86 v1(238.92,87.86) 238.2,87.86 237.21,86.87 237.02,86.87 v1(236.79,86.63)
  IN3 w0.114: v2(96.89,106.92) 97.71,106.1 97.71,105.68 96.55,104.53 96.55,102.21 97.46,101.3 97.46,98.05 99.63,95.88 99.63,94.28 102.39,91.51 102.39,90.12 103.66,88.85 103.66,83.54 105.98,81.22 105.98,80.54 110.85,75.68 126.21,75.68 126.9,74.99 141.06,74.99 141.75,75.68 163.96,75.68 169.27,80.99 183.08,80.99 189.01,86.92 235.2,86.92 235.26,86.86 236.56,86.86 v1(236.79,86.63)
  BOTTOM w0.076: v2(96.89,106.92) 97.12,107.16 97.12,107.23 97.33,107.45 98.55,107.45 98.63,107.37 98.9,107.37 99.01,107.43 99.16,107.43 99.35,107.37 99.53,107.37 99.78,107.45 UC1.C52
H_HDMI_TX2+: length 192.4
  TOP w0.114: CRE9.1 240.05,89.94 239.37,89.94 v1(239.26,90.05)
  IN3 w0.114: v1(239.26,90.05) 239.42,89.89 239.9,89.89 240.46,89.32 240.46,85.75 239.45,84.74 233.92,84.74 233.39,85.27 189.69,85.27 178.2,73.78 154.17,73.78 153.93,74.03 142.44,74.03 141.74,73.34 126.22,73.34 126.05,73.51 110.18,73.51 106.27,77.41 106.27,77.92 104,80.19 103.39,80.19 100.73,82.84 100.73,90.64 97.93,93.44 97.32,93.44 95.45,95.31 95.45,100.33 93.9,101.87 93.9,107.9 v1(93.78,108.02)
  BOTTOM w0.076: 95.74,109.17 95.76,109.17 95.79,109.14 98.51,109.14 98.56,109.19 98.93,109.19 98.96,109.18 99.02,109.16 99.21,109.16 99.21,109.16 99.36,109.22 99.8,109.14 100.03,109.24 100.43,109.19 100.63,108.97 100.63,108.87 UC1.D50
  BOTTOM w0.114: v1(93.78,108.02) 93.95,108.19 93.95,108.54 94.57,109.17 95.74,109.17
H_HDMI_TX2-: length 192.4
  TOP w0.114: CRE11.1 240.32,89.45 240.06,89.71 239.54,89.71 239.24,89.4 v1(239.24,89.2)
  IN3 w0.114: v1(239.24,89.2) 239.24,89.41 239.51,89.68 239.81,89.68 240.26,89.24 240.26,85.84 239.37,84.95 234.01,84.95 233.48,85.48 189.61,85.48 178.12,73.98 154.26,73.98 154.01,74.23 142.35,74.23 141.66,73.54 126.3,73.54 126.13,73.71 110.26,73.71 106.48,77.5 106.48,78 104.09,80.39 103.47,80.39 100.94,82.93 100.94,90.72 98.01,93.64 97.4,93.64 95.65,95.4 95.65,100.41 94.1,101.96 94.1,107.71 v1(94.41,108.02)
  BOTTOM w0.076: 95.74,108.94 95.76,108.94 95.79,108.97 98.58,108.97 98.63,109.03 98.9,109.03 99.01,108.97 99.16,108.97 99.4,109.04 99.83,108.96 100.05,109.07 100.35,109.03 100.46,108.9 100.46,108.6 100.35,108.49 100.21,108.49 100.09,108.61 UC1.C50
  BOTTOM w0.114: 95.74,108.94 94.67,108.94 94.18,108.45 94.18,108.2 94.36,108.02 v1(94.41,108.02)
H_HDMI_TXC+: length 177.1
  TOP w0.114: CRE13.1 240.42,84.77 240.42,84.56 240.3,84.45 239.74,84.45 239.05,85.13 v1(239.05,85.33) 239.05,86.59 238.78,86.86 238.31,86.86 238.2,86.98 238.2,87.15 v1(238.37,87.32)
  IN3 w0.114: v1(98.32,108) 98.22,108 98.04,107.81 98.04,107.71 98.23,107.52 98.38,107.52 98.88,107.02 98.88,98.01 100.67,96.23 100.67,94.83 103.65,91.85 103.65,90.42 104.69,89.38 104.69,84.09 112.07,76.71 127.07,76.71 127.76,76.02 140.63,76.02 141.32,76.71 163.53,76.71 168.85,82.02 182.04,82.02 187.98,87.97 237.34,87.97 237.69,87.63 237.69,87.15 237.97,86.86 238.49,86.86 238.6,86.98 238.6,87.21 238.49,87.32 v1(238.37,87.32)
  BOTTOM w0.076: UC1.C51 99.76,108.26 99.69,108.34 99.41,108.34 99.26,108.18 98.4,108.18 98.32,108.11 v1(98.32,108)
H_HDMI_TXC-: length 177
  TOP w0.114: CRE14.1 240.07,84.22 239.64,84.22 238.83,85.04 238.83,86.49 238.68,86.63 238.59,86.63 v1(238.37,86.41)
  IN3 w0.114: v1(238.37,86.41) 238.12,86.66 237.88,86.66 237.48,87.06 237.48,87.54 237.26,87.76 188.07,87.76 182.12,81.82 168.93,81.82 163.62,76.51 141.41,76.51 140.72,75.81 127.68,75.81 126.99,76.51 111.99,76.51 104.48,84.01 104.48,89.3 103.45,90.34 103.45,91.77 100.46,94.75 100.46,96.15 98.68,97.93 98.68,106.93 98.3,107.32 98.15,107.32 97.83,107.63 97.83,107.86 v1(97.69,108)
  BOTTOM w0.076: UC1.D51 100.18,108.2 99.87,108.5 99.34,108.5 99.19,108.35 98.47,108.35 98.44,108.38 98.06,108.38 v1(97.69,108)
H_PECI: length 184
  TOP w0.114: v1(182,135.21) RE1.1 ; v2(97.24,106.03) 97.24,105.77 96.32,104.86 96.32,100.92 94.65,99.24 93.71,99.24 v1(93.28,99.68)
  IN3 w0.114: v1(182,135.21) RE1.1 182.61,133.59 183.76,132.43 183.76,129.46 183.24,128.94 181.59,128.94 180.45,130.08 179.31,130.08 177.76,128.53 177.76,114.78 177.19,114.21 177.19,113.65 177.76,113.08 177.76,111.13 176.68,110.04 176.68,95.17 179.26,92.59 v1(181.74,92.59) ; v1(99.39,78.07) 99.45,78.13 99.92,78.13 100.32,78.53 100.32,80.82 96.21,84.93 94.21,84.93 92.13,87.01 92.13,99.27 92.54,99.68 v1(93.28,99.68)
  BOTTOM w0.076: UC1.A54 98.68,106.18 97.39,106.18 v2(97.24,106.03)
  BOTTOM w0.114: v1(99.39,78.07) 99.42,78.04 100.36,78.04 101.41,79.08 v4(101.85,79.08) 105.4,79.08 105.64,79.32 126.84,79.32 128.05,80.53 160.5,80.53 161.06,81.09 167.18,81.09 175.9,89.81 175.9,91.78 177.34,93.22 181.1,93.22 v1(181.74,92.59)
H_PROCHOT_EC: length 3.5
  TOP w0.114: QE1.2 195.98,123.49 195.26,122.77 UE1.80
H_THERMTRIP#: length 63.3
  IN3 w0.114: v1(54.64,129.55) 54.64,125.84 54.03,125.23 53.67,125.23 53.19,124.75 53.19,118.48 55.61,116.06 55.61,116.06 57.24,114.43 57.72,114.43 58.66,115.37 60.41,115.37 60.99,114.79 61.75,114.79 62.97,116 69.84,116 70.87,114.97 77.09,114.97 78.12,116 80.11,116 83.64,112.47 84.86,112.47 86.92,110.4 86.92,109.2 v1(87.9,108.22)
  BOTTOM w0.114: v1(87.9,108.22) 87.22,107.54 v4(87.19,107.54) 87.19,102.1 RC54.1 ; QV3.1 55.24,129.55 v1(54.64,129.55)
HDA_BCLK: length 3.7
  TOP w0.114: RC364.1 132.2,115.74 132.16,115.7 132.16,115.29 131.94,115.07 RPC2.7 131.94,114.39 131.79,114.24 v4(130.24,114.24)
HDA_BCLK_R: length 23.5
  TOP w0.114: RC364.2 131.82,117.17 131.59,116.94 131.59,115.6 v1(131.72,115.48)
  BOTTOM w0.076: UC1.AY22 120.27,124.91 120.38,124.8 120.5,124.7 120.7,124.63 120.82,124.63 121.05,124.69 121.19,124.69 121.31,124.64 121.8,124.64 122.13,124.97 122.82,124.97 123.42,125.57 124.21,125.57
  BOTTOM w0.114: 124.21,125.57 124.88,125.57 125.16,125.85 129.49,125.85 131.59,123.75 131.59,115.6 v1(131.72,115.48)
HDA_RST#: length 21.7
  TOP w0.114: RPC2.8 131.44,115.03 v1(131.09,115.37)
  BOTTOM w0.076: 124.21,125.25 123.32,125.25 122.88,124.81 122.2,124.81 121.87,124.47 121.27,124.47 121.24,124.49 121.16,124.52 121.04,124.52 120.83,124.46 120.68,124.46 120.52,124.51 120.44,124.51 119.74,124.73 119.74,124.73 119.56,124.91 UC1.AW22
  BOTTOM w0.114: 124.21,125.25 125.17,125.25 125.27,125.34 129.15,125.34 131.09,123.4 v1(131.09,115.37)
HDA_SDOUT: length 29.4
  TOP w0.114: RPC2.6 132.44,114.93 132.6,115.09 v1(132.6,115.48) 133.24,116.12 134.22,116.12 134.58,115.75 135.62,115.75 135.95,115.42 RC302.1 RC299.1 RC21.2 v4(139.61,115.42)
  BOTTOM w0.076: UC1.BB22 121.85,124.91 122.32,125.38 123,125.38 123.52,125.9 124.65,125.9
  BOTTOM w0.114: 124.65,125.9 125.09,126.35 129.84,126.35 132.21,123.98 132.21,115.86 v1(132.6,115.48)
HDA_SYNC: length 61.5
  TOP w0.114: RC367.1 133.98,91.56 v4(136.34,89.2) v1(137.74,87.8) ; v1(133.23,115.45) 132.94,115.16 RPC2.5
  BOTTOM w0.076: UC1.BA22 120.97,124.91 121.24,125.17 121.36,125.17 122.05,125.86 123.14,125.86 123.4,126.12
  BOTTOM w0.114: v1(137.74,87.8) 137.74,87.85 133.98,91.61 133.98,107.82 132.58,109.22 132.58,110.28 133.23,110.93 v1(133.23,115.45) 133.23,115.58 132.46,116.35 132.46,124.08 129.94,126.59 124.96,126.59 124.5,126.12 123.4,126.12
HDD_DETECT#: length 110.5
  TOP w0.114: v1(192.14,122.22) 192.14,122.22 181.99,122.22 181.22,122.98 180.12,122.98 179.53,123.57 UE1.15 176.04,123.57 RE15.2
  IN1 w0.14: v1(195.18,109.38) 196.2,109.38 196.58,109.76 196.58,111.67 196.96,112.05 198.61,112.05 200.46,110.2 208.7,110.2 209.15,110.65 209.15,110.65 v1(209.16,110.66) ; v1(235.69,76.11) 235.69,76.87 225.42,87.14 216.15,87.14 214.11,89.19 v1(213.72,89.19)
  IN3 w0.114: v1(192.14,122.22) 193.77,120.59 193.77,110.79 v1(195.18,109.38) ; JHDD.12 244.62,75.82 243.81,76.63 236.22,76.63 v1(235.69,76.11)
  BOTTOM w0.114: v1(213.72,89.19) 213.21,89.69 v4(213.21,98.1) 213.21,105.29 209.15,109.36 209.15,110.65 v1(209.16,110.66)
HDD_DEVSLP0: length 240.9
  TOP w0.114: v2(103.24,138.25) 102.98,137.98 102.98,137.85 102.07,136.95 92.91,136.95 91.78,138.08 RC88.2
  IN1 w0.14: JHDD.10 242.08,74.36 241.79,74.07 236.84,74.07 236.2,74.71 236.2,76.74 225.53,87.41 216.26,87.41 v1(213.72,89.95) ; v1(198.27,111.25) 198.65,111.25 199.96,109.93 209.07,109.93 209.8,110.66 v1(209.8,110.66)
  IN3 w0.114: v1(198.27,111.25) 198.27,111.5 196.55,113.21 196.55,125.64 199.1,128.19 199.1,136.11 192.51,142.7 192.51,150.36 180.97,161.9 161.41,161.9 160.84,161.32 144.39,161.32 143.57,160.5 126.42,160.5 125.17,159.25 118.89,159.25 114.49,154.85 108.95,154.85 106.71,152.62 106.71,139.53 105.96,138.78 104.64,138.78 104.11,138.25 v2(103.24,138.25)
  BOTTOM w0.076: UC1.J1 103.62,137.86 v2(103.24,138.25)
  BOTTOM w0.114: v1(209.8,110.66) 209.8,109.05 213.72,105.13 v4(213.72,96.3) v1(213.72,89.95)
HDMI_CLK: length 252.3
  TOP w0.076: v2(106.16,133.96) 106.44,133.96 106.52,134.04 106.52,134.79 105.96,135.35 105.96,135.93 105.72,136.18 105.65,136.18
  TOP w0.114: 105.65,136.18 105.62,136.2 105.62,136.2 104.5,137.33 104.5,140.37 102.83,142.04 102.83,142.35 RC277.2 ; v1(240.39,91.55) 240.58,91.36 241.27,91.36 241.42,91.5 244.58,91.5 245.02,91.06 245.02,90.08 245.11,90 URE1.38
  IN3 w0.114: v2(106.16,133.96) 105.59,133.39 105.59,131.98 106.65,130.92 106.65,130.3 107.97,128.98 107.97,128.64 108.87,127.73 110.14,127.73 110.6,127.28 110.6,125.4 111.17,124.83 111.17,122.91 110.67,122.41 110.67,121.29 110.27,120.89 104.58,120.89 103.36,119.67 103.36,109.59 102.69,108.92 99.68,108.92 99.49,108.73 93.49,108.73 92.96,108.2 92.96,101.51 94.53,99.94 94.53,95.06 96.98,92.61 97.59,92.61 99.89,90.31 99.89,82.02 102.95,78.96 104.05,78.96 105.43,77.58 105.43,76.22 109.14,72.51 142.09,72.51 142.78,73.2 153.58,73.2 154.82,71.97 177.55,71.97 190.03,84.45 233.05,84.45 233.58,83.92 239.79,83.92 241.33,85.45 241.33,91.1 241.07,91.36 240.58,91.36 v1(240.39,91.55)
  BOTTOM w0.114: UC1.N7 105.89,133.69 v2(106.16,133.96)
HDMI_CLK_CON: length 76.8
  TOP w0.114: URE1.32 247.51,90.13 247.66,90.28 247.66,90.68 v1(247.25,91.09)
  IN3 w0.14: v1(283.42,51.67) 282.99,52.1 282.99,53.97 279.79,57.17 279.79,71.5 276.13,75.15 273.62,75.15 270.52,78.26 265.86,78.26 262.67,81.44 256.77,81.44 250.94,87.27 249.42,87.27 248.85,87.84 248.85,88.85 248.25,89.45 247.61,89.45 246.79,90.27 246.79,90.82 247.07,91.09 v1(247.25,91.09)
  BOTTOM w0.114: JHDMI.15 289.59,55 289.14,54.54 289.14,53.19 288.73,52.79 287.81,52.79 287.31,53.3 287.31,53.63 287.06,53.87 D2.7 D2.4 283.62,53.87 R4.2 283.01,52.08 v1(283.42,51.67)
HDMI_DAT: length 250.8
  TOP w0.076: 105.72,136.43 105.79,136.36 105.79,136.34 106.13,136 106.13,135.41 106.69,134.86 106.69,133.97 106.16,133.44 v2(106.16,133.32)
  TOP w0.114: RC287.2 103.05,142.4 103.05,142.14 104.73,140.46 104.73,137.42 105.72,136.43 ; URE1.39 244.71,90 244.79,90.08 244.79,90.96 244.48,91.28 v1(243.48,91.28) 241.51,91.28 241.37,91.13 240.61,91.13 v1(240.39,90.91)
  IN3 w0.114: v1(240.39,90.91) 240.64,91.16 240.99,91.16 241.13,91.02 241.13,85.54 239.71,84.12 233.66,84.12 233.13,84.65 189.95,84.65 177.47,72.17 154.91,72.17 153.67,73.41 142.69,73.41 142,72.72 109.22,72.72 105.63,76.3 105.63,77.67 104.13,79.17 103.03,79.17 100.09,82.11 100.09,90.4 97.67,92.82 97.06,92.82 94.73,95.15 94.73,100.02 93.16,101.6 93.16,108.11 93.57,108.53 99.58,108.53 99.77,108.72 102.78,108.72 103.56,109.5 103.56,119.58 104.66,120.68 110.35,120.68 110.88,121.21 110.88,122.33 111.37,122.82 111.37,124.91 110.8,125.48 110.8,127.36 110.23,127.94 108.96,127.94 108.17,128.72 108.17,129.06 106.85,130.38 106.85,131.01 105.79,132.07 105.79,133.2 105.92,133.32 v2(106.16,133.32)
  BOTTOM w0.114: UC1.N8 105.87,133.04 v2(106.16,133.32)
HDMI_DAT_CON: length 69.8
  TOP w0.114: URE1.33 247.11,90.31 v1(247.25,90.46)
  IN3 w0.14: v1(284.72,54.91) 282.95,54.91 280.32,57.54 280.32,71.79 276.42,75.69 273.84,75.69 270.69,78.84 266.14,78.84 263.01,81.98 256.99,81.98 251.16,87.8 250.43,87.8 248.42,89.82 247.89,89.82 v1(247.25,90.46)
  BOTTOM w0.114: JHDMI.16 287.14,54.5 287.02,54.37 D2.6 D2.5 283.87,54.37 283.64,54.13 283.04,54.13 R5.2 283.01,54.85 283.5,55.33 v3(283.8,55.33) 284.3,55.33 v1(284.72,54.91)
HDMI_HPD: length 239.5
  TOP w0.114: URE1.3 242.69,88.03 v1(242.37,88.35)
  IN3 w0.114: v2(104.32,133.94) 104.62,133.65 104.62,132.71 104.85,132.48 104.85,129.99 105.27,129.57 106.81,129.57 107.56,128.81 107.56,126.56 107.79,126.34 109.09,126.34 109.25,126.17 109.25,125.76 109.77,125.24 109.77,122.75 109.64,122.63 104.54,122.63 104.39,122.47 103.7,122.47 102.93,121.7 102.93,110.04 102.64,109.76 100.95,109.76 100.7,110.01 99.88,110.01 98.89,109.02 95.94,109.02 95.62,109.34 93.4,109.34 91.49,107.43 91.49,86.95 94.01,84.44 95.43,84.44 97.4,82.47 97.4,78.77 98.54,77.63 103.8,77.63 104.5,76.93 104.5,76.11 108.59,72.02 142.39,72.02 144.34,70.07 176.77,70.07 190.65,83.95 232.84,83.95 233.37,83.42 240,83.42 241.92,85.34 241.92,87.89 v1(242.37,88.35)
  BOTTOM w0.076: UC1.L7 104.51,133.94 v2(104.32,133.94)
HDMI_HPD_CON: length 65.8
  TOP w0.114: URE1.28 v1(249.41,88.03)
  IN3 w0.14: v1(283.47,52.51) 283.29,52.69 283.29,54.04 280.05,57.28 280.05,71.61 276.24,75.42 273.73,75.42 270.58,78.58 266.03,78.58 262.9,81.71 256.88,81.71 251.05,87.54 249.9,87.54 v1(249.41,88.03)
  BOTTOM w0.114: v1(283.47,52.51) 283.83,52.87 D2.2 D2.8 286,52.87 286.01,52.86 v4(286.38,52.86) 287.15,52.86 287.66,52.36 289.21,52.36 JHDMI.19
HDMI_TX0+_CON: length 18.5
  TOP w0.114: v1(286.34,58.71) 286.34,58.7 286.06,58.43 285.35,58.43 285.19,58.59 D3.9 D3.1 283.05,58.59 283.04,58.59 282.67,58.59 L1.2
  IN1 w0.14: v1(286.34,58.71) 286.58,58.47 287.12,58.47 287.52,58.06 287.52,53.26 287.98,52.8 288.53,52.8 288.94,53.21 288.94,58.32 289.25,58.63 289.48,58.63 JHDMI.7
HDMI_TX0+_REIN: length 2.8
  TOP w0.114: CRE1.2 241.56,86.32 242.09,86.32 242.51,86.74 243.05,86.74 243.14,86.83 URE1.6
HDMI_TX0+_REOUT: length 50.4
  TOP w0.114: L1.1 280.97,58.64 280.11,58.64 279.28,59.47 v1(279.28,64.72) 279.28,68.96 270.71,77.53 266.26,77.53 263.13,80.65 256.15,80.65 252.94,83.87 251.64,83.87 250.49,85.02 250.49,85.93 249.68,86.74 249.19,86.74 249.1,86.83 URE1.25
HDMI_TX0-_CON: length 18.6
  TOP w0.114: L1.3 282.54,58.36 282.95,58.36 282.95,58.36 283.26,58.36 283.53,58.09 D3.2 D3.8 285.14,58.09 285.25,58.2 286.09,58.2 286.34,57.95 v1(286.34,57.94)
  IN1 w0.14: JHDMI.9 289.48,58.37 289.36,58.37 289.2,58.21 289.2,53.11 288.64,52.55 287.88,52.55 287.27,53.16 287.27,57.96 287.01,58.21 286.6,58.21 v1(286.34,57.94)
HDMI_TX0-_REIN: length 2.8
  TOP w0.114: URE1.7 243.14,86.43 243.05,86.51 242.61,86.51 v1(242.42,86.33) 242.18,86.09 241.56,86.09 CRE3.2
HDMI_TX0-_REOUT: length 50.4
  TOP w0.114: URE1.24 249.06,86.43 249.15,86.51 249.59,86.51 250.26,85.84 250.26,84.92 251.54,83.64 252.84,83.64 256.06,80.42 263.04,80.42 266.16,77.3 270.61,77.3 279.05,68.86 v1(279.05,60.4) 279.05,59.37 280.01,58.41 281,58.41 L1.4
HDMI_TX1+_CON: length 5.3
  TOP w0.114: JHDMI.4 287.98,60.18 287.61,60.18 286.95,60.84 286.34,60.84 286.18,61 D11.2 D11.8 284.88,61 284.51,60.64 283.81,60.64 L2.2
HDMI_TX1+_REIN: length 2.8
  TOP w0.114: URE1.4 243.14,87.63 243.05,87.54 242.42,87.54 241.87,88.09 241.56,88.09 CRE5.2
HDMI_TX1+_REOUT: length 50.1
  TOP w0.114: URE1.27 249.08,87.63 249.17,87.54 250,87.54 251.21,86.33 251.21,85.32 251.93,84.6 253.23,84.6 256.45,81.38 263.43,81.38 266.56,78.25 271.01,78.25 280,69.26 280,68.98 v1(280.08,68.9) 280,68.83 280,61.83 281.21,60.63 282.31,60.63 L2.1
HDMI_TX1-_CON: length 5.3
  TOP w0.114: L2.3 283.95,60.41 284.61,60.41 284.7,60.5 D11.9 D11.1 286.2,60.5 286.32,60.61 286.86,60.61 v1(287.08,60.39) 287.52,59.95 287.85,59.95 JHDMI.6
HDMI_TX1-_REIN: length 2.8
  TOP w0.114: URE1.5 243.14,87.23 243.05,87.31 242.32,87.31 241.77,87.87 241.56,87.87 CRE7.2
HDMI_TX1-_REOUT: length 50.1
  TOP w0.114: URE1.26 249.08,87.23 249.17,87.31 249.91,87.31 250.98,86.24 250.98,85.22 251.83,84.37 253.13,84.37 256.36,81.15 263.34,81.15 266.46,78.02 270.91,78.02 279.77,69.16 279.77,61.74 v1(280.42,61.1) 281.12,60.4 282.2,60.4 L2.4
HDMI_TX2+_CON: length 6.9
  TOP w0.114: L3.2 283.78,62.57 284.53,62.57 284.6,62.5 D11.6 D11.5 286.26,62.5 286.43,62.33 v1(288.33,62.33) 288.66,62.33 289.38,61.62 289.47,61.62 JHDMI.1
HDMI_TX2+_REIN: length 3.4
  TOP w0.114: URE1.1 243.25,88.83 243.17,88.74 243.07,88.74 242.92,88.89 242.92,89.55 242.59,89.87 v1(242.29,89.87) 241.56,89.87 CRE9.2
HDMI_TX2+_REOUT: length 48.4
  TOP w0.114: URE1.30 249.08,88.83 249.17,88.74 250.11,88.74 256.75,82.1 263.73,82.1 266.86,78.98 271.31,78.98 280.73,69.56 v1(280.73,66.69) 280.73,63.18 281.27,62.63 282.16,62.63 L3.1
HDMI_TX2-_CON: length 7
  TOP w0.114: JHDMI.3 289.46,61.39 289.28,61.39 288.57,62.1 v1(286.83,62.1) 286.33,62.1 286.24,62 D11.4 D11.7 284.77,62 284.44,62.34 283.72,62.34 L3.3
HDMI_TX2-_REIN: length 3.4
  TOP w0.114: URE1.2 243.25,88.43 243.16,88.51 242.97,88.51 242.69,88.8 242.69,89.45 242.5,89.64 241.56,89.64 CRE11.2
HDMI_TX2-_REOUT: length 48.4
  TOP w0.114: URE1.29 249.08,88.43 249.17,88.51 250.02,88.51 256.66,81.87 263.64,81.87 266.76,78.75 271.21,78.75 280.5,69.46 v1(280.5,63.44) 280.5,63.08 281.18,62.4 282.09,62.4 L3.4
HDMI_TXC+_CON: length 6.3
  TOP w0.114: JHDMI.10 287.96,57.16 v1(287.26,57.16) 287.06,57.16 286.86,56.95 285.2,56.95 285.06,57.09 D3.7 D3.4 283.5,57.09 283.32,56.9 282.59,56.9 L4.2
HDMI_TXC+_REIN: length 3
  TOP w0.114: URE1.9 243.14,85.63 243.05,85.54 242.84,85.54 241.83,84.54 241.56,84.54 CRE13.2
HDMI_TXC+_REOUT: length 51
  TOP w0.114: URE1.22 249.08,85.63 249.17,85.54 249.52,85.54 249.77,85.29 249.77,84.28 252.6,81.45 254.33,81.45 255.85,79.93 262.83,79.93 265.96,76.81 270.41,76.81 278.55,68.66 v1(278.55,62.47) 278.55,58.59 280.21,56.94 281.04,56.94 L4.1
HDMI_TXC-_CON: length 6.3
  TOP w0.114: L4.3 282.63,56.67 283.34,56.67 283.43,56.59 D3.5 D3.6 285.04,56.59 285.17,56.73 v1(285.6,56.73) 286.95,56.73 287.15,56.93 287.87,56.93 JHDMI.12
HDMI_TXC-_REIN: length 3
  TOP w0.114: CRE14.2 241.56,84.31 241.93,84.31 242.93,85.31 243.05,85.31 243.14,85.23 URE1.10
HDMI_TXC-_REOUT: length 51.1
  TOP w0.114: URE1.21 249.06,85.23 249.14,85.31 249.42,85.31 249.54,85.2 249.54,84.19 252.5,81.22 254.23,81.22 255.76,79.7 262.74,79.7 265.86,76.58 270.31,76.58 278.33,68.56 v1(278.33,58.8) 278.33,58.5 280.11,56.71 280.93,56.71 L4.4
HG_1PH: length 2.2
  IN3 w0.762: 70.82,102.09 72.98,102.09
  vias: v1(70.53,102.35) v1(70.52,101.7) v1(73.16,101.45) v1(73.82,101.45)
HG_A1: length 7.5
  IN3 w0.762: 74.33,73.67 72.78,72.12 67.49,72.12
  vias: v1(66.53,72.09) v1(67.19,72.12) v1(74.51,74.12) v1(74.51,73.49)
HG_B1:
  vias: v1(82.61,52.79) v1(82.71,53.42) v4(83.21,52.78)
HGNDA: length 5.1
  TOP w0.381: JU3AC.23 139.66,55.64 139.57,55.55 139.16,55.95 JU3AC.22
  TOP w0.508: v1(180.19,50.45) 180.37,50.27 v4(180.89,50.27) CA30.2 ; v1(179.84,57.16) v1(180.85,57.16)
  vias: v1(139.45,51.8) v1(139.65,51.17) v1(140,50.64) v1(179.97,56.52) v1(180.68,56.42)
HGNDB: length 4.8
  TOP w0.203: 184.38,56.86 183.12,56.86 182.96,56.7 v1(182.96,56.67)
  TOP w0.305: 138.28,55.49 138.16,55.62 JU3AC.20 ; 138.66,55.33 JU3AC.21
  TOP w0.508: CA29.2 182.81,53.4 v1(183.29,53.88)
  vias: v1(137.8,51.19) v1(137.8,50.55) v1(138.49,51.21) v1(138.56,50.53) v1(182.05,57.28) v1(182.05,56.65) v1(182.76,57.28) v3(181.57,56.9)
HP_OUTL: length 17.9
  TOP w0.203: v1(185.34,50.71) 184.77,50.13 CA31.2 183.74,51.04 RA17.1 ; RA16.1 188.07,49.38 v3(188.04,49.36) 187.87,49.19 187.36,49.19 v1(187.1,48.93) ; v1(183.47,59.14) 183.47,58.93 183.95,58.46 UA1.22
  IN1 w0.254: v1(183.47,59.14) 183.47,59.11 184.65,57.94 184.65,51.4 v1(185.34,50.71) 187.1,48.94 v1(187.1,48.93)
HP_OUTL_CON: length 48.2
  TOP w0.254: JU3AC.26 141.4,56.61 141.76,56.24 141.76,52.01 144.21,49.56 159.37,49.56 159.52,49.41 v4(175.75,49.41) 182.29,49.41 183,50.12 RA17.2
HP_OUTR: length 17.9
  TOP w0.203: v1(184.77,49.31) 185.22,48.85 v3(185.4,48.85) 185.48,48.85 186.04,49.41 CA32.2 186.04,50.2 187.13,51.29 RA23.1 187.19,51.29 187.43,51.53 RA22.1 ; v1(182.81,59.04) 182.89,59.04 183.87,58.06 UA1.23
  IN1 w0.254: v1(182.81,59.04) 182.81,59.01 184.14,57.68 184.14,50.45 184.79,49.79 184.79,49.36 184.77,49.33 v1(184.77,49.31)
HP_OUTR_CON: length 53.6
  TOP w0.254: JU3AC.25 140.66,56.16 141.26,55.56 141.26,51.8 144,49.05 159.16,49.05 159.37,48.84 v4(182.95,48.84) 184.14,48.84 184.69,48.29 185.68,48.29 187.18,49.79 RA23.2
I2C_ADDR: length 16.3
  TOP w0.114: v4(271.05,148.23) 270.84,148.01 RM28.2 RM27.1 268.64,148.39 265.34,148.39 v1(264.93,147.99) ; UM1.3 v1(256.78,146.31)
  IN3 w0.114: v1(256.78,146.31) 258.45,147.99 v1(264.93,147.99)
I2C_CLK_GSENSE: length 2.9
  TOP w0.203: QV13.1 183.13,107.11 v4(182.61,107.62) 182.34,107.35 UGSEN1.4
I2C_DATA_GSENSE: length 6.2
  TOP w0.203: QV13.4 185.19,109.36 184.9,109.65 182.72,109.65 v4(182.45,109.37) 181.21,109.37 180.64,108.8 UGSEN1.6
ISEN1: length 8.3
  BOTTOM w0.203: PU601.13 117.89,168.41 118.73,167.57 119.55,167.57 v4(119.71,167.41) 120.82,166.3 PC608.2
  BOTTOM w0.254: PR616.1 123.83,165.08 123.27,165.64 122.13,165.64 121.47,166.3 PC608.2
ISEN2: length 9.1
  BOTTOM w0.203: PC628.2 122.18,166.86 121.11,166.86 120.05,167.93 118.9,167.93 118.29,168.55 PU601.12
  BOTTOM w0.254: PC628.2 124.19,166.28 v4(124.42,166.04) 124.72,165.74 PR632.1
ITP_PMODE: length 15.9
  BOTTOM w0.076: UC1.E8 101.12,132.58 100.95,132.75 100.57,132.75 100.44,132.62 100.31,132.62 100.18,132.75 99.93,132.75 99.8,132.62 99.68,132.62 99,133.29 98.11,133.29 98,133.41
  BOTTOM w0.114: 98,133.41 97.07,133.41 96.06,134.41 v4(94.06,134.41) 93.25,134.41 91.87,133.04 91.33,133.04 90.65,132.36 87.8,132.36 RC354.1
JSENSE: length 9.2
  TOP w0.254: v3(191.95,49) 191.5,48.55 RA18.2 190.76,48.55 190.41,48.89 190.41,49.11 190,49.53 RA21.2 RA20.2 188.74,49.75 188.74,52.02 187.97,52.8 187.97,53.98 188.03,54.03 UA1.38
JSENSE_CON: length 56.9
  TOP w0.254: 140.62,55.28 140.62,55.38 140.16,55.84 JU3AC.24
  TOP w0.508: v1(187.81,48.55) 188.65,48.55 188.71,48.61 RA20.1 RA21.1 ; 140.62,55.28 140.62,51.53 141.13,51.03 v1(141.13,50.32)
  IN3 w0.508: v1(187.81,48.55) 187.56,48.29 184.77,48.29 184,49.05 183.08,49.05 182.48,48.46 142.99,48.46 v1(141.13,50.32)
JTAG_TCK: length 7.9
  BOTTOM w0.114: UV3.L3 50.54,161.21 50.95,161.62 50.95,162.16 50.57,162.54 50.57,163.54 48.29,165.82 TPV9.1 47.99,166.05 47.35,166.68 RV67.1
JTAG_TDI: length 10.3
  BOTTOM w0.114: RV65.2 45.57,166.66 45.31,166.39 TPV8.1 45.84,165.54 47.73,165.54 49.63,163.64 49.63,162.66 50.16,162.13 50.16,160.73 50.54,160.36 UV3.L5
JTAG_TDO: length 10.1
  BOTTOM w0.114: UV3.K4 49.74,160.73 49.3,161.16 49.3,161.95 49.3,161.95 49.3,163.59 47.63,165.26 46.78,165.26 46.5,164.98 TPV11.1 45.66,164.98 44.84,165.81 44.84,166.43 44.69,166.58 RV66.2
JTAG_TMS: length 7.5
  BOTTOM w0.114: RV64.2 46.46,166.35 TPV10.1 47,165.82 47.81,165.82 50.01,163.62 50.01,162.66 50.54,162.13 UV3.L1
JTAG_TRSTB: length 9.4
  BOTTOM w0.114: UV3.L6 50.54,159.53 50.95,159.95 50.95,160.76 51.19,161 51.51,161 51.71,161.2 51.71,163.19 49.8,165.09 TPV7.1 49.8,166.41 RV63.2
KB_FN: length 77.3
  TOP w0.114: RPE1.6 176.3,120.43 176.64,120.77 176.64,121.33 176.88,121.57 UE1.20 179.82,121.57 180.32,121.07 181.09,121.07 182.58,119.57 187.5,119.57 v1(187.7,119.77) ; JKB.29 161.2,73.42 163.64,75.87 v4(164.33,75.87) 164.66,75.87 165.13,76.33 168,76.33 179.05,87.39 179.05,91.9 182.99,95.84 184.78,95.84 187.56,98.62 v1(187.56,100.25)
  IN3 w0.114: v1(187.7,119.77) 187.7,118.79 188.01,118.48 188.01,104.64 186.84,103.47 186.84,100.97 v1(187.56,100.25)
KBRST#: length 134.1
  TOP w0.114: UE1.4 178.74,127.97 178.84,127.86 179.48,127.86 181.15,126.19 183.02,126.19 v1(183.46,126.63) ; RPC22.4 125.47,148.56 125.67,148.36 128.14,148.36 v4(128.62,148.84) v1(129.99,148.84)
  BOTTOM w0.076: 123.08,129.42 121.76,129.42 121.65,129.31 121.28,129.31 121.16,129.36 121.04,129.36 120.83,129.3 120.68,129.3 120.52,129.35 120.44,129.35 119.74,129.57 119.74,129.57 119.56,129.75 UC1.AW13
  BOTTOM w0.114: v1(183.46,126.63) 183.46,126.95 184.05,127.54 184.05,132.52 185.42,133.89 185.42,138.72 184.35,139.8 184.35,149.07 183.34,150.07 183.34,157.94 180.7,160.58 164.96,160.58 164.01,159.63 147.7,159.63 146.56,158.49 138.53,158.49 136.77,156.73 136.77,153.31 133.09,149.63 131.29,149.63 130.81,149.14 130.29,149.14 v1(129.99,148.84) 131.14,147.69 131.14,138.92 130.38,138.16 130.38,134.98 126.52,131.12 124.77,131.12 123.08,129.42
KSI0: length 73
  TOP w0.114: v1(188.45,117.76) 189.14,117.07 189.14,116.36 189.46,116.05 UE1.58 ; v1(188.08,102.38) 187.41,102.38 185.59,100.56 181.91,100.56 v4(181.6,100.25) 180.84,99.49 180.84,98.98 180.4,98.54 179.4,98.54 178.86,98 178.86,97.17 175.19,93.5 175.19,88.99 167.05,80.85 162.96,80.85 160.75,78.64 156.33,78.64 153.17,75.47 153.17,75.06 152.7,74.59 JKB.12
  IN3 w0.114: v1(188.45,117.76) 189.14,117.08 189.14,108.02 188.8,107.68 188.8,104.4 187.57,103.17 187.57,102.77 187.95,102.38 v1(188.08,102.38)
KSI1: length 80.9
  TOP w0.114: JKB.1 147.2,74.23 v4(147.57,74.6) 154.26,81.29 159.65,81.29 162.22,83.86 163.63,83.86 166.14,86.38 168.83,86.38 172.54,90.09 172.54,94.6 176.21,98.27 176.21,99.66 178.21,101.66 179.1,101.66 179.94,102.49 184.79,102.49 189.8,107.5 v1(191.12,107.5) ; UE1.59 189.86,116.02 189.38,116.49 189.38,118.18 v1(189.85,118.65)
  IN3 w0.114: v1(189.85,118.65) 191.2,118.65 192.02,117.83 192.02,112.51 190.92,111.41 190.92,107.7 v1(191.12,107.5)
KSI2: length 72.9
  TOP w0.114: UE1.60 190.26,115.96 189.85,116.37 v1(189.85,117.13) ; v1(188.71,103.04) 188.71,103.34 188.6,103.46 187.81,103.46 185.39,101.04 180.54,101.04 177.9,98.4 177.9,97.57 174.23,93.9 174.23,89.39 167.01,82.18 163.78,82.18 v4(163.57,81.96) 162.7,81.96 160.35,79.6 155.93,79.6 150.7,74.37 JKB.8
  IN3 w0.114: v1(189.85,117.13) 189.62,116.9 189.62,107.82 189.28,107.48 189.28,103.61 v1(188.71,103.04)
KSI3: length 73
  TOP w0.114: JKB.9 151.2,74.53 156.03,79.36 160.45,79.36 162.66,81.57 163.82,81.57 164.03,81.79 v4(165.35,81.79) 166.97,81.79 174.47,89.29 174.47,93.8 178.14,97.47 178.14,98.3 180.64,100.8 185.49,100.8 187.71,103.02 v1(188.08,103.02) ; v1(189.85,117.76) 190.3,117.31 190.3,116.42 190.66,116.06 UE1.61
  IN3 w0.114: v1(188.08,103.02) 188.08,103.32 189.04,104.28 189.04,107.58 189.38,107.92 189.38,117.29 v1(189.85,117.76)
KSI4: length 72.2
  TOP w0.114: JKB.5 149.2,74.2 v4(151.5,76.5) 155.33,80.33 160.05,80.33 162.62,82.9 166.71,82.9 173.5,89.69 173.5,94.2 177.17,97.87 177.17,99.26 178.61,100.69 179.5,100.69 180.34,101.53 185.19,101.53 189.41,105.75 v1(189.72,105.75) ; v1(190.86,116.49) 191.06,116.3 UE1.62
  IN3 w0.114: v1(190.86,116.49) 190.86,112.72 189.95,111.81 189.95,107.71 189.68,107.43 189.68,105.79 v1(189.72,105.75)
KSI5: length 74.3
  TOP w0.114: v1(190.86,117.13) 191.46,116.53 UE1.63 ; v1(190.43,105.63) 189.5,104.69 v4(189.02,104.69) 188.7,104.69 185.29,101.28 180.44,101.28 179.6,100.45 178.71,100.45 177.41,99.16 177.41,97.77 173.74,94.1 173.74,89.59 166.81,82.66 162.72,82.66 160.15,80.09 155.73,80.09 149.7,74.05 JKB.6
  IN3 w0.114: v1(190.43,105.63) 190.43,105.67 189.92,106.19 189.92,107.29 190.2,107.57 190.2,111.71 191.3,112.81 191.3,116.67 190.86,117.11 v1(190.86,117.13)
KSI6: length 79.4
  TOP w0.114: JKB.3 148.2,74.34 154.67,80.81 159.85,80.81 162.42,83.38 166.51,83.38 173.02,89.89 173.02,94.4 176.69,98.07 176.69,99.46 178.41,101.18 179.3,101.18 180.14,102.01 184.99,102.01 189.61,106.62 v1(190.35,106.62) ; IT7.1 191.86,113.87 UE1.64 191.86,116.77 v1(190.86,117.76)
  IN3 w0.114: v1(190.86,117.76) 191.54,117.08 191.54,112.71 190.44,111.61 190.44,106.71 v1(190.35,106.62)
KSI7: length 77.1
  TOP w0.114: JKB.2 147.7,74.18 154.57,81.05 159.75,81.05 162.32,83.62 163.73,83.62 166.24,86.14 168.93,86.14 172.78,89.99 172.78,94.5 176.45,98.17 176.45,99.56 178.31,101.42 179.2,101.42 180.04,102.25 184.89,102.25 189.7,107.06 191.47,107.06 v1(191.88,107.47) ; v1(191.88,111.67) 193.53,111.67 IT6.1 192.39,114.87 192.39,116.49 192.66,116.77 UE1.65
  IN3 w0.114: v1(191.88,107.47) v1(191.88,111.67)
KSO0: length 61.3
  TOP w0.114: v1(178.77,99.9) v4(178.01,99.14) 177.65,98.78 177.65,97.67 173.98,94 173.98,89.49 166.91,82.42 162.82,82.42 160.25,79.85 155.83,79.85 150.2,74.21 JKB.7 ; UE1.36 180.66,114.3 180.99,113.97 v2(180.99,113.64)
  IN3 w0.114: v1(178.77,99.9) 179.43,100.56 179.43,105.68 180.29,106.54 180.29,112.63 180.51,112.85 180.51,113.15 v2(180.99,113.64)
KSO1: length 62.8
  TOP w0.114: UE1.37 181.06,114.34 181.46,113.94 181.46,113.61 v1(181.9,113.17) 182.24,112.84 RPE2.8 ; JKB.11 152.2,74.64 v4(152.78,75.22) 152.78,75.43 156.23,78.88 160.65,78.88 162.86,81.09 166.95,81.09 174.95,89.09 174.95,93.6 178.62,97.27 178.62,98.1 179.3,98.78 180.3,98.78 180.6,99.08 v1(180.6,100.12)
  IN3 w0.114: v1(180.6,100.12) 180.6,100.54 181.8,101.74 181.8,110.55 182.1,110.85 182.1,112.97 v1(181.9,113.17)
KSO2: length 63.5
  TOP w0.114: RPE2.7 182.74,113.03 v1(181.9,113.87) 181.46,114.32 UE1.38 ; JKB.13 153.2,74.54 153.41,74.75 153.41,75.17 v4(154.3,76.05) 154.3,76.26 156.43,78.4 160.85,78.4 163.06,80.61 167.15,80.61 175.43,88.89 175.43,93.4 179.1,97.07 179.1,97.87 179.33,98.1 v1(179.58,98.1)
  IN3 w0.114: v1(179.58,98.1) 180.59,98.1 180.9,98.42 180.9,99.76 181.2,100.05 181.2,100.8 182.04,101.64 182.04,110.45 182.34,110.75 182.34,113.43 v1(181.9,113.87)
KSO3: length 67.7
  TOP w0.114: v1(183.12,117.76) 181.97,117.76 181.59,117.38 181.59,116.36 181.86,116.1 UE1.39 ; JKB.18 155.7,74.22 158.45,76.97 v4(159.5,76.97) 161.12,76.97 163.56,79.4 167.65,79.4 176.64,88.39 176.64,92.9 182.71,98.97 v1(182.71,99.49)
  IN3 w0.114: v1(183.12,117.76) 183.62,117.25 183.62,116.69 185.9,114.41 185.9,113.66 185.15,112.91 185.15,109.93 184.44,109.22 184.44,101.67 183.15,100.38 183.15,99.93 v1(182.71,99.49)
KSO4: length 63.8
  TOP w0.114: UE1.40 182.26,116.34 v1(182.1,116.49) ; JKB.14 153.7,74.91 v4(155.93,77.14) 156.95,78.16 160.95,78.16 163.16,80.37 167.25,80.37 175.67,88.79 175.67,93.3 179.54,97.17 v1(179.54,97.47)
  IN3 w0.114: v1(182.1,116.49) 182.58,116.01 182.58,111.06 182.99,110.65 182.99,110.14 182.28,109.44 182.28,101.54 181.44,100.7 181.44,99.95 181.14,99.66 181.14,98.32 180.54,97.71 179.78,97.71 v1(179.54,97.47)
KSO5: length 66.6
  TOP w0.114: v1(180.11,99.23) 179.41,99.23 178.38,98.2 178.38,97.37 174.71,93.7 174.71,89.19 166.85,81.33 162.76,81.33 160.55,79.12 156.13,79.12 151.63,74.62 v4(151.63,73.83) 151.7,73.76 JKB.10 ; UE1.41 182.66,116.57 v1(182.1,117.13)
  IN3 w0.114: v1(182.1,117.13) 181.46,116.49 181.46,112.76 181.86,112.36 181.86,110.95 181.56,110.65 181.56,109.95 180.77,109.17 180.77,105.99 181.56,105.2 181.56,101.95 180.11,100.5 v1(180.11,99.23)
KSO6: length 63.7
  TOP w0.114: v1(182.71,100.12) 182.71,100.11 182.03,99.43 182.03,98.63 176.4,93 176.4,88.49 167.55,79.64 163.46,79.64 161.17,77.35 157.9,77.35 v4(157.73,77.18) 156.21,75.66 156.21,75.07 155.2,74.06 JKB.17 ; v1(183.12,116.49) 183.06,116.43 UE1.42
  IN3 w0.114: v1(182.71,100.12) 182.71,100.28 184.2,101.77 184.2,109.32 184.91,110.03 184.91,115.06 183.48,116.49 v1(183.12,116.49)
KSO7: length 65.5
  TOP w0.114: v1(183.12,117.13) 183.62,116.62 183.62,116.36 183.46,116.2 UE1.43 ; v1(181.59,99.49) 181.59,99.47 181.14,99.02 181.14,98.43 175.91,93.2 175.91,88.69 167.35,80.13 163.26,80.13 160.97,77.84 157.18,77.84 154.3,74.96 v4(154.3,74.21) 154.2,74.12 JKB.15
  IN3 w0.114: v1(183.12,117.13) 182.59,116.6 182.59,116.34 182.82,116.11 182.82,113.14 184.13,111.84 184.13,110.27 182.52,108.67 182.52,101.44 181.68,100.6 181.68,99.58 v1(181.59,99.49)
KSO8: length 61.7
  TOP w0.114: v1(183.37,113.82) 183.86,114.31 UE1.44 ; v1(181.59,98.85) 181.59,98.54 176.16,93.1 176.16,88.59 167.45,79.88 163.36,79.88 161.07,77.59 157.28,77.59 155.82,76.14 v4(155.82,75.23) 154.7,74.11 JKB.16
  IN3 w0.114: v1(181.59,98.85) 182.03,99.29 182.03,100.6 183.69,102.27 183.69,105.77 182.77,106.69 182.77,108.57 184.37,110.17 184.37,111.94 183.37,112.94 v1(183.37,113.82)
KSO9: length 85.1
  TOP w0.114: v1(191.12,106.62) 190.68,106.19 189.51,106.19 185.09,101.77 180.24,101.77 179.4,100.93 178.51,100.93 176.93,99.36 176.93,97.97 173.26,94.3 173.26,89.79 166.61,83.14 162.52,83.14 159.95,80.57 154.98,80.57 v4(149.47,75.06) 148.7,74.29 JKB.4 ; UE1.45 184.26,115.99 183.88,116.36 183.88,118.02 184.51,118.65 v1(188.45,118.65)
  IN3 w0.114: v1(188.45,118.65) 188.9,118.2 191.31,118.2 191.78,117.73 191.78,112.61 190.68,111.51 190.68,107.06 v1(191.12,106.62)
KSO10: length 66.8
  TOP w0.114: v1(185.29,99.49) 185.29,98.91 183.42,97.04 182.49,97.04 177.84,92.4 177.84,87.89 168.15,78.2 164.06,78.2 v4(161.09,75.23) 158.2,72.34 JKB.23 ; UE1.46 184.66,116.08 184.12,116.62 184.12,117.92 184.49,118.29 185.77,118.29 v1(186.04,118.02)
  IN3 w0.114: v1(186.04,118.02) 186.04,117.76 187.11,116.69 187.11,113.16 186.36,112.41 186.36,106.75 186.12,106.5 186.12,100.32 v1(185.29,99.49)
KSO11: length 61
  TOP w0.114: v1(184.46,99.49) 184.46,99.04 v4(183.76,98.34) 182.7,97.28 182.39,97.28 177.6,92.5 177.6,87.99 168.05,78.44 163.96,78.44 161.15,75.62 160.92,75.62 157.7,72.41 JKB.22 ; UE1.51 186.66,116.48 v1(186.67,116.49)
  IN3 w0.114: v1(186.67,116.49) 186.87,116.29 186.87,113.26 186.12,112.51 186.12,109.53 185.41,108.82 185.41,100.43 v1(184.46,99.49)
KSO12: length 65.6
  TOP w0.114: JKB.19 156.2,73.96 v4(157.6,75.36) 158.82,76.58 161.08,76.58 163.66,79.16 167.75,79.16 176.88,88.29 176.88,92.8 183.15,99.07 183.15,99.67 183.59,100.11 v1(183.59,100.12) ; v1(184.89,116.49) 185.4,117 186.93,117 187.18,116.75 187.18,116.11 187.06,115.99 UE1.52
  IN3 w0.114: v1(183.59,100.12) 183.59,100.34 184.68,101.44 184.68,109.12 185.4,109.83 185.4,112.81 186.14,113.56 186.14,114.75 184.89,116.01 v1(184.89,116.49)
KSO13: length 66.1
  TOP w0.114: v1(183.59,99.49) 183.59,99.16 177.12,92.7 177.12,88.19 167.85,78.92 163.76,78.92 161,76.16 160.28,76.16 v4(159.34,75.21) 158.39,75.21 156.7,73.52 JKB.20 ; v1(184.89,117.13) 185.02,117.25 187.01,117.25 187.46,116.81 UE1.53
  IN3 w0.114: v1(183.59,99.49) 184.02,99.93 184.02,100.44 184.92,101.34 184.92,109.02 185.64,109.73 185.64,112.71 186.39,113.46 186.39,114.85 185.33,115.91 185.33,116.69 v1(184.89,117.13)
KSO14: length 66.7
  TOP w0.114: v1(184.46,100.12) 184.46,100.11 184.02,99.67 184.02,99.26 177.36,92.6 177.36,88.09 167.95,78.68 163.86,78.68 161.05,75.87 160.65,75.87 158.5,73.71 v4(158.22,73.71) 157.2,72.69 JKB.21 ; v1(184.89,117.76) 185.16,117.49 187.11,117.49 187.7,116.91 187.7,116.18 187.86,116.02 UE1.54
  IN3 w0.114: v1(184.89,117.76) 185.6,117.06 185.6,115.98 186.63,114.95 186.63,113.36 185.88,112.61 185.88,109.63 185.16,108.92 185.16,100.83 v1(184.46,100.12)
KSO15: length 65.1
  TOP w0.114: v1(185.34,98.34) 183.79,96.8 182.59,96.8 178.09,92.3 178.09,87.79 167.74,77.45 v4(167.38,77.45) 167.23,77.3 163.71,77.3 158.7,72.29 JKB.24 ; UE1.55 188.26,116.05 187.94,116.37 187.94,117.01 186.93,118.02 v1(186.67,118.02)
  IN3 w0.114: v1(186.67,118.02) 186.67,117.47 187.35,116.79 187.35,113.06 186.6,112.31 186.6,106.64 186.36,106.4 186.36,99.37 v1(185.34,98.34)
KSO16: length 61.5
  TOP w0.114: JKB.31 162.2,74.08 163.54,75.42 164.56,75.42 165.23,76.09 168.1,76.09 179.29,87.29 179.29,91.8 183.09,95.59 184.88,95.59 186.07,96.79 186.4,96.79 v4(186.56,96.95) 188,98.39 188,100.45 v1(187.56,100.88) ; UE1.56 188.66,116.29 v1(188.45,116.49)
  IN3 w0.114: v1(188.45,116.49) 188.65,116.29 188.65,108.22 188.32,107.88 188.32,104.6 187.08,103.37 187.08,101.36 v1(187.56,100.88)
KSO17: length 63.2
  TOP w0.114: v1(188.45,117.13) 188.9,116.68 188.9,116.11 189.06,115.95 UE1.57 ; JKB.32 162.7,74.24 163.64,75.18 164.66,75.18 165.29,75.81 168.15,75.81 179.53,87.19 179.53,91.7 183.19,95.35 184.98,95.35 186.08,96.45 186.61,96.45 188.46,98.3 v4(188.46,99.11) 188.45,99.12 v1(188.45,100.25)
  IN3 w0.114: v1(188.45,117.13) 188.89,116.68 188.89,108.12 188.56,107.78 188.56,104.5 187.33,103.27 187.33,101.74 188,101.07 188,100.7 v1(188.45,100.25)
LAN_PWRON: length 78.9
  TOP w0.114: UE1.97 191.93,130.8 v1(192.68,130.04) ; v1(211.19,125.52) 207.89,122.22 v4(207.89,120.57) 207.89,110.41 208.4,109.9 v1(210.43,109.9)
  IN1 w0.14: v1(192.68,130.04) 192.71,130.01 192.71,128.13 198.04,122.8 198.04,122.16 198.75,121.46 201.16,121.46 205.22,125.52 v1(211.19,125.52)
  BOTTOM w0.114: RL25.1 238.8,102.54 216.65,102.54 210.43,108.76 v1(210.43,109.9)
LAN_PWRON#: length 3.8
  BOTTOM w0.114: RL24.1 RL22.2 245.64,100.78 v1(244.8,100.78) 244.07,100.78 QL3.1
LAN_PWRON_R: length 4.2
  BOTTOM w0.114: v4(238.24,100.88) 238.33,100.79 RL25.2 RL23.1 241.81,100.79 QL3.2
LAN_WAKE#: length 143.2
  TOP w0.114: RPE2.5 183.74,112.92 v1(184,113.19) ; UE1.125 180.66,129.06 181.65,128.06 v1(187.06,128.06)
  IN1 w0.14: v1(184,113.19) 184.37,113.19 184.64,113.46 184.64,114.2 185.05,114.61 185.9,114.61 186.31,114.2 186.31,110.65 186.81,110.16 186.81,105.84 182.26,101.29 182.26,93.11 182.53,92.84 182.53,91.25 183.03,90.75 185.21,90.75 189.66,95.2 189.66,97.99 196.67,105 198.02,105 201.08,108.06 211.06,108.06 214.03,105.1 214.03,103.97 220.02,97.97 228.35,97.97 v1(228.97,98.6)
  IN3 w0.114: v1(228.97,98.6) 229.1,98.47 233.93,98.47 235.37,97.03 243.5,97.03 249.8,90.72 249.8,89.78 250.57,89.01 250.73,89.01 250.74,89.02 v1(250.77,89.02)
  BOTTOM w0.114: RL18.1 250.17,88.4 250.77,88.99 v1(250.77,89.02) ; v1(187.06,128.06) 186.91,127.91 186.91,124.1 183.86,121.05 183.86,114.71 184.51,114.07 184.51,113.7 v1(184,113.19)
LAN_WAKE#_R: length 6.1
  TOP w0.114: RL26.2 252.29,88.69 v1(252.08,88.91) 252.44,89.27 UL1.2
  BOTTOM w0.114: v4(249.17,86.91) 250.56,86.91 251.09,87.44 RL18.2 251.11,87.92 252.08,88.88 v1(252.08,88.91)
LAN_XTALI: length 4.2
  TOP w0.114: UL1.10 255.64,88.98 256.41,88.21 256.41,87.45 CL8.1 256.6,87.26 YL1.3
LAN_XTALO: length 5.4
  TOP w0.114: UL1.9 255.24,89.2 255.27,89.16 255.27,88.78 v4(255.52,88.54) 255.71,88.35 CL7.1 255.71,87.04 255.9,86.85 255.9,85.67 YL1.1
LANGND: length 5.3
  BOTTOM w0.508: JRJ451.16 295.77,69.67 JRJ451.13 ; JRJ451.15 295.77,88.32 JRJ451.14
  vias: v1(259.72,84.49) v1(259.72,83.73) v1(260.85,88.49) v1(261.74,88.49) v1(264.03,86.41) v1(267.71,86.41) v1(271.77,86.28) v1(275.46,86.28) v1(279.01,76.25) v1(280.79,90.98) v1(281.3,74.09) v1(282.06,84.63) v1(282.69,90.98) v1(283.2,73.96) v1(283.2,72.18) v1(284.22,90.09) v1(284.98,73.96) v1(284.98,72.18) v1(284.98,69.9) v1(286.38,89.84) v1(286.38,87.93) v1(287.01,69.26) v1(289.17,69.26) v1(291.33,69.26) v4(283.63,82.6)
LANPHYPC: length 222.4
  TOP w0.114: UL1.3 252.84,89.03 v1(252.71,88.91)
  IN1 w0.14: v1(177.79,114.19) 178.78,115.18 186.38,115.18 187.3,114.26 199.43,114.26 199.74,114.57 202.25,114.57 203.21,113.62 212.81,113.62 214.1,112.33 215.84,112.33 222.47,105.7 222.47,105.19 222.93,104.73 222.93,104.09 223.69,103.32 227.74,103.32 234.61,96.45 246.33,96.45 249.52,93.26 250.74,93.26 251.38,92.63 251.38,90.24 252.71,88.91 v1(252.71,88.91)
  BOTTOM w0.076: 126.03,128.06 124.76,128.06 123.78,127.09 121.83,127.09 121.64,126.89 121.28,126.89 121.16,126.94 121.04,126.94 120.83,126.88 120.68,126.88 120.52,126.93 120.44,126.93 119.74,127.15 119.74,127.15 119.56,127.33 UC1.AW17
  BOTTOM w0.114: 126.03,128.06 141.11,128.06 145.46,132.41 145.46,136.7 144.52,137.64 142.6,137.64 141.9,138.33 141.9,148.33 141.01,149.22 141.01,149.94 141.87,150.8 144.01,150.8 145.94,152.72 145.94,153.19 148.97,156.22 152.8,156.22 153.44,156.86 174.58,156.86 175.67,155.77 175.67,142.4 175.05,141.78 175.05,137.9 177.59,135.36 177.59,114.4 v1(177.79,114.19) ; v4(252.34,86.66) 252,87 RL9.2 252,88.2 v1(252.71,88.91)
LG_1PH: length 10.2
  IN3 w0.762: v1(63.43,102.39) 63.68,102.39 66.78,99.3 72.35,99.3
  vias: v1(62.78,102.38) v1(72.7,99.35) v1(73.34,99.35)
LG_A1: length 8.3
  IN3 w1.016: 63.3,82.05 64.35,81.01 64.35,74.17
  vias: v1(62.64,84.46) v1(62.64,78.92) v1(63.28,84.46) v1(63.28,78.92) v1(64.12,73.31) v1(64.09,72.68)
LG_B1: length 3.9
  TOP w1.016: 84.89,52.36 87.41,52.36 88.4,51.37
  vias: v1(85.3,51.26) v1(85.3,50.63) v1(91.27,51.29) v1(91.27,50.65) v4(90.04,50.97)
LID_SW#: length 292.2
  TOP w0.114: v1(186.57,129.46) 187.06,129.94 UE1.109 187.06,131.73 187.93,132.61 187.93,136.34 187.44,136.83 187.44,138.24 187.68,138.48 191.68,138.48 192.42,137.74 v1(192.78,137.74) ; RPE3.5 180.82,112.77 v1(181.02,112.97) ; U8.3 297.91,45.1 296.55,43.75 v1(295.79,43.75) ; v1(268.69,152.85) 268.73,152.81 D5.3 271,152.81 271.63,152.18 271.63,137.08 274.06,134.65 v1(274.06,129.59) ; D22.1 v1(252.84,148.62)
  IN1 w0.14: v1(268.69,152.85) 267.05,152.85 265.19,154.72 260.34,154.72 258.1,152.48 258.1,150.96 256.36,149.22 253.44,149.22 v1(252.84,148.62) ; v1(295.79,43.75) 294.39,43.75 293.22,42.58 287.26,42.58 282.97,46.87 282.97,56.2 283.06,56.29 283.06,70.73 276.7,77.09 272.12,77.09 269.92,79.29 266.12,79.29 263.62,81.79 257.67,81.79 256,83.46 255.52,83.46 253.8,85.18 253.8,86.21 254.88,87.3 256.91,87.3 258.06,88.44 258.06,89.58 259.91,91.44 v1(259.91,93.16)
  IN3 w0.114: v1(274.06,129.59) 275.33,128.32 275.71,128.32 279.01,125.01 279.01,110.92 280.79,109.14 280.79,102.79 276.98,98.98 265.09,98.98 261.36,95.25 261.36,94.61 v1(259.91,93.16)
  BOTTOM w0.114: v1(252.84,148.62) 252.25,148.03 251.55,148.03 250.37,149.21 236.3,149.21 229.54,142.45 204.58,142.45 203.04,140.91 200.27,140.91 198.24,138.89 193.97,138.89 192.82,137.74 v1(192.78,137.74) ; v1(186.57,129.46) 186.6,129.43 186.6,124.38 181.42,119.2 181.42,113.38 v1(181.02,112.97)
LOGO_LED#: length 397.9
  TOP w0.114: JLCD.10 55.82,115 56.04,115.22 56.04,116.75 56.71,117.42 57.04,117.42 60.43,120.81 v1(60.56,120.81) 61.58,120.81 62.19,120.2 65.94,120.2 67.49,121.75 v1(69.83,121.75) ; JLOGO.2 282.04,23.66 v1(282.81,22.89) ; v1(179.82,119.55) 179.37,120.01 178.76,120.01 178.72,119.97 UE1.24
  IN1 w0.14: v1(184.47,91.29) 184.99,91.29 189.39,95.69 189.39,98.1 197.5,106.21 198.85,106.21 200.97,108.33 211.17,108.33 214.29,105.21 214.29,104.08 219.42,98.95 225.15,98.95 225.51,98.6 v1(226.94,98.6)
  IN3 w0.114: 284.24,39.7 281.68,37.13 281.68,24.02 v1(282.81,22.89) ; v1(179.82,119.55) 179.93,119.45 179.93,118.39 179.35,117.8 179.35,112.83 180.05,112.12 180.05,106.64 179.19,105.78 179.19,101.39 178.33,100.54 178.33,96.53 179.51,95.35 184.83,95.35 185.16,95.02 185.16,93.88 182.75,91.47 182.75,91.02 182.96,90.8 183.99,90.8 v1(184.47,91.29)
  IN3 w0.14: v1(226.94,98.6) 227.7,97.84 233.55,97.84 234.89,96.49 241.98,96.49 246.47,92 246.47,90.06 248.37,88.16 248.37,87.69 249.18,86.88 250.95,86.88 256.66,81.18 262.56,81.18 265.74,77.99 270.41,77.99 273.51,74.89 276.02,74.89 279.52,71.39 279.52,57.06 282.72,53.86 282.72,45.99 284.24,44.47 284.24,39.7
  BOTTOM w0.114: v1(60.56,120.81) 60.69,120.94 60.82,120.94 61.71,121.84 D1.2 ; v1(69.83,121.75) 70.68,122.6 72.04,122.6 76.6,118.03 76.6,116.32 78.45,114.47 78.8,114.47 80.72,112.56 80.72,87.88 86.42,82.17 86.42,78.35 88.32,76.45 94.74,76.45 95.99,75.19 101.73,75.19 103.38,73.54 107.29,73.54 109.99,76.24 128.03,76.24 129.57,77.78 161.01,77.78 161.94,78.7 167.92,78.7 174.48,85.26 181.47,85.26 184.24,88.04 184.24,91.06 v1(184.47,91.29)
LPC_AD0: length 132.6
  TOP w0.114: UE1.10 178.74,125.57 178.78,125.53 179.4,125.53 180.18,124.75 184.19,124.75 v1(184.39,124.55)
  BOTTOM w0.076: 122.94,129.62 121.73,129.62 121.59,129.48 121.31,129.48 121.19,129.54 121.05,129.54 120.82,129.47 120.7,129.47 120.5,129.54 120.38,129.64 120.27,129.75 UC1.AY13
  BOTTOM w0.114: 122.94,129.62 124.67,131.36 126.42,131.36 130.14,135.08 130.14,138.26 130.9,139.02 130.9,146.5 129.49,147.91 129.49,149.09 129.79,149.39 130.51,149.39 131.04,149.91 133.03,149.91 136.53,153.41 136.53,156.87 138.39,158.73 146.46,158.73 147.6,159.87 163.91,159.87 164.86,160.82 175.14,160.82 v4(176.01,161.69) 179.93,161.69 183.58,158.04 183.58,150.17 184.6,149.15 184.6,139.88 185.76,138.73 185.76,133.88 184.29,132.42 184.29,127.44 183.9,127.05 183.9,125.03 v1(184.39,124.55)
LPC_AD1: length 133
  TOP w0.114: v1(185.27,124.56) 184.85,124.99 180.28,124.99 179.5,125.77 178.88,125.77 178.68,125.97 UE1.9
  BOTTOM w0.076: UC1.BA13 120.97,129.75 121.24,130.01 122.65,130.01 122.87,130.24
  BOTTOM w0.114: 122.87,130.24 124.24,131.61 124.47,131.84 126.22,131.84 129.66,135.28 129.66,146.68 129.01,147.34 129.01,149.29 129.59,149.87 130.31,149.87 132.29,151.84 132.78,151.84 136.05,155.12 136.05,157.07 138.19,159.21 146.26,159.21 147.4,160.35 163.58,160.35 164.53,161.3 171.38,161.3 v4(172.13,162.05) 172.42,162.34 179.96,162.34 184.06,158.24 184.06,150.37 187.23,147.21 187.23,134.67 184.78,132.22 184.78,125.9 184.84,125.84 184.84,124.99 v1(185.27,124.56)
LPC_AD2: length 130.5
  TOP w0.114: UE1.8 178.83,126.37 179.18,126.01 179.6,126.01 180.38,125.23 183.78,125.23 184.06,125.51 v1(184.41,125.51)
  BOTTOM w0.076: 122.82,129.84 121.7,129.84 121.61,129.75 UC1.BB13
  BOTTOM w0.114: v1(184.41,125.51) 184.53,125.64 184.53,132.32 186.99,134.77 186.99,147.11 183.82,150.27 183.82,158.14 179.86,162.1 174.2,162.1 v4(173.93,161.83) 173.16,161.06 164.76,161.06 163.81,160.11 147.5,160.11 146.36,158.97 138.29,158.97 136.29,156.97 136.29,155.02 132.88,151.6 132.39,151.6 130.41,149.63 129.69,149.63 129.25,149.19 129.25,147.81 130.66,146.4 130.66,139.12 129.9,138.36 129.9,135.18 126.32,131.6 124.57,131.6 122.82,129.84
LPC_AD3: length 134.6
  TOP w0.114: UE1.7 178.77,126.77 179.28,126.25 179.7,126.25 180.48,125.47 183.68,125.47 184.16,125.95 184.84,125.95 v1(185.28,125.51)
  BOTTOM w0.076: 123.29,131.05 122.42,130.18 120.88,130.18 120.71,130.01 120.29,130.01 119.98,130.32 UC1.AY12
  BOTTOM w0.114: v1(185.28,125.51) 185.28,126.39 185.02,126.65 185.02,132.12 187.47,134.57 187.47,147.31 184.31,150.47 184.31,158.34 180.06,162.58 170.68,162.58 v4(170.4,162.3) 169.64,161.54 164.43,161.54 163.48,160.59 147.3,160.59 146.16,159.45 138.09,159.45 135.81,157.17 135.81,155.22 133.57,152.98 132.55,152.98 130.42,150.84 129.68,150.84 128.77,149.92 128.77,147.24 129.42,146.58 129.42,135.76 126.14,132.48 125.11,132.48 124.87,132.72 124.19,132.72 123.46,132 123.46,131.17 123.34,131.05 123.29,131.05
LPC_FRAME#: length 150.4
  TOP w0.114: v1(179.81,113.19) 179.32,112.69 RPE3.8 ; UE1.6 178.71,127.17 178.75,127.13 v1(179.16,127.13) 180.58,125.71 183.5,125.71 183.98,126.19 185.22,126.19 185.62,125.79 v1(186.16,125.79)
  BOTTOM w0.076: UC1.BA12 120.47,130.34 122.34,130.34 123.23,131.23
  BOTTOM w0.114: v1(186.16,125.79) 185.72,126.24 185.72,127.5 185.89,127.67 185.89,131.74 187.71,133.56 187.71,147.41 184.55,150.57 184.55,158.44 180.16,162.83 168.98,162.83 v4(168.67,162.52) 167.94,161.78 164.33,161.78 163.38,160.84 147.2,160.84 146.06,159.69 137.99,159.69 134.76,156.47 134.76,155.55 130.3,151.08 129.58,151.08 128.52,150.02 128.52,147.14 129.18,146.48 129.18,135.86 126.04,132.72 125.21,132.72 124.97,132.96 124.07,132.96 123.23,132.12 123.23,131.23 ; v1(179.81,113.19) 179.31,113.7 179.31,118.41 180.45,119.56 180.45,120.71 179.7,121.46 179.7,126.59 v1(179.16,127.13)
