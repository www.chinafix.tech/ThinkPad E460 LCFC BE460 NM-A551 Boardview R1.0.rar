# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Nets (continued)
USB20_N0: L11.4 UC1.AB9(USB2N_1)
USB20_N0_CON: D8.6(V_I/O4) JUSB1.2(D-) L11.3
USB20_N1: L14.4 UC1.AD6(USB2N_2)
USB20_N1_CON: D9.6(V_I/O4) JUSB2.2(D-) L14.3
USB20_N2: U14.2(DM_OUT) UC1.AH3(USB2N_3)
USB20_N2_C: L6.1 R122.1 U14.11(DM_IN)
USB20_N2_CONN: JU3AC.3 L6.2 R122.2
USB20_N3: L20.4 R115.1 UC1.AD9(USB2N_4)
USB20_N3_OD: D15.6(V_I/O4) JLINK.10(USB20_N) L20.3 R115.2
USB20_N4_TPANEL: L19.4 R269.1 UC1.AJ1(USB2N_5)
USB20_N4_TPANEL_C: JTOUCH1.4 L19.3 R269.2
USB20_N5: JWLBT.5(USB_D-) UC1.AF6(USB2N_6)
USB20_N6: L5.4 R19.1 UC1.AH1(USB2N_7)
USB20_N6_CMOS: JLCD.17 L5.3 R19.2
USB20_N8: D4.3 JFPB.4 UC1.AF8(USB2N_8)
USB20_P0: L11.1 UC1.AB10(USB2P_1)
USB20_P0_CON: D8.1(V_I/O1) JUSB1.3(D+) L11.2
USB20_P1: L14.1 UC1.AD7(USB2P_2)
USB20_P1_CON: D9.1(V_I/O1) JUSB2.3(D+) L14.2
USB20_P2: U14.3(DP_OUT) UC1.AJ3(USB2P_3)
USB20_P2_C: L6.4 R121.1 U14.10(DP_IN)
USB20_P2_CONN: JU3AC.2 L6.3 R121.2
USB20_P3: L20.1 R114.1 UC1.AD10(USB2P_4)
USB20_P3_OD: D15.4(V_I/O3) JLINK.8(USB20_P) L20.2 R114.2
USB20_P4_TPANEL: L19.1 R270.1 UC1.AJ2(USB2P_5)
USB20_P4_TPANEL_C: JTOUCH1.5 L19.2 R270.2
USB20_P5: JWLBT.3(USB_D+) UC1.AF7(USB2P_6)
USB20_P6: L5.1 R20.1 UC1.AH2(USB2P_7)
USB20_P6_CMOS: JLCD.18 L5.2 R20.2
USB20_P8: D4.2 JFPB.5 UC1.AF9(USB2P_8)
USB30_RX_N2_CON: D10.5(IN4) D10.6(OUT1) JUSB2.5(STDA_SSRX-) L13.3
USB30_RX_P2_CON: D10.4(IN3) D10.7(OUT2) JUSB2.6(STDA_SSRX+) L13.2
USB30_TX_N2_CON: D10.2(IN2) D10.8(OUT3) JUSB2.8(STDA_SSTX-) L12.3
USB30_TX_P2_CON: D10.1(IN1) D10.9(OUT4) JUSB2.9(STDA_SSTX+) L12.2
USB_OC0#: C120.1 RPC15.6(R6) U15.3(O\C\) UC1.A9(GPP_E9/USB2_OC0#)
USB_OC1#: RPC15.7(R7) U14.13(FAULT#) UC1.C9(GPP_E10/USB2_OC1#)
USB_OC2#: RPC15.8(R8) UC1.D9(GPP_E11/USB2_OC2#)
USB_OC3#: RPC15.5(R5) UC1.B9(GPP_E12/USB2_OC3#)
USB_ON#: RE2.1 U15.4(E\N\) UE1.33(GINT/CTS0#/GPD5)
USBCOMP: RC359.1 UC1.AB6(USB2_COMP)
VGA_AC_DC#: DV2.1 UE1.126(GA20/GPB5)
VGA_LGATE1: PQ602.4(G) PQ603.4(G) PU601.24(LGATE1)
VGA_LGATE2: PQ605.4(G) PQ606.4(G) PU601.27(LGATE2)
VGA_ON: DV6.1 PR603.1 QV10.2(G1) RPC26.1(R1) RV49.2 RV136.1 RV152.1 RV153.1 UC1.U8(GPP_C18/I2C1_SDA)
VGA_PHASE1: PC612.2 PL603.1 PQ601.1(S1) PQ601.2(S2) PQ601.3(S3) PQ602.5(D) PQ603.5(D) PR607.2 PR608.2 PR616.2 PU601.23(PHASE1)
VGA_PHASE2: PC618.2 PL604.1 PQ604.1(S1) PQ604.2(S2) PQ604.3(S3) PQ605.5(D) PQ606.5(D) PR630.2 PR631.2 PR632.2 PU601.28(PHASE2)
VGA_UGATE1: PQ601.4(G) PU601.22(UGATE1)
VGA_UGATE2: PQ604.4(G) PU601.29(UGATE2)
VGATE: PR406.1 PU401.38(VR_RDY) UE1.78(DAC2/TACH0B/GPJ2)
VMB: PC9.1 PF2.1 PL3.1 PL4.1
VMB2: JBATT1.6 JBATT1.7 PF2.2
VR_HOT#: CE17.1 PR126.1 PR409.2 QE1.1(D) RC5.1 RC294.2
VR_HOT#_R: RC5.2 UC1.C65(PROCHOT#)
VR_ON: D59.2 D60.2 PR407.1 QC3.2(G1) RE47.1
VR_ON_EC: D60.1 UE1.30(PWM4/GPA4)
VR_SVID_ALRT#: PR408.1 RC19.2 RC20.2
VR_SVID_ALRT#_R: RC19.1 UC1.B63(VIDALERT#)
VR_SVID_CLK: PR404.2 PR410.1 RC356.2 UC1.A63(VIDSCK)
VR_SVID_DAT: PR403.2 PR411.1 RC355.2 UC1.D64(VIDSOUT)
VRALERT#: T49.1 UC1.AM11(GPP_B2/VRALERT#)
VSUM+: PC633.1 PC634.1 PR608.1 PR631.1 PR633.1 PR634.1 PU601.14(ISUMP)
VSUM-: PC608.1 PC628.1 PC633.2 PC634.2 PC637.2 PR618.1 PR634.2 PR635.2 PR636.1 PR639.2 PRT601.1
VSYSTEM: PC6.1 PC7.1 PC101.1 PD1.2 PD102.2 PL1.2 PL2.2 PQ101.5(D) PR5.1 PR113.1
VTTREF_0.675V: PC315.1 PU301.4(VTTREF)
WLAN_PWRON: R9449.1 UE1.123(CTX0/TMA0/GPB2)
WLAN_PWRON#: Q26.1(D) R9450.2 R9451.1
WLAN_PWRON_R: Q26.2(G) R69.1 R9449.2
WRST#: CE11.1 IT8.1 RE4.2 UE1.14(WRST#)
XDP_BPM#0: T15.1 UC1.C55(BPM#[0])
XDP_BPM#1: T16.1 UC1.D55(BPM#[1])
XDP_BPM#2: T19.1 UC1.B54(BPM#[2])
XDP_BPM#3: T20.1 UC1.C56(BPM#[3])
XDP_PRDY_N: TP115.1 UC1.D56(PROC_PRDY#)
XDP_PREQ_N: TP116.1 UC1.D61(PROC_PREQ#)
XDP_TCLK: RC4.1 T5.1 UC1.B61(PROC_TCK)
XDP_TDI: RC31.1 T4.1 UC1.D60(PROC_TDI)
XDP_TDO: RC3.1 RC404.1 T6.1 UC1.A61(PROC_TDO)
XDP_TMS: RC34.1 T3.1 UC1.C60(PROC_TMS)
XDP_TRST#: RC6.1 T14.1 UC1.B59(PROC_TRST#)
XTALIN: CV144.1 RV68.2 UV3.AM28(XTALIN) YV1.3(OSC2)
XTALOUT: CV143.1 RV68.1 UV3.AK28(XTALOUT) YV1.1(OSC1)
YELLOW_LED: JRJ451.11(YELLOW_LED+) RL15.2
N09817: PC621.2 PC622.1 PR625.2 PR626.1 PU601.17(RTN)
N09897: PC617.1 PC619.2 PC621.1 PR621.1 PR622.2 PR623.1 PU601.16(VSEN)
N10003: PC610.1 PR613.2
N10023: PC609.2 PC610.2 PR619.2 PU601.19(COMP)
N10051: PC609.1 PR613.1 PR617.2 PR623.2 PR624.1 PU601.18(FB)
N10079: PC617.2 PR617.1
N10153: PC620.1 PR624.2
N13273: PC635.1 PR635.1 PU601.15(ISUMN)
N13333: PC635.2 PR639.1
N13487: PR633.2 PRT601.2
N18669: PC612.1 PR614.2
N18705: PR614.1 PU601.21(BOOT1)
N22144: PC618.1 PR620.2
N22186: PR620.1 PU601.30(BOOT2)
N32858: PC636.2 PR642.1 PU601.10(IMON)
N34928: PC605.1 PR602.1 PU601.26(VDDP)
N41772: PC601.1 PR603.2 PU601.8(ENABLE)
N193745: PR641.1 PRT602.1 PU601.11(NTC)
N13690206: CV140.1 QV7.2(G) RV49.1 RV50.2
N13748098: CV104.1 RV26.2 RV27.1
N13748269: CV131.1 RV38.2 RV39.1
N13756593: CV76.2 RV12.1
N13756597: CV77.2 RV13.1
N13756601: CV76.1 TPV15.1 UV3.K8(CLKTESTA)
N13756610: CV77.1 TPV16.1 UV3.L7(CLKTESTB)
N13756920: CV74.1 RV9.2 RV10.1
N13756934: CV75.1 RV10.2 RV11.1 UV3.L10(DRAM_RST)
N13757067: CV73.1 RV7.2 RV8.1 UV3.J26(MVREFSA_2)
N13757116: CV72.1 RV5.2 RV6.1 UV3.K26(MVREFDA_1)
N13769821: DV1.2 RV86.2 RV87.1 RV88.1
N13769835: CV148.1 QV3.2(BASE) RV87.2
N13886213: RV47.1 UV3.Y22(PCIE_CALR_TX)
N13886217: RV48.1 UV3.AA22(PCIE_CALR_RX)
N13886250: RV40.2 UV3.N10(TEST_PG)
N13887174: RV55.2 TPV1.1 UV3.U1(BP_0)
N13887181: RV54.2 TPV2.1 UV3.U3(BP_1)
N13887277: RV71.2 UV3.R1(SCL)
N13887284: RV70.2 UV3.R3(SDA)
N13887527: RV81.2 UV3.AA3(PLL_ANALOG_OUT)
N13887571: TPV13.1 UV3.AA1(PLL_ANALOG_IN)
N13887575: RV78.2 RV79.2 UV3.AB16(PX_EN)
N13887638: QV4.3(S) RV80.2 RV106.2 UV3.AJ27(WAKEB)
N13887928: RV76.2 RV77.2 UV3.K7(TESTEN)
N13887997: RV82.2 UV3.AC22(XO_IN)
N13887999: RV83.2 UV3.AB22(XO_IN2)
N13916283: RV14.2 UV3.K25(MEM_CALRP0)
N13962114: RV89.2 RV91.2 RV93.1 UV9.2(1A)
N13962118: RV90.2 RV92.2 RV94.1 UV9.3(2A)
N13962250: CV151.1 CV152.1 RV95.1 UV9.5(DIR)
N13963666: RV96.1 UV9.7(1B)
N13963670: RV97.1 UV9.6(2B)
N13969324: RV75.2 RV112.2 UV3.N7(CLKREQB)
N13973823: RV78.1 TPV12.1
N15168718: PC310.2 PR303.1
N15172206: PR301.2 PU301.11(VID)
N15172224: PC316.1 PR306.2 PU301.12(VDD)
N15173757: PR308.1 PU301.10(PGOOD)
N15178230: PR302.2 PU301.13(CS)
N15269244: PC805.2 PR804.2 PR805.1 PU801.6(FB)
N15269410: PC804.2 PR803.1
N16794113: PR120.2 PU101.11(SDA)
N16794114: PR121.2 PU101.12(SCL)
N16794121: PC104.2 PC105.2 PC107.1 PL101.2 PR101.1 PR107.1
N16794165: PC115.1 PR114.1 PU101.28(VCC)
N16794166: PD102.1 PD103.1 PR114.2
N16794173: PC118.2 PR116.2
N16794272: PR111.2 PU101.4(ACDRV)
N16794274: PR112.2 PU101.3(CMSRC)
N16794279: PC101.2 PC102.2 PD101.2 PQ102.4(G) PQ103.1(D) PR102.2 PR111.1
N16794300: PC117.2 PR113.2 PR115.2 PU101.6(ACDET)
N16794308: PR118.2 PU101.5(ACOK)
N16794310: PC126.2 PR123.1
N16794326: PR126.2 PU101.10(PROCHOT#)
N16794335: PQ103.2(G) PR104.1 PR105.2
N16794344: PR122.2 PU101.7(IADP)
N16794345: PR123.2 PU101.8(IDCHG)
N16794346: PR124.2 PU101.9(PMON)
N16797507: PD1.1 PD3.1 PR2.2 PR3.2
N16797515: PC1.2 PQ1.1 PQ2.2(B) PQ3.1(D) PR3.1 PRT1.2
N16797523: PQ1.3 PR1.2 PR2.1
N16797527: PD2.1 PQ1.2 PQ2.1(C) PR1.1
N16797541: PRT2.1 PRT4.1
N16797550: PRT4.2 PRT5.1
N16797569: PRT5.2 PRT6.1
N16797599: PRT1.1 PRT3.2
N16797601: PRT2.2 PRT3.1
N16880284: PR606.2 PU601.9(PWROK)
N16880287: PR609.2 PU601.3(SVC)
N16880290: PR615.2 PU601.5(SVD)
N16880296: PR611.2 PU601.7(SVT)
N16880299: PR610.2 PU601.4(VR_HOT_L)
N16901916: PC616.1 PR607.1
N16902103: PC632.1 PR630.1
N16922606: PR129.2 PU101.21(ILIM)
N16922622: PC128.1 PR129.1 PR130.2 PR131.1 PR132.1
N16922664: PR131.2 PU101.16(TB_STAT#)
N16922835: PC121.1 PR119.1
N16954250: JBATT1.3 PR16.2 PR17.1
N19577504: RL5.2 UL1.33(JTAG_TMS)
N19577505: RL6.2 UL1.35(JTAG_TCK)
N19577517: RL7.1 UL1.30(TEST_EN)
N19577520: RL8.1 UL1.12(RBIAS)
N19577582: RL4.1 UL1.1(RSVD1_VCC3P3)
N26325477: PC432.1 PC433.1 PC434.1 PC435.1 PC436.1 PC437.1 PC438.1 PL401.1 PL402.1 PQ401.5(D)
N26386889: PC445.1 PR450.1
N31349437: PC442.2 PR449.1
N31349441: PR449.2 PU402.1(BST)
N31382737: PC446.1 PC447.1 PC448.1 PC449.1 PC450.1 PC451.1 PC452.1 PL404.1 PL405.1 PQ404.5(D)
N31383366: PC456.2 PR454.1
N31383897: PC453.2 PR453.1
N31383905: PR453.2 PU403.1(BST)
N31389989: PC457.1 PC458.1 PC459.1 PC460.1 PC461.1 PL407.1 PQ407.5(D)
N31390138: PC464.1 PR458.1
N31390261: PC462.2 PR457.1
N31390277: PR457.2 PU404.1(BST)
N31396697: PC416.2 PR425.2 PU401.1(IOUT_2PH)
N31396723: PC415.2 PR424.2 PU401.48(VSN_2PH)
N31396745: PC412.2 PR420.2 PU401.27(ILIM_1A)
N31396767: PC411.2 PR421.1 PU401.30(IOUT_1A)
N31396821: PR414.2 PR415.2 PU401.24(VSP_1A)
N31396831: PC404.2 PR414.1
N31396857: PC428.1 PR440.2
N31396859: PC427.2 PC428.2 PU401.43(COMP_1B)
N31396879: PC409.2 PC410.2 PU401.26(COMP_1A)
N31396887: PC410.1 PR419.2
N31396963: PC407.2 PR416.2 PU401.25(VSN_1A)
N31397011: PC429.1 PC439.1 PR438.1 PR439.1 PU401.40(CSP_1B)
N31397019: PR439.2 PRT405.1
N31397040: PR409.1 PU401.31(VR_HOT#)
N31397051: PC424.1 PR435.1 PU401.11(TSENSE_2PH)
N31397062: PR435.2 PR436.2 PRT404.1
N31397070: PR432.1 PU401.5(ILIM_2PH)
N31397078: PC418.1 PC419.1 PR427.1 PR432.2 PRT403.1 PU401.6(CSCOMP_2PH)
N31397084: PC418.2 PC419.2 PR426.1 PR430.2 PU401.7(CSSUM_2PH)
N31397096: PR427.2 PR430.1 PRT403.2
N31397121: PC414.2 PC417.1 PR423.1 PU401.8(CSREF_2PH)
N31397144: PC414.1 PR422.1 PU401.10(CSP1_2PH)
N31397166: PC408.1 PR417.1 PU401.23(TSENSE_1PH)
N31397172: PR417.2 PR418.2 PRT402.1
N31397188: PC401.1 PR401.2 PU401.12(VRMP)
N31397190: PC402.1 PR402.2 PU401.13(VCC)
N31397230: PC441.1 PR407.2 PU401.37(EN)
N31397238: PR410.2 PU401.34(SCLK)
N31397260: PC405.1 PC440.1 PR405.1 PR412.1 PU401.29(CSP_1A)
N31397268: PR405.2 PRT401.1
N31397346: PC431.2 PR441.2 PU401.42(ILIM_1B)
N31397348: PR428.1 PR431.1 PU401.2(DIFFOUT_2PH)
N31397350: PC421.2 PC422.1 PR428.2 PR429.1 PU401.3(FB_2PH)
N31397402: PC420.2 PC422.2 PU401.4(COMP_2PH)
N31397404: PC430.2 PR442.2 PU401.39(IOUT_1B)
N31397538: PR443.2 PU401.14(ROSC_COREGT)
N31397546: PR444.2 PU401.15(ROSC_SAUS)
N31397550: PR446.2 PU401.19(ICCMAX_1A)
N31397552: PR445.2 PU401.18(ICCMAX_2PH)
N31397554: PR447.2 PU401.20(ICCMAX_1B)
N31397556: PR448.2 PU401.21(ADDR_VBOOT)
N31397566: PR408.2 PU401.33(ALERT#)
N31397696: PR433.2 PR434.2 PU401.45(VSP_1B)
N31397710: PR411.2 PU401.32(SDIO)
N31397718: PC423.2 PR433.1
N31398277: PC426.2 PR437.2 PU401.44(VSN_1B)
N31398315: PC420.1 PR429.2
N31398319: PC421.1 PR431.2
N36436059: PC317.2 PR304.1
N36436199: PR303.2 PU301.18(BOOT)
N38076593: RV16.1 UV5.L8(ZQ)
N38077179: RV17.1 UV6.L8(ZQ)
N38081150: RV28.1 UV7.L8(ZQ)
N38081832: RV29.1 UV8.L8(ZQ)
N48440511: PC702.2 PR702.2 PU701.26(VREF)
N48440559: PR706.2 PU701.20(TRIP)
N48440565: PC703.1 PU701.21(SLEW)
N48440766: PC704.1 PR707.2
N48440774: PC701.1 PR701.2 PU701.28(EN)
N48440814: PC718.1 PR708.1
N50697329: JDIMM1.197(SA0) RC316.2
N50697343: CD2.2 RD4.1
N50697618: JDIMM1.201(SA1) RC315.2
N50697658: CD12.2 RD12.1
N50702365: CD31.2 RD18.1
N50702825: JDIMM2.197(SA0) RC317.2
N51647759: TPV17.1 UV3.N9(NC_DBG_DATA16)
N51647766: TPV18.1 UV3.L9(NC_DBG_DATA15)
N51647773: TPV19.1 UV3.AE9(NC_DBG_DATA14)
N51647780: TPV20.1 UV3.Y11(NC_DBG_DATA13)
N51647787: TPV21.1 UV3.AE8(NC_DBG_DATA12)
N51647794: TPV22.1 UV3.AD9(DBG_DATA11)
N51647801: TPV23.1 UV3.AC10(DBG_DATA10)
N51647808: TPV24.1 UV3.AD7(DBG_DATA9)
N51647815: TPV25.1 UV3.AC8(DBG_DATA8)
N51647822: TPV26.1 UV3.AC7(DBG_DATA7)
N51647829: TPV27.1 UV3.AB9(DBG_DATA6)
N51647836: TPV28.1 UV3.AB8(DBG_DATA5)
N51647843: TPV29.1 UV3.AB7(DBG_DATA4)
N51647850: TPV30.1 UV3.AB4(DBG_DATA3)
N51647857: TPV32.1 UV3.Y8(DBG_DATA1)
N51647864: TPV33.1 UV3.Y7(DBG_DATA0)
N51647871: TPV34.1 UV3.AL9(NC_DBG_CNTL0)
N51647878: TPV31.1 UV3.AB2(DBG_DATA2)
N52745643: RV107.1 UV3.AK12(GPIO_SVD)
N52745645: RV109.1 UV3.AJ11(GPIO_SVC)
N52745647: RV108.1 UV3.AL11(GPIO_SVT)
N53646061: QV4.2(G) RV115.2
N53646159: QV4.1(D) RV140.2
N54603879: PR702.1 PR703.2 PU701.25(REFIN)
N54887023: JDIMM2.201(SA1) RD19.2
N55632055: PR627.2 PU601.36(COMP_NB) PU601.37(FB_NB) PU601.38(VSEN_NB)
N55632901: PR637.2 PU601.39(ISUMN_NB) PU601.40(ISUMP_NB)
N55634236: PR640.1 PU601.2(IMON_NB)
N55637104: PR638.1 PU601.1(NTC_NB)
N55638710: PR628.1 PU601.32(UGATE_NB) PU601.33(PHASE_NB)
N56243451: PC4.1 PC5.1 PF1.1 PL1.1 PL2.1
N56300303: PR612.2 PR644.2 PU601.6(VDDIO)
N56340374: PR629.1 PU601.34(LGATE_NB)
N56471499: PR705.1 PU701.3(MODE)
N56799483: CL9.1 CL13.1 TL1.3(TDCT1) TL1.4(TDCT2) TL1.9(TDCT3) TL1.10(TDCT4)
N57615062: T24.1 UL1.34(JTAG_TDO)
N57615075: T23.1 UL1.32(JTAG_TDI)
N57722199: F1.1 JLINK.6(VBUS)
N57725801: JKB.25 R111.2
N57726117: D6.2 R112.1
N57726123: JRTC.1 R112.2
N57732272: R120.1 U14.16(ILIM_HI)
N57732400: R118.1 U14.15(ILIM_LO)
N57740748: R3.1 U1.7(THERM#)
N57771515: R30.2 U5.7(REXT)
N57771580: C31.2 U5.22(B_OUTP)
N57771583: C33.2 U5.23(B_OUTN)
N57771966: TP72.1 U5.5(PD#)
N57771968: TP73.1 U6.5(PD#)
N57772670: R45.2 U6.7(REXT)
N57772804: C38.2 U6.22(B_OUTP)
N57772807: C39.2 U6.23(B_OUTN)
N57774513: CRE17.1 CRE18.1 CRE19.1 CRE20.1 CRE21.1 CRE22.1 RRE32.1 URE1.12(VDDRX_1) URE1.19(VDDTA) URE1.20(VDDTX_1) URE1.31(VDDTX_2) URE1.40(VDDRX_2)
N57774860: TP71.1 URE1.36(PD#)
N57775834: RRE20.1 URE1.18(REXT)
N57806855: C71.1 U11.12(CT1)
N57806872: C72.1 U11.10(CT2)
N57919388: CA29.1 RA14.2
N57919390: CA30.1 RA15.2
N57919402: CA31.1 RA19.2
N57919452: DA4.1 RA22.2
N57919454: CA32.1 RA24.2
N57919809: CA22.2 CA23.2 DA1.1(ANODE) RA11.1 RA13.1
N57919838: CA24.1 RA11.2
N57924109: CA16.2 UA1.11(CLASS-D_REF)
N57924172: CA17.2 UA1.19(FLY_P)
N57924174: CA17.1 UA1.20(FLY_N)
N58156905: PQ101.4(G) PR102.1
N58599815: DA3.1 RA16.2
N58636514: QV8.5(G2) RV136.2 RV137.1
N58636526: QV8.6(D1) RV138.1
N58636528: QV8.2(G1) RV139.2
N58636569: CV169.1 QV5.2(G) RV135.2
N58636580: JV3.1 QV5.1(D)
N58868284: JLCD.4 R21.2
N59027813: PQ4.6(D1) PR4.1 PR6.2
N59062655: PR641.2 PR643.1 PRT602.2
N59727618: PD101.1 PQ105.1(D)
N59727917: PQ105.2(G) PR109.2 PR110.2
N60801854: QV11.2(G) RV142.2
N60801856: QV11.1(D) RV141.1
N60801870: CV160.1 QV9.4(G) RV130.2
N60802017: QV10.5(G2) QV10.6(D1) RV143.2
N60939795: PC208.1 PR205.1 PU201.5(LDO)
N60939813: PC209.2 PR204.1
N61716887: PC212.2 PR207.1
N62639755: TP37.1 UC1.BB68(RSVD_TP_BB68)
N62639757: TP39.1 UC1.BB69(RSVD_TP_BB69)
N62639791: TP43.1 UC1.AK13(RSVD_TP_AK13)
N62639793: TP45.1 UC1.AK12(RSVD_TP_AK12)
N62639820: TP49.1 UC1.BB2(RSVD_BB2)
N62639829: TP51.1 UC1.BA3(RSVD_BA3)
N62639863: TP59.1 UC1.AU5(TP5)
N62639865: TP60.1 UC1.AT5(TP6)
N62639899: TP64.1 UC1.B3(RSVD_B3)
N62639901: TP66.1 UC1.A3(RSVD_A3)
N62640032: TP29.1 UC1.AW1(RSVD_AW1)
N62640090: TP23.1 UC1.D4(RSVD_D4)
N62640092: TP25.1 UC1.B2(RSVD_B2)
N62640101: TP27.1 UC1.C2(RSVD_C2)
N62640103: TP22.1 UC1.D5(RSVD_D5)
N62640164: TP31.1 UC1.E1(RSVD_E1)
N62640180: TP33.1 UC1.E2(RSVD_E2)
N62640214: TP34.1 UC1.BA4(RSVD_BA4)
N62640216: TP35.1 UC1.BB4(RSVD_BB4)
N62640259: TP67.1 UC1.A4(RSVD_A4)
N62640261: TP68.1 UC1.C4(RSVD_C4)
N62640281: TP54.1 UC1.BB5(TP4)
N62640313: TP24.1 UC1.AY2(RSVD_AY2)
N62640315: TP26.1 UC1.AY1(RSVD_AY1)
N62640335: TP74.1 UC1.D1(RSVD_D1)
N62640353: TP30.1 UC1.D3(RSVD_D3)
N62640386: TP32.1 UC1.F60(RSVD_F60)
N62640584: TP86.1 UC1.K46(RSVD_K46)
N62640593: TP85.1 UC1.K45(RSVD_K45)
N62640620: TP88.1 UC1.AL25(RSVD_AL25)
N62640629: TP87.1 UC1.AL27(RSVD_AL27)
N62640656: TP90.1 UC1.C71(RSVD_C71)
N62640665: TP89.1 UC1.B70(RSVD_B70)
N62640692: TP91.1 UC1.A52(RSVD_A52)
N62640710: TP92.1 UC1.BA70(RSVD_TP_BA70)
N62640712: TP93.1 UC1.BA68(RSVD_TP_BA68)
N62640746: TP94.1 UC1.J71(RSVD_J71)
N62640748: TP95.1 UC1.J68(RSVD_J68)
N62640782: TP96.1 UC1.F61(RSVD_F61)
N62640784: TP97.1 UC1.E61(RSVD_E61)
N62640818: TP98.1 UC1.AW69(RSVD_AW69)
N62640820: TP99.1 UC1.AW68(RSVD_AW68)
N62640854: TP100.1 UC1.AU56(RSVD_AU56)
N62640856: TP101.1 UC1.AW48(RSVD_AW48)
N62640904: TP102.1 UC1.C7(RSVD_C7)
N62640906: TP103.1 UC1.U12(RSVD_U12)
N62640922: TP104.1 UC1.U11(RSVD_U11)
N62640924: TP105.1 UC1.H11(RSVD_H11)
N62641188: TP106.1 UC1.F6(RSVD_F6)
N62641190: TP107.1 UC1.E3(RSVD_E3)
N62641192: TP108.1 UC1.C11(RSVD_C11)
N62641208: TP109.1 UC1.B11(RSVD_B11)
N62641224: TP110.1 UC1.A11(RSVD_A11)
N62641226: TP111.1 UC1.D12(RSVD_D12)
N62641228: TP112.1 UC1.C12(RSVD_C12)
N62641230: TP113.1 UC1.F52(RSVD_F52)
N62685817: RC121.1 UC1.E32(VCC_SENSE)
N62687376: RC142.1 UC1.E33(VSS_SENSE)
N62693311: RC360.1 UC1.E5(PCIE_RCOMPP)
N62870607: T56.1 UC1.AN11(GPP_B0/CORE_VID0)
N62959739: RC124.2 UC1.J70(VCCGT_SENSE)
N62959779: RC183.2 UC1.J69(VSSGT_SENSE)
N62960030: RC126.1 UC1.H21(VSSSA_SENSE)
N62960070: RC185.1 UC1.H20(VCCSA_SENSE)
N63157869: JCP.6 R58.2
N63295136: PC203.1 PR202.2
N63299821: PC229.2 PR215.1
N63299840: PR209.2 PR210.2 PR211.2
N63300161: PC226.2 PR214.1
N63300165: PC217.1 PR212.2
N64422010: CG1.2 CG2.2 CG4.1 QG1.2(G) RG4.2
N64422483: RC350.1 UGSEN1.8(CS)
N64484679: C75.1 Q27.2(G) R9451.2
N64485478: CL17.1 QL2.2(G) RL24.2
N64611066: R267.2 UTPM1.27(SERIRQ)
N64646019: Q28.3(D2) R159.2
N64756017: CV165.1 UV11.6(CT)
N64756162: CV178.1 UV12.6(CT)
N65172917: R9455.2 U16.7(REXT)
N65173045: TP941.1 U16.5(PD#)
N65755761: PQ201.2(G1) PQ201.3(D2) PR216.2
N65782228: TP69.1 UM1.26(ENABLE)
N65787567: CM11.1 UM1.2(VCORE1)
N65865635: TC118.1 UC1.AP13(GPP_A12/BM_BUSY#/ISH_GP6)
N66358052: T60.1 UC1.D63(CATERR#)
N66397047: TC119.1 UC1.AD1(GPP_C20/UART2_RXD)
N66397050: TC120.1 UC1.AD2(GPP_C21/UART2_TXD)
N66563319: Q24.5(G2) Q24.6(D1) R9448.2
N66641811: Q29.1(D) R268.1 R273.2 UTPM1.3(GPX/GPIO2)
N66644838: QC3.5(G2) QC3.6(D1) RC382.2
N67109924: PD6.2 PR18.1 PR19.2
N67222149: RC385.1 UC1.AG3(USB2_ID)
N67222152: RC386.1 UC1.AG4(USB2_VBUSSENSE)
N67239370: R9492.2 R9494.1 U148.B1(EN)
N67267230: RC389.1 UC1.AB3(GPP_C11/UART0_CTS#)
N67782265: RC363.1 UC1.AB7(SD_RCOMP)
N67912715: RC361.1 UC1.AT1(EMMC_RCOMP)
N67976050: D23.2 R722.1 U149.2(ON)
N67979431: C747.2 U149.5(CAP)
N68137601: RC296.1 UC1.AY3(RSVD_AY3)
N68137603: RC295.1 UC1.AY71(VSS_AY71)
N68137613: RC358.2 UC1.C64(PROC_SELECT#)
N68137683: TP927.1 UC1.A69(RSVD_A69)
N68137699: TP928.1 UC1.B69(RSVD_B69)
N68137715: TP929.1 UC1.D71(RSVD_D71)
N68137731: TP930.1 UC1.C70(RSVD_C70)
N68137747: TP931.1 UC1.C54(RSVD_C54)
N68137763: TP932.1 UC1.D54(RSVD_D54)
N68137779: TP933.1 UC1.AY4(TP1)
N68137795: TP934.1 UC1.BB3(TP2)
N68137811: TP935.1 UC1.AR56(ZVM#)
N68137827: TP936.1 UC1.AW71(RSVD_TP_AW71)
N68137843: TP937.1 UC1.AW70(RSVD_TP_AW70)
N68139906: TP938.1 UC1.AP56(MSM#)
N68275593: C8538.1 Q23.4(G) R9447.2
N68447222: RC47.2 T18.1
N68576329: RC48.1 RC348.1 UC3.4(OUT_Y)

Pads without a net: D8 3 4; D9 3 4; D15 1 3; D24 3; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JCP 10; JCR 9; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JFPB 1; JHDD 20 21 22; JHDMI 13 14; JLCD 23; JTOUCH1 7 8 9; JTP 3 4 5 9 10 11 12; JWLBT 6 16 17 19 20 21 22 25 26 27 28 31 32 34 44 46 48 58 59 60 61 62 65 67 68 70 71 73; NOREF#4 1; PU1 4 5 6; PU101 13 14; PU401 17; PU601 35; PU701 2 4 27; PU801 4 7; RPC6 2 4; RPC8 1; RPC10 4; RPC18 5; RPC22 3; RPC26 4 5; RPC200 6; RPE1 8; RPE3 3 6; RPE4 2 3 6 7; U1 8; U3 3; U4 3; U5 24; U6 24; U16 24; U17 3; UA1 35 36 37; UC1 A7 A17 A26 A27 A29 A31 A33 A36 A38 A42 A45 A47 A65 AB4 AB11 AB12 AB13 AB62 AC3 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG1 AG2 AG62 AH7 AH8 AH9 AH10 AH12 AJ62 AK6 AK7 AK9 AK10 AK32 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM1 AM2 AM3 AM4 AM15 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN7 AN13 AN15 AN55 AP1 AP2 AP3 AP4 AP7 AP8 AP43 AP53 AT7 AT52 AU58 AU63 AW7 AW20 AW56 AY5 AY7 AY8 AY9 AY20 AY21 AY56 B7 B17 B26 B27 B29 B31 B33 B36 B38 B42 B45 B47 B52 BA5 BA7 BA8 BA9 BB7 BB9 BB57 BB66 C8 C16 C19 C21 C27 C28 C29 C31 C32 C33 C36 C37 C38 C42 D7 D8 D16 D19 D21 D27 D28 D29 D31 D32 D33 D36 D37 D38 D42 E13 E16 E48 F11 F16 F21 F46 F48 F53 F56 G11 G13 G21 G46 G53 G56 G61 H1 H3 H5 H13 H63 J3 J4 J5 K32 L6 M2 M3 M4 N1 N2 N3 N9 N11 N12 P1 P2 P4 P62 U1 U2 U3 U4 U6 V1 V2 V62 W7 W8 W10 W11 W12; UC3 1; UE1 111; UGSEN1 2 3; UL1 25; UM1 13 14 15 16 17 21 33 34 37 43 44 45 47 48; USROM1 1 2; UTPM1 5 7 10 11 12 15 25 26 28 29 31; UV3 A32 AA5 AA6 AA29 AA31 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC16 AC23 AC25 AD2 AD4 AD10 AD11 AD13 AD16 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK10 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM1 AM3 AM5 AM6 AM8 AM10 AM12 AM14 AM16 AM18 AM20 AM22 AM24 AM26 AM32 J8 J22 J25 K13 K30 L16 L29 L31 M4 M27 M28 M30 N3 N5 N6 N26 N29 N31 P7 P23 P24 P26 P27 P28 P30 R6 R29 R31 T2 T4 T7 T23 T24 T26 T27 T28 T30 U5 U6 U12 U23 U24 U26 U29 U31 V2 V4 V6 V12 V27 V28 V30 W1 W3 W5 W6 W7 W8 W23 W24 W29 W31 Y2 Y4 Y6 Y12 Y23 Y24 Y26 Y27 Y28 Y30; UV5 J1 J9 L1 L9; UV6 J1 J9 L1 L9; UV7 J1 J9 L1 L9; UV8 J1 J9 L1 L9; YV1 2 4

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4828 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1242 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 71 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 639 vias
v5: diameter 0.457, hole 0.203, TOP to BOTTOM, 41 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8VSP_LX: length 1
  TOP w0.508: PR803.2 v1(187.84,170.97)
  vias: v4(186.45,171.98)
3V5V_ON: length 30.8
  IN1 w0.254: v1(220.71,163.99) 220.1,163.99 216.4,167.69 216.4,170.1 215.64,170.86 204.97,170.86 204.71,170.6 v1(203.67,170.6)
  BOTTOM w0.254: 217.02,164.42 217.53,164.93 PR206.2 219.51,164.19 219.51,164.04 PQ201.6 219.71,163.84 220.56,163.84 v1(220.71,163.99) ; 217.02,164.42 PC213.2 217.02,163.56 PR208.1 ; 217.02,164.42 216.31,164.42 215.09,165.64 PU201.1 ; PU202.1 203.12,171.01 203.52,170.6 v1(203.67,170.6)
+0.95VS_VGA: length 27.6
  TOP w0.381: v1(51.33,143.23) 51.53,143.03 CV33.1 ; CV70.1 61.24,153.24 v2(61.11,153.37) ; CV36.1 51.36,143.94 v1(51.28,143.87)
  TOP w0.457: CV30.1 54.96,145.34 55.83,146.2 v2(55.83,146.28) 55.83,146.28 56.94,146.28 CV34.1 CV32.1 ; v2(51.27,145.92) 51.08,146.11 CV35.1 ; CV71.1 56.11,145.42 v2(56.23,145.54) ; CV31.1 52.85,146.74 53.18,147.07 53.18,147.13 v2(53.17,147.15) ; v2(53.69,145.79) 54.32,145.79 54.75,146.22 54.77,146.22 55.52,146.97 55.54,146.97 55.74,147.17 v2(55.77,147.17) ; v2(52.54,145.9) 52.54,145.32 CV29.1 51.94,145.01 v2(51.54,145.4)
  BOTTOM w0.305: v2(53.17,147.15) 53.18,147.15 53.18,147.17 53.54,147.52 UV3.R21 ; UV3.L23 51.15,145.8 v2(51.27,145.92) 51.41,146.06 51.41,146.47 UV3.M22 ; UV3.N22 v2(52.54,145.9) 52.54,145.6 UV3.N24 ; v2(56.23,145.54) 56.23,145.65 56.28,145.7 56.28,145.99 56.37,146.07 56.37,146.57 UV3.V22 ; UV3.R22 53.54,146.29 53.69,146.14 53.69,145.82 ; UV3.L26 50.9,143.23 51.33,143.23 51.33,143.24 v1(51.33,143.23) ; UV3.L24 51.14,145 v2(51.54,145.4) UV3.N23 ; 53.69,145.82 v2(53.69,145.79) ; 53.69,145.82 54.47,146.6 UV3.T22 ; v2(55.83,146.28) 55.83,146.3 55.54,146.6 UV3.U22 ; UV3.L25 51.07,143.87 v1(51.28,143.87) ; v2(55.77,147.17) UV3.U21
  BOTTOM w0.381: UV3.AD14 61.11,152.97 v2(61.11,153.37)
  BOTTOM w0.508: LV5.1 50.55,130.79 CV22.1 51.9,130.79 v1(52,130.69) ; RV47.2 RV48.2 53.09,133.15 v1(53.27,132.98)
  vias: v1(50.81,128.61) v1(51.36,126.71) v1(51.52,128.54) v1(52.04,126.69) v1(52.23,128.58) v1(52.74,126.69) v1(52.91,128.58) v2(57.12,137.94) v4(53.7,131.32)
+0.95VS_VGA_GATE: length 13
  BOTTOM w0.114: v3(39.83,124.49) 40.14,124.8 40.14,126.24 RV129.2
  BOTTOM w0.203: QV10.3 41.63,131.31 40.84,131.31 40.04,130.51 40.04,127.64 39.66,127.26 RV129.2
  BOTTOM w0.381: QV10.3 44.14,132.6 44.51,132.24 RV130.1
+0.675VS:
  vias: v1(149.84,154.59) v1(150.86,154.59) v1(152.25,154.59) v1(164.57,154.72) v1(165.72,154.72) v1(170.67,154.46) v1(171.81,154.46) v4(177.41,161.21)
+0.675VSP: length 1.6
  TOP w0.229: PU301.2 180.16,168.26
  TOP w0.254: 180.16,168.26 180.16,167.72 179.81,167.37 179.76,167.37
  vias: v4(175.71,165.3)
+1.8V_LDO: length 6.1
  TOP w0.254: UA1.3 190.3,56.06 190.5,55.85 190.5,55.68 190.74,55.45 190.74,54.77 CA6.2 191.14,54.19 191.6,53.73 192.03,53.73 v3(192.51,53.25) 192.91,53.25 CA7.1
+1.8VALW: length 81.9
  TOP w0.508: v1(133.41,153.47) 134.32,153.47 136.87,150.92 136.87,150.92 v4(137.69,150.11) 137.94,149.85 137.94,147.8 137.27,147.13 135.32,147.13 134.89,146.71 134.56,146.71 RC173.1
  IN2 w0.508: v1(189.6,157.15) 189.34,156.88 187.2,156.88 183.83,160.25 146.42,160.25 145.63,159.46 140.68,159.46 139.86,158.64 138.22,158.64 136.26,156.68 136.26,155.04 134.69,153.47 v1(133.41,153.47)
  IN3 w0.508: v1(189.6,157.15) 189.87,157.41 189.87,158.13 185.69,162.31 v1(185.69,163.48)
  vias: v1(59.06,176.33) v1(59.7,176.33) v1(60.33,176.33) v1(185.15,163.81) v1(185.71,164.13)
+1.8VALW_PCH: length 45.9
  TOP w0.254: v2(112.12,129.32) 111.61,129.32 110.99,129.94 110.99,131.11 v4(111.42,131.54) 111.77,131.54 112.1,131.87 112.1,134.86 111.52,135.43 CC61.1 111.03,136.39 v2(109.59,137.83)
  TOP w0.508: RC173.2 132.91,146.5 131.86,145.45 v1(130.17,145.45)
  IN1 w0.254: v2(112.12,129.32) 112.12,130.24 112.54,130.65 113.02,130.65 113.68,129.99 114.01,129.99 114.17,129.84 118.88,129.84 121.68,132.63 121.68,133.95
  IN1 w0.508: v1(130.17,145.45) 130.17,144.83 129.18,143.84 129.18,143.25 128.54,142.62 128.54,142.35 126.04,139.85 124.94,139.85 124.02,138.93 124.02,137.46 121.68,135.12 121.68,133.95
  BOTTOM w0.203: UC1.AA1 v2(109.59,137.83)
  BOTTOM w0.254: v2(112.12,129.32) 112.18,129.26 112.18,128.7 UC1.AF16
+1.8VS_VGA: length 161.7
  TOP w0.381: v2(62.54,153.39) 62.54,153.69 CV28.1
  TOP w0.508: 65,171.08 65.4,170.68 v1(65.4,170.1) ; LV4.1 42.65,171.13 41.79,171.99 v1(41.79,172.02)
  IN1 w0.508: v1(66.47,141) 65.9,141 64.37,142.53 64.37,143.16 62.47,145.07 60.56,145.07 59.77,145.85 v2(59.77,147.19) ; v1(63.72,162.28) 63.28,162.72 56.83,162.72 56.39,162.28 54.14,162.28 51.54,164.88 51.54,166.41 50.58,167.37 49.46,167.37 48.83,168 48.83,169.01 48.37,169.47 48.37,169.5 47.38,170.49 47.09,170.49 46.62,170.96 46.62,174.43 46.33,174.71 44.46,174.71 44,174.25 44,173.76 42.25,172.02 v1(41.79,172.02) ; v1(74.66,152.69) 74.66,153.98 74.15,154.49 74.15,156.1 v1(74.63,156.58)
  IN3 w0.254: v1(64.13,170.86) 64.13,171.16 65.6,172.64 81.73,172.64 82.48,173.39 87.74,173.39 90.47,176.12 120.59,176.12 123.81,172.9 v1(123.81,172.88)
  IN3 w0.508: v1(41.79,172.02) 41.75,172.02 41.31,171.58 39.23,171.58 37.3,169.65 31.63,169.65 30.82,170.47 26.07,170.47 24.77,169.17 v1(24.77,168.46)
  BOTTOM w0.254: v1(24.77,168.46) 25,168.69 26.02,168.69 CV150.1 25.88,169.15 25.48,169.15 24.9,169.73 24.9,170.31 24.8,170.41 UV9.8 ; UV3.AD17 60.72,150.18 v2(60.72,149.8) ; PR644.1 123.43,173.26 v1(123.81,172.88)
  BOTTOM w0.381: v2(62.54,153.39) UV3.AF14 ; UV3.AA20 v2(58.77,148.17) 59.2,148.6 UV3.AB20 ; UV3.AM30 v1(66.47,141) ; v2(58.77,147.17) UV3.AA21
  BOTTOM w0.457: UV3.AB21 59.36,147.6 v2(59.77,147.19)
  BOTTOM w0.508: RV125.2 73.9,157.69 73.9,156.72 RV123.2 74.03,156.58 v1(74.63,156.58) ; RV55.1 63.86,167.55 63.94,167.62 RV54.1 64.24,168.43 64.13,168.55 v1(64.13,170.86) ; LV3.1 43.82,174.45 43.42,174.86 42.25,174.86 41.08,173.69 40.69,173.69 40.22,173.21 40.22,171.84 40.49,171.56 41.33,171.56 v1(41.79,172.02) ; RV104.1 70.44,148.09 71.3,148.96 71.3,150.48
  vias: v1(63.77,158.24) v1(63.91,157.21) v1(71.6,154.38) v4(64.51,175.56)
+1.8VSP: length 15.4
  IN3 w0.381: v1(193.71,174.22) 192.91,173.42 192.91,165.05 191.42,163.57 v1(187.62,163.57)
+1.35V: length 120.7
  TOP w0.305: CC340.1 118.29,123.27 v2(118,122.98) ; v2(118,120.23) 118.29,120.53 CC341.1 ; 119.99,122.96 CC342.1 ; CC342.1 119.04,122.96 ; CC342.1 119.47,122.61 ; v2(118,112.92) 118.32,113.24 CC344.1 ; v2(118,116.57) 118.29,116.87 CC343.1
  TOP w0.381: CC94.1 119.11,112.68 118.42,113.37 CC344.1 ; CC526.1 114.89,121.7 114.88,121.71
  TOP w0.508: 159.29,89.87 159.8,89.36 RD1.1 ; 159.29,89.87 159.29,97.42 158.23,98.47 152.89,98.47 151.24,100.12 151.24,102.78 ; 159.29,89.87 157.08,89.87 156.89,90.06 153.48,90.06 152.35,88.93 152.35,87.92 150.96,86.52 148.19,86.52 147.68,87.03 RD15.1
  VCC w0.076: 130.78,115.67 130.96,115.84
  BOTTOM w0.114: UC1.AL23 v2(114.58,124.4)
  BOTTOM w0.152: UC1.BB41 121.91,114.28
  BOTTOM w0.178: v2(122.36,124.41) 122.19,124.24 121.25,124.24 121.2,124.22 UC1.BB23 ; v2(121.99,108.18) 121.98,108.17 121.44,108.17 121.15,108.17 UC1.BB51 ; v2(121.98,119.25) 121.23,119.25 121.2,119.24 UC1.BB32 ; UC1.BB47 121.61,110.63 121.96,110.63 v2(122.03,110.67)
  BOTTOM w0.254: UC1.AM40 v2(115.4,114.68) ; UC1.AU23 v2(118,122.98) ; UC1.AU28 v2(118,120.23) ; UC1.AU35 v2(118,116.57) ; 121.91,114.28 121.93,114.27 v2(122.87,114.27) ; UC1.AU42 v2(118,112.92)
  BOTTOM w0.305: JDIMM1.106 170.24,124.25 v1(170.23,124.25) ; v1(170.23,117.02) 170.26,117.05 JDIMM1.82 172.79,117.05 173.02,117.28 173.02,118.51 172.68,118.85 171.75,118.85 JDIMM1.88 ; v1(165.03,118.58) 165,118.55 JDIMM1.87 ; JDIMM1.124 171.74,129.66 170.43,129.66 v1(170.37,129.6) ; v1(165.72,122.77) 165.1,122.15 JDIMM1.99 ; v1(165.04,114.99) 165,114.95 JDIMM1.75 ; JDIMM1.111 162.36,125.75 v1(162.16,125.95) ; v1(160.71,127.24) 162.26,127.24 162.57,127.55 JDIMM1.117 ; JDIMM1.105 v1(164.97,123.95) ; JDIMM1.118 171.75,127.85 170.27,127.85 v1(170.23,127.81) ; v1(170.38,114.79) 170.84,115.25 JDIMM1.76 ; JDIMM1.94 170.31,120.65 v1(170.23,120.57) ; JDIMM1.100 170.33,122.45 v1(170.23,122.35) ; JDIMM1.123 v1(165.46,129.35)
  BOTTOM w0.356: JDIMM2.118 159.44,127.85 v1(160.05,127.24) ; JDIMM2.105 149.07,123.95 v1(148.9,123.78) 148.9,122.51 149.26,122.15 JDIMM2.99 ; JDIMM2.106 159.56,124.25 160.13,123.68 v1(160.13,123.55) 160.13,123.05 159.53,122.45 JDIMM2.100 ; v1(152.03,118.64) 151.94,118.55 JDIMM2.87 ; JDIMM1.112 170.56,126.05 v1(170.23,125.72) ; v1(152.09,116.37) 151.85,116.37 151.46,116.75 JDIMM2.81 ; JDIMM2.88 159.44,118.85 160.15,118.14 v1(160.15,117.97) 160.15,117.4 159.79,117.05 JDIMM2.82 ; JDIMM1.81 162.21,116.75 v1(161.78,116.31) ; JDIMM2.124 157.26,129.65 v1(157.21,129.7) ; JDIMM2.76 157.68,115.25 156.7,114.27 v1(156.7,113.98) ; v1(152,120.56) 151.69,120.56 151.48,120.35 JDIMM2.93 ; v1(160.32,120.04) 159.71,120.65 JDIMM2.94 ; JDIMM1.93 164.81,120.35 165.08,120.08 v1(165.08,119.64) ; v1(153.67,112.69) 153.67,112.96 151.69,114.95 JDIMM2.75 ; v1(151.77,127.6) 151.72,127.55 JDIMM2.117 ; JDIMM2.123 151.47,129.35 v1(151.8,129.68) ; JDIMM2.112 v1(157.18,126.05) ; JDIMM2.111 151.5,125.75 v1(151.7,125.55)
  vias: v1(63.11,175.05) v1(63.11,174.42) v1(63.75,175.05) v1(63.75,174.42) v1(66.67,175.05) v1(66.67,173.53) v1(67.05,174.29) v1(67.43,175.05) v1(67.68,173.53) v1(67.81,174.29) v1(68.19,175.05) v1(68.45,173.53) v1(68.57,174.29) v1(68.95,175.05) v1(69.21,173.53) v1(69.33,174.29) v1(113.81,104.64) v1(128.94,166.9) v1(128.94,166.26) v1(128.95,167.54) v1(129.54,167.87) v1(129.53,167.24) v1(129.53,166.6) v1(129.55,165.95) v1(130.24,167.58) v1(130.23,166.94) v1(130.23,166.31) v1(151.5,165.17) v1(151.5,164.54) v1(152.13,164.37) v1(152.24,165.65) v1(152.16,165.02) v1(152.82,166.62) v1(152.8,165.98) v1(152.77,165.25) v1(152.81,164.61) v1(153.42,166.99) v1(153.43,166.35) v1(153.41,165.71) v1(153.41,165.08) v1(153.42,164.42) v1(154.02,167.31) v1(154.02,166.67) v1(154.01,166.03) v1(154,165.39) v1(154,164.76) v1(154.62,166.43) v1(154.61,165.79) v1(154.61,165.16) v1(154.62,164.5) v1(154.7,167.07) v1(173.22,105.46) v1(173.22,104.69) v1(173.22,103.04) v1(173.22,102.28) v1(247.13,92.38) v1(247.64,91.87) v2(113.81,107.39) v2(113.78,106.5) v2(113.81,105.61) v2(115.31,109.24) v2(115.36,107.49) v4(155.06,160.17)
+1.35VP: length 76.3
  TOP w0.229: PU301.5 181.36,168.21
  TOP w0.254: PC314.1 182.49,165.82 PR305.1 ; v1(181.65,167.71) 181.65,167.92 181.36,168.21
  TOP w0.381: v1(183.13,165.02) 183.13,165.19 PR305.1
  TOP w1.524: 174.81,169.04 173.36,167.6 173.36,165.41 171.69,163.74 161.91,163.74 160,165.64 158.87,165.64
  IN3 w0.381: v1(183.13,165.02) 182.14,165.02 180.88,163.76 165.06,163.76 164.84,163.98 159.31,163.98 158.91,163.58 157.42,163.58 157.02,163.99 v1(157.02,164.33) ; v1(181.65,167.71) 181.65,165.27 180.65,164.27 165.31,164.27 165.09,164.49 v1(158.96,164.49)
  vias: v1(157.02,166.94) v1(157.02,166.3) v1(157.02,165.67) v1(157.02,165.03) v1(157.66,166.36) v1(157.66,165.72) v1(157.66,165.08) v1(157.66,164.45) v1(158.33,164.49) v4(158.49,163.75)
+1.35VS_VGA: length 234.4
  TOP w0.152: v1(28.7,160.03) 28.7,159.87 28.33,159.5 27.89,159.5 27.49,159.9 UV7.B2
  TOP w0.203: UV6.H2 22.09,139.54 21.33,139.54 UV6.K2 21.31,140.35 21.31,140.92 ; v2(26.6,153.74) 26.51,153.83 UV7.C9
  TOP w0.229: 21.49,153.87 21.32,154.04 21.32,154.68 UV7.K8
  TOP w0.254: v1(17.32,133.9) 17.32,133.44 15.67,131.8 CV99.1 ; 26.09,133 26.09,133.22 25.52,133.79 v1(25.28,133.79) ; UV7.G7 23.13,156.08 23.13,156.89 v1(23.08,156.94) ; 21.49,153.87 v2(22.07,153.87) 22.08,153.87 UV7.H9 ; CV96.1 16.56,131.22 18.89,133.55 v1(18.89,133.91) ; CV92.1 23.8,130.96 23.39,131.37 23.39,132.2 22.68,132.91 22.68,133.65 v1(22.63,133.7) 22.63,133.72 22.51,133.84 UV6.H9 ; v1(24.9,131.3) 24.92,131.32 24.92,132.42 24.53,132.81 24.08,132.81 23.73,133.17 23.73,133.74 v1(23.78,133.79) ; 21.31,140.92 21.79,141.41 v1(21.79,141.6) ; v1(19.06,153.75) 18.95,153.75 18.51,154.19 UV7.N9 ; UV6.C9 26.51,133.97 26.65,133.83 v1(26.65,133.8) ; UV6.C1 26.53,140.74 26.53,140.74 27.31,139.96 UV6.B2
  TOP w0.305: UV7.K2 21.06,160.05 21.07,160.05 v1(21.31,160.28) ; UV7.D9 25.68,154.27 25.68,153.92 25.58,153.82 v2(25.58,153.75) ; CV106.1 23.62,163.37 23.62,161.18 v1(23.7,161.11) 24.11,160.7 UV7.F1 ; v1(22.92,160.32) 22.59,159.98 22.59,159.98 UV7.H2 ; UV7.N1 18.17,161.04 18.17,161.09 17.61,161.65 17.61,161.65 v1(17.46,161.8) ; CV90.1 26.09,131.31 26.09,133 ; v2(25.58,153.75) 25.55,153.79 25.42,153.79 UV7.E9 ; v2(25.58,153.75) 25.58,153.68 25.86,153.4 25.86,152.97 25.71,152.81 v1(25.71,151.74) ; v1(17.28,141.24) 17.17,141.13 17.16,141.13 16.91,140.88 UV6.R1 ; CV110.1 26.47,161.93 26.79,161.61 26.81,161.61 26.92,161.49 ; v1(18.89,133.91) 18.51,134.29 UV6.N9 ; UV6.E9 24.91,134.16 v1(25.28,133.79) 25.28,133.89 25.71,134.32 UV6.D9 ; v2(18.95,141.18) 18.53,140.76 UV6.N1 ; UV6.C1 26.51,140.76 26.51,141.34 v1(26.54,141.37) ; UV6.D2 25.7,139.96 v2(25.31,140.35) ; 26.92,161.49 v1(26.9,161.49) ; 26.92,161.49 26.95,161.49 26.69,161.23 26.69,160.87 UV7.C1 ; UV7.A1 28.32,160.91 28.33,160.91 28.5,161.08 v1(28.5,161.46) 28.5,162 27.87,162.64 CV112.1 ; v1(16.52,161.32) 16.52,161.09 UV7.R1 ; UV6.G7 23.19,136.08 v1(23.19,136.65) ; UV6.A8 27.83,134.88 27.83,134.87 v2(27.72,134.76) ; UV6.A1 28.22,140.87 v1(28.22,141.61) ; UV7.R9 16.91,153.84 16.99,153.76 v1(17.22,153.76) ; UV6.F1 24.11,140.96 24.16,141.01 24.16,141.43 24.16,141.43 24.16,141.49 23.92,141.73 23.88,141.73 23.73,141.88 v1(23.57,141.88) ; UV6.K8 21.3,134.77 v1(21.31,134.77) ; v1(28.55,154.69) 28.51,154.69 28.11,155.09 UV7.A8 ; v1(17.32,133.9) 16.91,134.31 UV6.R9 ; v1(23.68,153.78) 23.68,152.4 v1(24.31,151.77) ; UV7.D2 25.52,160.09 v2(25.3,160.3) ; v1(24.9,131.3) 25.66,130.55 CV91.1
  TOP w0.381: CV4.1 49.97,155.43 49.97,155.81 50.15,155.99 v2(50.22,155.99) ; v2(18.95,141.18) 17.96,142.16 CV98.1 ; CV7.1 48.06,148.18 v2(48.06,148.52) ; v1(16.81,151.94) 17.22,152.34 v1(17.22,153.76) 15.27,151.81 CV107.1 ; CV8.1 50.15,158.17 v2(49.35,158.17) ; CV97.1 16.56,141.96 v1(17.28,141.24) ; v1(49.94,154.54) 50,154.48 CV3.1 ; v2(49.35,156.6) 49.35,157.32 CV1.1 ; CV6.1 49.37,146.3 v2(50.01,146.3) ; v1(19.06,153.75) 19.06,153.71 18.98,153.63 18.98,151.56 CV109.1 ; CV2.1 47.53,150.55 47.55,150.55 v2(47.55,151.04)
  TOP w0.508: v1(23.57,141.88) 23.6,141.9 23.6,143.05 24.06,143.51 CV93.1 ; CV114.1 25.78,150.95 25.78,151.67 v1(25.71,151.74) ; CV115.1 16.82,151.93 v1(16.81,151.94) ; v1(28.22,141.61) 28.22,142.23 27.65,142.79 27.65,144.2 CV94.1 ; v1(24.31,151.77) CV111.1 ; v1(20.19,149.09) 19.79,149.49 RV30.1 ; CV105.1 19.7,163.8 18.92,163.02 v1(18.76,163.02) ; CV89.1 19.92,143.6 v1(20.09,143.43) ; CV95.1 26.09,143.57 26.57,143.09 26.57,141.39 v1(26.54,141.37) ; v1(17.15,163.32) 17.85,163.32 18.09,163.56 CV108.1 ; CV113.1 21.06,163.83 v1(21.57,163.32) ; v2(49.33,144.6) 49.53,144.4 50,143.93 CV5.1 ; v1(21.01,145.84) RV24.1
  BOTTOM w0.203: v1(22.63,133.7) 22.63,133.71 22.92,134 22.92,134.75 UV5.H2 ; 21.31,154.07 21.3,154.09 21.3,154.71 UV7.K8 ; UV5.K8 21.29,140.34 21.29,140.91 21.47,141.08
  BOTTOM w0.254: v1(21.79,141.6) 21.79,141.41 21.47,141.08 ; v1(23.04,141.4) 23.04,141.29 UV5.H9 ; UV7.N9 18.63,154.18 18.63,154.07 18.95,153.75 v1(19.06,153.75) ; v1(26.54,141.37) 26.51,141.34 26.51,140.76 UV5.C9 ; v1(22.08,154.7) 22.48,155.1 UV8.H2 ; UV8.H9 22.67,160.54 22.69,160.54 22.92,160.32 v1(22.92,160.32) ; UV8.D2 26.24,154.57 UV7.C9 ; UV8.A8 28.53,159.9 28.66,160.03 v1(28.7,160.03) ; v2(18.95,141.18) 18.92,141.18 18.51,140.76 UV5.N9 ; v2(22.07,153.87) 21.52,153.87 21.31,154.07
  BOTTOM w0.305: v1(16.52,161.32) 16.52,161.09 UV7.R1 ; UV7.C1 26.51,161.06 26.95,161.49 26.92,161.49 ; UV7.C9 26.51,153.83 v2(26.6,153.74) ; v1(21.31,160.28) 21.07,160.04 21.06,160.04 UV7.K2 ; 25.31,140.35 25.31,140.35 UV5.E9 ; 25.31,140.35 25.71,140.75 UV5.D9 ; 25.31,140.35 v2(25.31,140.35) ; v1(26.65,133.8) 26.65,134.21 UV5.C1 ; v1(23.2,138.62) 23.2,139.05 UV5.G7 ; UV7.N1 18.51,160.71 18.12,161.09 18.12,161.12 17.61,161.63 17.61,161.65 v1(17.46,161.8) ; v1(17.32,133.9) 16.91,134.31 UV5.R1 ; UV5.F1 24.11,134.12 v1(23.78,133.79) ; UV8.D9 25.69,160.7 v2(25.3,160.3) UV8.E9 ; v1(17.22,153.76) 17.27,153.81 17.2,153.88 17.2,154 UV7.R9 ; v2(48.06,148.52) 48.1,148.57 48.1,149.16 UV3.H19 ; 26.92,161.49 v1(26.9,161.49) ; 26.92,161.49 26.81,161.61 26.8,161.61 26.47,161.94 CV110.1 ; UV5.A8 28.34,140.19 28.36,140.19 v1(28.53,140.36) ; UV8.A1 28.11,154.28 28.53,153.86 v1(28.53,153.61) ; UV3.H13 48.56,153.57 v2(48.56,153.29) ; v2(48.53,144.62) 48.8,144.89 48.83,144.89 UV3.J24 ; UV8.H9 22.51,160.7 22.51,161.12 22.36,161.27 22.36,161.73 23.14,162.5 23.14,164.02 CV121.1 CV122.1 ; UV8.F1 23.98,154.17 23.98,154.08 v1(23.68,153.78) ; UV5.B2 27.33,135.16 v2(27.72,134.76) 28.11,134.38 UV5.A1 ; CV126.1 27.55,162.41 v1(28.5,161.46) ; v1(18.89,133.91) 18.51,134.29 UV5.N1 ; v2(47.55,151.04) 47.55,151.16 47.99,151.6 UV3.H16 ; v1(24.9,131.3) 24.44,130.84 CV86.1 ; UV5.D2 25.33,135.54 25.33,135.54 v2(25.31,135.55) ; UV8.B2 27.31,155.09 27.7,154.7 v2(27.71,154.7) ; UV3.L22 50.3,146.6 v2(50.01,146.3) ; UV8.G7 23.45,158.95 23.45,157.7 v1(23.52,157.63) ; UV3.K10 49.41,155.87 v2(49.41,155.76)
  BOTTOM w0.381: CV117.1 20.12,151.56 22,153.44 22,153.79 v2(22.07,153.87) ; v1(35.83,126.24) 35.83,126.85 36.52,127.54 37.95,127.54 38.87,128.45 38.87,133.84 39.96,134.93 44.66,134.93 45.9,133.69 RV7.1 46.48,133.29 46.5,133.29 46.69,133.1 48.39,133.1 49.04,132.46 49.9,132.46 51.13,133.69 RV5.1 ; v2(18.95,141.18) 18.95,143.04 18.49,143.5 CV85.1 ; v1(19.06,153.75) 18.78,153.47 18.78,151.36 CV109.1 ; UV3.J9 48.95,157 v2(49.35,156.6) ; v2(49.35,156.6) 49.74,156.99 UV3.K9 ; v2(49.35,156.6) 48.95,156.2 UV3.J10 ; v1(17.22,153.76) 17.22,152.94 17.41,152.75 17.41,151.39 CV118.1 ; UV3.L13 UV3.L12 50.09,154.4 v1(49.94,154.54) ; UV3.K23 49.74,146.03 v2(50.01,146.3) ; UV3.L11 50.54,155.67 v2(50.22,155.99) ; v2(49.33,144.6) 49.73,145 UV3.K24 UV3.J23 ; UV3.L20 UV3.L21 50.36,147.42 49.93,147.42 v2(49.91,147.4) ; UV5.R9 17,140.85 17,140.87 17.28,141.15 v1(17.28,141.24) ; CV95.1 CV84.1 24.5,142.91 23.57,141.98 v1(23.57,141.88) ; v1(14.08,161.45) 13.44,161.45 CV116.1 13.7,162.21 v1(14.08,162.21) 16.12,162.21 16.52,161.82 v1(16.52,161.32) ; CV81.1 18.89,131.39 v1(18.89,133.91) ; UV5.K2 21.29,134.78 21.3,134.78 v1(21.31,134.77) ; CV80.1 23.59,144.22 23.59,143.4 v1(21.79,141.6) ; CV87.1 17.33,131.18 17.33,133.89 v1(17.32,133.9)
  BOTTOM w0.508: CV97.1 16.56,141.96 v1(17.28,141.24) ; CV88.1 27.7,130.97 v1(27.7,131.7) ; RV36.1 22.37,149.85 v1(22.37,149.09) ; CV120.1 16.72,152.03 v1(16.81,151.94) ; CV125.1 13.69,153.72 14.48,153.72 15.06,153.13 15.84,153.13 16.38,153.68 17.14,153.68 v1(17.22,153.76) ; v1(21.57,163.32) 22.02,163.77 CV119.1 ; RV18.1 20.73,145.56 v1(21.01,145.84) ; v1(14.53,131.69) CV78.1 ; CV79.1 28.63,131.6 v1(28.71,131.68)
  vias: v1(49.36,171.7) v1(49.74,171.19) v1(50.73,172.73) v1(50.92,173.4) v1(51.37,172.78) v1(51.68,173.4) v1(52.06,172.77) v1(52.44,173.4) v1(52.82,172.77) v1(53.21,173.4) v1(57.5,174.26) v1(58.13,174.26) v1(58.29,174.9) v1(58.77,174.26) v1(58.92,174.9) v1(59.4,174.29) v1(59.56,174.93)
+1.65V_LDO: length 6.7
  TOP w0.203: CA8.1 180.96,53.52 181.15,53.72 181.96,53.72 182.64,54.4 182.65,54.4 183.06,54.81 183.06,54.82 183.9,55.66 UA1.29
  TOP w0.508: CA8.1 CA9.1 v4(179.13,53.19)
+1VALW: length 26.6
  TOP w0.254: U148.A1 76.3,122.81 76.32,122.83
  TOP w0.508: U149.3 77.47,114.69 C749.2 77.94,114.67 77.94,115.04 78.22,115.32 v1(78.22,115.49) ; v1(82.42,115.51) 83.56,115.51 84.52,114.55 84.52,112.52 RC362.2
  IN2 w0.508: v1(74.41,127.43) 74.47,127.43 76.7,125.19 76.7,122.87 v1(78.02,121.55) 77.97,121.5 77.97,115.74 v1(78.22,115.49) 78.22,115.18 78.61,114.8 81.7,114.8 v1(82.42,115.51)
  vias: v1(42.77,124.72) v1(43.18,124.19) v1(43.4,124.8) v1(43.84,124.19) v1(44.06,124.82) v1(44.55,124.34) v1(73.02,127.81) v1(73.65,127.94) v1(73.68,127.3) v1(73.91,128.7) v1(74.41,128.06) v1(87.78,147.48) v1(87.78,146.84) v1(88.13,148.08) v1(88.41,147.48) v1(88.82,148.05) v1(89.45,148.1) v1(90.11,148.08) v1(90.8,148.64) v1(91.13,149.2) v1(91.43,148.64) v1(91.48,149.75) v1(91.79,149.2) v1(92.12,149.75) v1(92.09,148.64) v1(92.45,149.2) v1(92.78,149.75) v1(135.13,164.75) v1(135.16,166.03) v1(135.16,165.39) v1(135.16,164.12) v1(135.74,166.33) v1(135.74,165.68) v1(135.72,165.05) v1(135.74,164.41) v1(136.38,166.32) v1(136.38,165.68) v1(136.36,165.04) v1(136.38,164.41) v1(136.99,166.71) v1(136.98,166.06) v1(136.98,165.42) v1(136.96,164.78) v1(136.98,164.15) v1(137.62,166.71) v1(137.62,166.05) v1(137.62,165.41) v1(137.6,164.78) v1(137.62,164.14) v4(47.85,127.76)
+1VALW_CLK2: length 23.4
  IN3 w0.254: v2(103.82,126.75) 103.82,126.85 103.57,127.1 101.01,127.1 98.37,129.74 91.81,129.74 90.23,131.33 84.17,131.33 v1(83.31,130.46)
  BOTTOM w0.254: UC1.K19 v2(103.82,126.75)
  vias: v4(83.79,129.81)
+1VALW_CLK4: length 0.5
  BOTTOM w0.254: v2(106.28,125.38) 106.21,125.38 UC1.N20
  vias: v1(81.77,126.32) v4(81.53,125.65)
+1VALW_CLK5: length 28.1
  TOP w0.254: v1(82.29,129.89) 82.76,129.42 LC5.1
  IN3 w0.254: v2(104.63,126.65) 104.63,126.8 103.42,128.01 101.49,128.01 101.01,128.49 100.09,128.49 98.44,130.15 92.14,130.15 90.56,131.73 83.8,131.73 82.29,130.22 v1(82.29,129.89)
  BOTTOM w0.254: UC1.L19 104.75,126.65 v2(104.63,126.65)
+1VALW_PCH: length 54.7
  TOP w0.254: v2(109.68,125.98) 109.52,125.98 109.15,126.35 CC95.1 109.15,126.88 ; v2(105.53,125.34) 105.12,125.76 105.12,126.59 CC49.1 105.21,126.86 v2(104.64,127.43)
  TOP w0.381: RC374.2 RC373.2 84.7,110.1 85.29,110.69 v1(85.59,110.69)
  TOP w0.508: v2(109.39,134.69) 109.39,134.02 109.34,133.98 LC2.1
  IN1 w0.254: v2(104.64,127.43) 104.63,127.44 104.63,128.34 105.67,129.38 105.67,134.27 105.39,134.55
  IN1 w0.508: v2(103.07,139.57) 103.5,139.57 103.95,139.11 103.95,137.3 105.39,135.86 105.39,134.55
  BOTTOM w0.102: v2(98,129.27) 98.97,129.27 98.97,129.27 98.98,129.26 UC1.A14
  BOTTOM w0.203: v2(113.84,125.32) 113.91,125.32 UC1.AK20 ; UC1.T1 106.94,137.66 v2(106.95,137.67) ; v2(98.13,131.81) 98.16,131.74 UC1.A10
  BOTTOM w0.254: v2(105.53,125.34) 105.37,125.34 UC1.L21 ; UC1.AB17 110.04,127.64 v2(109.68,127.28) 109.39,126.99 UC1.Y18 ; UC1.P18 106.77,126.99 v2(107.09,127.31) ; UC1.AB20 109.98,125.69 v2(109.68,125.98) 109.74,125.98 UC1.AB19 ; v2(104.64,127.43) 104.44,127.43 UC1.K17
  BOTTOM w0.381: v1(85.87,130.28) 85.87,130.02 83.19,127.34 83.19,117.92 85.59,115.51 v1(85.59,110.69)
  BOTTOM w0.508: v2(103.07,139.57) 103.5,139.57 104.29,138.78 UC1.L1
  vias: v1(86.32,130.73) v1(86.66,134.09) v1(89.15,143.07) v1(89.54,143.62) v1(89.55,144.29) v1(90.19,144.29) v1(90.18,143.62) v4(86.48,140.13)
+1VALW_PLL: length 3.6
  TOP w0.508: v2(108.85,129.22) 109.3,129.22 v3(109.67,129.59) 109.67,129.89 109.44,130.12 CC539.1 109.44,131.43 LC2.2
  BOTTOM w0.254: v2(108.85,129.22) 108.57,128.94 UC1.V15
+1VS_VGA: length 1.6
  BOTTOM w0.114: 49.59,126.27 v4(49.59,124.64)
+3V_AVDD_HP: length 12.9
  TOP w0.203: CA13.1 181.26,58.58 v4(182.25,58.58) 182.86,58.58 183.79,57.66 UA1.24
  TOP w0.254: RA2.1 180.31,58.17 180.85,58.17 CA13.1
  TOP w0.508: RA3.2 180.41,60.19 180.08,59.86 180.08,59.23 179.72,58.87 RA2.1 178.61,59.87 177.78,59.87 177.06,60.6 RA30.1
+3V_DDR: length 23.1
  TOP w0.508: v1(176.65,139.72) 175.96,139.72 175.46,139.21 RD23.1 ; U17.1 179.11,153.9 C751.1 v4(178.94,148.81) v1(178.94,146.22)
  IN1 w0.508: v1(176.65,139.72) 176.7,139.77 176.7,141.4 178.3,143 178.3,145.59 v1(178.94,146.22)
+3V_LDO: length 7.1
  TOP w0.203: UA1.27 183.62,56.46 183.36,56.19 181.36,56.19 181.13,55.96 180.04,55.96 v3(180.02,55.99) 179.76,55.99 179.53,56.22 CA11.1
  TOP w0.508: CA11.1 179.04,56.69 178.8,56.93 CA10.1
+3V_PWRGD: length 16.3
  TOP w0.254: PR210.1 205.79,170.52 v1(205.79,169.67)
  IN1 w0.254: v1(215.81,165.67) 215.64,165.83 215.64,168.83 214.24,170.23 206.37,170.23 205.81,169.67 v1(205.79,169.67)
  BOTTOM w0.254: PU201.2 215.2,166.09 215.63,165.67 v1(215.81,165.67)
+3V_SPI: length 128.4
  TOP w0.305: UTPM1.22 131.4,160.54 131.93,161.07 C8496.1 ; C8497.1 129.38,156.78 UTPM1.14 ; 126.4,162.77 126.28,162.66 126.28,161.54 UTPM1.1
  TOP w0.381: C8498.1 124.66,161.62 122.87,161.62 122.16,160.9 120.44,160.9 Q29.3
  TOP w0.508: C8496.1 132.62,162.1 C8499.1 v1(131.43,162.34) ; 130.41,126.85 130.41,127.67 129.94,128.14 CC25.1 129.93,128.43 129.14,128.43 128.78,128.07 128.78,125.87 129.49,125.15 129.49,123.85 131.68,121.66 133.84,121.66 138.82,126.64 ; v1(126.4,164.08) 126.4,163.38 C8498.1 126.41,162.78 126.4,162.77 ; v1(137.87,129.42) 138.06,129.23 138.44,129.23 138.85,128.81 CC26.1 ; v1(129.48,154.88) 129.74,154.88 R261.2 129.85,155.73 C8497.1 ; RC110.2 142.05,136.99 v1(142.37,136.67) 142.69,136.99 RC310.2 RC117.1 RC118.1
  IN1 w0.508: v1(129.48,154.88) 129.48,154.62 130.41,153.7 132,153.7 133.01,152.68 135.84,152.68 138.88,149.64 v1(139.66,149.64)
  IN2 w0.254: 119.19,128.01 114.6,128.01 114.03,128.58 v2(113.05,128.58)
  IN2 w0.508: 119.19,128.01 120.08,128.01 120.95,128.88 120.95,135.38 125.16,139.59 133.77,139.59 139.84,145.67 139.84,149.46 v1(139.66,149.64)
  BOTTOM w0.254: v2(113.05,128.58) 113.16,128.58 UC1.AJ16
  BOTTOM w0.508: v1(139.66,149.64) 139.66,147.52 140.43,146.76 140.43,142.49 139.77,141.83 139.77,138.07 141.17,136.67 v1(142.37,136.67) 144.03,136.67 144.66,136.04 144.66,132.97 140.96,129.28 138.01,129.28 v1(137.87,129.42)
  vias: v4(125.85,158.31)
+3V_VIN:
  vias: v4(212.46,169.72)
+3V_WLAN: length 3.4
  BOTTOM w0.381: v1(250.55,153.58) 250.55,153.96 250.7,154.1 JWLBT.74 ; JWLBT.72 v1(251.2,153.58)
  vias: v1(250.55,152.94) v1(250.56,152.29) v1(251.19,152.94) v1(251.2,152.29) v1(268.21,153.96) v1(268.84,153.96) v4(250.44,144.7)
+3VALW: length 574.2
  TOP w0.203: RPE2.2 182.74,110.53 v1(182.48,110.27) 182.24,110.51 RPE2.1 ; RPE2.4 183.74,110.51 v1(183.5,110.27) 183.24,110.53 RPE2.3
  TOP w0.254: RPC6.8 136.39,149.63 v1(136.63,149.38) 136.38,149.13 RPC6.7 ; 75.94,115.24 76.47,115.77 U149.1 ; PR11.1 225.1,171.05 221.7,174.46 209.21,174.46 207.01,172.25 PR209.1 207.01,162.6 208.02,161.59 v4(208.02,160.57) v1(208.02,151.3) ; RPC6.5 136.39,148.13 v1(136.63,148.37) 136.38,148.63 RPC6.6
  TOP w0.508: v1(70.86,121.71) 72.1,120.47 74.06,120.47 74.64,119.89 UC3.5 ; RC379.1 v1(201.39,124.96) ; RC310.1 v1(143.11,138.72) ; RA2.2 176.94,58.76 175.13,56.94 v1(175.13,56.69) ; RE48.1 178.12,150.39 176.65,151.86 176.65,154.2 179.44,156.99 v1(179.44,157.78) 179.44,158.29 179.7,158.54 C750.1 180.33,157.84 180.27,157.78 U17.5 ; PD4.1 277.78,104.07 278.14,103.72 PR4.2 278.14,102.19 277.49,101.54 v1(277.49,101.52) ; RG1.1 171.63,110.98 QG1.3 172.5,111.85 CG1.1 v1(171.81,113.44) ; v1(280.04,44.48) 280.04,37.78 279.61,37.34 279.61,33.28 279.13,32.8 279.13,30.66 v4(280.17,29.62) 281.06,28.73 R84.1 ; RE49.1 201.03,127.17 v1(201.41,126.79) ; RC382.1 83.64,95.83 82.47,97 82.47,101.24 83.83,102.6 83.83,113.93 v1(82.92,114.83) ; 75.94,115.24 75.63,114.93 R722.2 75.44,114.48 74.66,114.48 C748.1 74.62,114.31 v1(73.91,113.6)
  TOP w0.762: RL1.1 246.81,99.22 v1(244.33,99.22)
  IN1 w0.508: v1(244.46,94.93) 245.55,94.93 248.47,92 248.47,91.53 249.42,90.59 249.42,88.92 253.18,85.16 253.18,84.44 v1(251.71,82.96) ; v1(136.63,148.37) 136.63,148.27 137.41,147.49 140.16,147.49 141.57,148.9 141.7,148.9 145.21,152.41 145.63,152.41 147.82,154.61 v1(148.46,154.61) ; 268.98,133.52 268.98,132.54 273.3,128.22 273.3,119.17 274.95,117.52 276.09,117.52 v1(276.34,117.27) ; v1(277.49,101.52) 277.49,101.01 276.6,100.12 259.46,100.12 258.55,99.22 v1(244.33,99.22) ; v1(183.5,110.27) v1(182.48,110.27)
  IN1 w0.762: v1(174.87,121.97) 175.75,122.85 175.75,126.4 177.27,127.92 177.27,136.2 179.42,138.35 180.21,138.35 181.68,139.82 186.22,139.82 187.51,138.53 v1(200.47,138.53) 200.69,138.75 213.35,138.75 213.63,139.04 215.13,139.04
  IN2 w0.508: v1(175.13,56.69) 175.82,56.69 176.7,57.57 176.7,57.59 177.25,58.14 178.48,58.14 181.48,61.13 183.76,61.13 184.35,60.55 187.65,60.55 189.58,58.62 192.12,58.62 192.4,58.9 194.84,58.9 195.65,59.71 195.65,71.17 198.44,73.96 203.07,73.96 206.88,77.77 212.97,77.77 v1(216.27,74.47) ; v1(171.81,113.44) 173.25,114.88 173.97,114.88 174.57,114.28 174.57,112.85 175.57,111.84 178.9,111.84 180.23,110.51 180.23,109.8 180.74,109.29 181.98,109.29 182.48,109.79 v1(182.48,110.27) ; v1(280.19,55.75) 279.86,55.42 279.86,45.78 280.04,45.6 v1(280.04,44.48) ; 70.86,119.99 v1(70.86,121.71) 70.86,121.97 68.75,124.07 68.75,125.14 70.1,126.49 70.1,133.24 71.44,134.59 73.98,134.59 76.7,137.31 76.7,141.09 83.25,147.65 ; 70.86,119.99 69.18,118.31 64.61,118.31 63.35,119.57 v1(61.01,119.57) ; 70.86,119.99 73.27,117.57 73.27,115.11 73.91,114.47 v1(73.91,113.6) 74.66,112.85 76.83,112.85 78.15,114.17 81.97,114.17 82.63,114.83 v1(82.92,114.83)
  IN3 w0.508: v1(251.71,82.96) 242.96,82.96 242.56,83.36 241.42,83.36 239.01,80.95 230.5,80.95 227.58,78.02 224.78,78.02 224.15,77.39 224.15,76.12 222.5,74.47 v1(216.27,74.47) ; 201.39,126.77 201.39,128.51 200.51,129.39 200.51,138.44 200.47,138.47 v1(200.47,138.53) ; 201.39,126.77 v1(201.41,126.79) ; 201.39,126.77 v1(201.39,124.96)
  IN3 w0.762: v1(171.81,113.44) 172.31,113.94 172.31,114.6 172.79,115.08 174,115.08 174.67,115.75 174.67,118.84 174.23,119.29 v1(174.23,119.4) 174.23,121.33 v1(174.87,121.97)
  BOTTOM w0.508: v1(251.71,82.96) 254.16,82.96 257.21,79.92 262.74,79.92 264.95,77.7 270.62,77.7 280.19,68.13 v1(280.19,55.75) ; R25.1 60.76,119.3 60.76,119.32 v1(61.01,119.57) ; PR130.1 v1(224.91,117.76) ; R93.1 v1(276.34,117.27) ; v1(148.46,154.61) 143.11,149.26 v1(143.11,138.72) ; v1(248.15,135.43) 251.29,132.29 PR16.1
  BOTTOM w0.762: v1(244.33,99.22) 244.46,99.09 v1(244.46,94.93) QL2.3
  vias: v1(85.45,147.35) v1(85.96,148.37) v1(86.1,147.34) v1(132.57,151.16) v1(132.66,150.41) v1(213.09,150.4) v1(213.09,149.21) v1(213.42,149.79) v1(213.77,150.4) v1(213.77,149.21) v1(214.1,149.79) v1(214.46,150.4) v1(214.46,149.21) v1(214.79,149.79) v1(215.03,138.12) v1(215,137.33) v1(215,136.57) v1(215.17,150.4) v1(215.17,149.21) v1(215.5,149.79) v1(215.69,138.12) v1(215.77,137.33) v1(215.77,136.57) v1(215.86,150.4) v1(215.86,149.21) v1(216.19,149.79) v1(216.27,138.86) v1(216.35,138.1) v1(216.52,150.4) v1(216.52,149.21) v1(216.53,137.33) v1(216.53,136.57) v1(216.85,149.79) v1(224.91,118.44) v1(245.55,150.78) v1(245.55,149.89) v1(246.26,150.78) v1(246.26,149.89) v1(267.19,134.53) v1(267.95,134.53) v1(268.71,134.53) v4(224.63,120.52)
