# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_CLK_4MB: length 23.4
  TOP w0.114: RPC24.2 142.1,131.73 142.21,131.62 142.42,131.62 142.54,131.5 142.54,131.11 142.42,131 141.74,131 141.57,130.83 141.57,130.48 141.75,130.31 143.48,130.31 143.6,130.2 143.6,129.8 143.48,129.69 142.1,129.69 141.57,129.16 141.57,128.25 141.89,127.94 142.08,127.94 142.47,127.55 142.47,125.15 142.28,124.96 138.95,124.96 138.75,124.77 138.75,124.35 138.89,124.21 142.84,124.21 143.11,124.48 UC4M1.6
SPI_CLK_8MB: length 34.7
  TOP w0.114: RPC23.2 138.42,131.42 137.88,130.88 134.21,130.88 134.2,130.89 133.94,130.63 126.26,130.63 125.72,130.1 125.72,127.62 125.93,127.41 126.19,127.41 126.39,127.61 126.39,129.72 126.64,129.97 126.85,129.97 127.09,129.73 127.09,127.57 127.27,127.39 127.55,127.39 127.67,127.5 127.67,129.4 128.39,130.12 133.06,130.12 133.39,129.79 133.39,128.8 RC314.2 133.03,127.87 132.95,127.79 UC8M1.6
SPI_CLK_R: length 3.2
  TOP w0.114: v4(133.07,157.25) 132.62,157.7 R266.2 132.62,158.4 131.96,158.4 131.32,159.04 UTPM1.19
SPI_CS0#_8MB: length 65.8
  TOP w0.114: RC311.2 131.55,117.71 130.41,118.85 UC8M1.1 129.87,119.5 129.56,119.81 129.39,119.81 129.28,119.69 129.28,118.02 129.16,117.9 126.01,117.9 125.9,118.02 125.9,118.47 126.01,118.59 128.48,118.59 128.65,118.76 128.65,119.69 128.54,119.81 125.81,119.81 125.54,120.07 125.54,120.32 125.77,120.54 130.16,120.54 130.41,120.8 130.41,121.16 129.88,121.7 123.3,121.7 122.79,122.21 122.79,125.41 122.68,125.52 121.56,125.52 121.42,125.66 121.42,126.07 121.58,126.23 123.46,126.23 123.61,126.39 123.61,127.05 123.5,127.17 121.48,127.17 121.37,127.28 121.37,127.67 121.48,127.79 123.5,127.79 123.61,127.9 123.61,128.3 123.5,128.41 122.6,128.41 122.48,128.53 122.48,128.92 122.6,129.03 123.5,129.03 123.61,129.15 123.61,129.83 123.5,129.95 122.8,129.95 122.69,130.06 122.69,130.46 122.8,130.57 123.5,130.57 123.61,130.68 123.61,134.67 121.58,136.7 118.92,136.7 118.31,137.31 118.31,138.22 v2(118.1,138.43)
  BOTTOM w0.076: v2(118.1,138.43) 117.93,138.26 117.93,137.41 117.78,137.26 117.78,136.93 117.94,136.52 117.94,136.23 118.21,135.97 UC1.AU3
SPI_CS1#_4MB: length 46.1
  TOP w0.114: UC4M1.1 140.57,118.12 139.59,117.14 136.47,117.14 135.18,118.44 132.73,118.44 132.32,118.85 132.32,120.12 130.23,122.21 123.55,122.21 123.3,122.46 123.3,124.67 124.02,125.4 124.02,134.87 121.95,136.94 119.09,136.94 118.61,137.42 118.61,137.87 118.74,137.99 118.74,138.73 v1(118.41,139.06)
  BOTTOM w0.076: v1(118.41,139.06) 118.64,138.83 118.64,138.45 118.09,137.91 118.09,137.35 117.94,137.2 117.94,136.96 118.07,136.71 118.21,136.56 UC1.AU2
SPI_CS2#_TPM: length 59.9
  TOP w0.114: R265.1 134.09,158.6 134.09,156.33 v1(135.2,155.23)
  IN3 w0.114: v2(117.98,133.93) 118.18,134.13 118.18,136.95 117.62,137.51 117.62,139.19 118.42,139.99 119.45,139.99 122.08,142.61 122.08,149.17 121.96,149.29 120.25,149.29 120.13,149.4 120.13,149.79 120.25,149.91 121.96,149.91 122.08,150.02 122.08,150.42 121.96,150.53 119.61,150.53 119.5,150.64 119.5,151.04 119.61,151.15 121.96,151.15 122.35,151.54 122.35,151.93 123.11,152.69 127.54,152.69 128.56,153.7 129.11,153.7 129.23,153.59 129.23,153.45 129.34,153.34 129.73,153.34 129.85,153.45 129.85,153.59 129.96,153.7 130.36,153.7 130.47,153.59 130.47,153.45 130.59,153.34 130.98,153.34 131.09,153.45 131.09,154.6 131.21,154.72 131.6,154.72 131.72,154.6 131.72,153.45 131.83,153.34 132.22,153.34 132.34,153.45 132.34,153.59 132.45,153.7 132.82,153.7 133.03,153.91 133.59,153.91 134.2,153.3 136.13,153.3 137.03,154.2 137.03,154.92 136.72,155.23 v1(135.2,155.23)
  BOTTOM w0.076: v2(117.98,133.93) 117.98,134.72 117.92,134.77 117.92,135.28 118.05,135.4 118.27,135.4 118.49,135.62 118.49,136.65 118.21,136.94 UC1.AU1
SPI_CS2_R: length 19
  TOP w0.114: UTPM1.20 131.53,159.54 131.77,159.3 v1(131.82,159.3) 131.83,159.29 132.51,159.29 132.62,159.18 R265.2 ; R9456.2 120.29,156.31 v4(120.44,156.15) 121.3,155.29 122.4,155.29 122.62,155.06 126.59,155.06 v1(126.81,154.83)
  BOTTOM w0.114: v1(126.81,154.83) 126.92,154.73 128.85,154.73 129.15,154.43 130.05,154.43 130.17,154.54 130.17,155.54 131.82,157.19 v1(131.82,159.3)
SPI_FMISO: length 108.1
  TOP w0.114: RC313.1 134.78,116.24 143.26,116.24 145.65,118.62 145.65,134.97 v4(144.67,135.95) 144.15,136.47 144.15,139.04 143.56,139.62 143.56,151.36 142.73,152.19 v1(142.73,152.48) ; v1(189.72,132.11) 189.46,131.85 UE1.103
  IN3 w0.114: v1(142.73,152.48) 142.73,152.82 143.43,153.51 150.64,153.51 150.83,153.32 158.63,153.32 161.69,150.26 167.4,150.26 167.74,150.6 173.29,150.6 174.1,149.79 175.34,148.54 175.34,147.43 183.39,139.38 185.04,139.38 187.34,137.08 187.34,134.89 189.72,132.51 v1(189.72,132.11)
SPI_FMOSI#: length 109.9
  TOP w0.114: RC312.1 134.8,129.39 135.35,129.94 v1(138.37,129.94) ; UE1.102 189.86,129.96 189.59,129.7 189.59,128.79 187.87,127.07 181.23,127.07 v1(180.19,128.11)
  BOTTOM w0.114: v1(138.37,129.94) 137.97,130.35 137.97,139.29 138.23,139.55 138.23,151.14 138.75,151.66 139.85,151.66 140.48,151.04 143.91,151.04 145.64,152.76 145.64,153.23 148.87,156.47 152.7,156.47 153.34,157.1 174.68,157.1 175.91,155.87 175.91,142.11 178.12,139.9 178.12,137.87 179.05,136.94 179.05,129.25 v1(180.19,128.11)
SPI_FSCK: length 108.6
  TOP w0.114: RC314.1 v1(132.11,129.35) ; UE1.105 188.66,129.78 188.64,129.77 188.64,128.63 187.58,127.57 181.44,127.57 v1(180.19,128.81)
  BOTTOM w0.114: v1(132.11,129.35) 132.29,129.35 137.47,134.53 137.47,139.49 137.74,139.76 137.74,141.59 137.14,142.19 137.14,143.58 137.74,144.18 137.74,151.38 138.51,152.15 140.57,152.15 v1(140.71,152.01) 141.65,152.01 141.65,152.01 144.18,152.01 145.1,152.93 145.1,153.39 148.67,156.96 152.49,156.96 153.13,157.6 174.89,157.6 176.41,156.08 176.41,142.48 178.73,140.15 178.73,137.96 179.55,137.14 179.55,129.46 v1(180.19,128.81)
SPI_IO2: length 39.3
  TOP w0.114: RPC23.5 139.94,133.58 140.09,133.73 v1(140.09,134.03) 140.09,136.59 135.66,141.02 123.99,141.02 122.15,139.17 120.15,139.17 119.78,139.54 v2(119.75,139.54) ; RC117.2 143.57,135.08 v1(143.78,135.29) 144.64,134.43 v4(144.64,134.18) 144.04,133.58 RPC24.5
  BOTTOM w0.076: UC1.AW2 119.36,136.54 119.36,137.16 119.65,137.45 119.65,137.85 120.26,138.46 120.26,139.1 119.82,139.54 v2(119.75,139.54)
  BOTTOM w0.114: v1(143.78,135.29) 143.38,135.69 141.21,135.69 140.09,134.57 v1(140.09,134.03)
SPI_IO2_4MB: length 18.9
  TOP w0.114: UC4M1.3 143.11,118.78 143.62,118.27 144.51,118.27 145.17,118.93 145.17,131.59 v4(144.66,132.1) 144.29,131.73 143.35,131.73 143.1,131.99 RPC24.4
SPI_IO2_8MB: length 31.5
  TOP w0.114: RPC23.4 139.42,130.05 140.49,128.98 140.49,128.13 141.21,127.41 141.21,125.92 140.99,125.7 138.88,125.7 137.29,124.11 137.29,119.54 137.17,119.43 136.8,119.43 136.68,119.54 136.68,122.93 136.57,123.05 136.19,123.05 136.07,122.93 136.07,119.63 135.96,119.52 135.62,119.52 135.5,119.63 135.5,121.64 135.39,121.75 135.01,121.75 134.89,121.64 134.89,120.65 134.78,120.53 133.71,120.53 132.95,119.77 UC8M1.3
SPI_IO3: length 38.2
  TOP w0.114: RC118.2 v1(141.59,134.42) 141.59,134.02 141.6,134.01 RPC24.8 ; RPC23.8 137.92,134.56 v1(138.4,135.05) 138.11,135.34 137.62,135.34 RC380.1 137.43,136.2 v4(137.96,136.73) 135.81,138.88 129.57,138.88 129.07,138.38 127.87,138.38 126.88,139.36 124.91,139.36 122.87,137.33 119.84,137.33 119.02,138.15 119.02,138.86 v2(119.17,139.01)
  BOTTOM w0.076: UC1.AU4 118.65,135.56 118.65,136.72 118.48,136.9 118.48,137.19 118.41,137.25 118.41,137.73 119.09,138.41 119.09,138.93 v2(119.17,139.01)
  BOTTOM w0.114: v1(141.59,134.42) 141.59,133.95 140.66,133.02 139.56,133.02 138.4,134.18 v1(138.4,135.05)
SPI_IO3_4MB: length 13.3
  TOP w0.114: v4(140.55,135.51) 140.55,132.9 141.02,132.43 RPC24.1 141.6,131.96 141.22,131.58 140.1,131.58 139.98,131.46 139.98,131.07 140.1,130.95 140.96,130.95 141.08,130.84 141.08,130.28 140.96,130.17 140.49,130.17 140.38,130.06 140.38,129.66 140.49,129.55 140.96,129.55 141.08,129.43 141.08,128.05 141.84,127.29 UC4M1.7
SPI_IO3_8MB: length 28.6
  TOP w0.114: UC8M1.7 131.68,127.87 131.57,127.98 131.57,129.41 131.35,129.63 128.67,129.63 128.16,129.12 128.16,127.27 127.78,126.89 125.54,126.89 125.23,127.21 125.23,130.3 126.05,131.12 133.74,131.12 134,131.38 137.68,131.38 137.92,131.62 RPC23.1
SPI_SI: length 65.6
  TOP w0.114: v1(139.17,150.36) 139.17,151.01 135.64,154.54 135.64,155.63 134.46,156.8 134.46,159.13 R263.1 ; RPC24.6 142.6,133.79 142.91,134.1 v1(142.91,134.42) ; v2(119.75,138.98) 119.82,138.92 122.23,138.92 124.07,140.75 130.59,140.75 RC298.1 131.47,139.87 132.71,139.87 133.21,140.36 v4(133.47,140.36) 135.98,140.36 139.31,137.03 v1(139.31,135.96) 139.5,135.77 139.5,134.51 138.92,133.93 RPC23.6
  BOTTOM w0.076: v2(119.75,138.98) 120.03,138.7 120.03,138.5 119.49,137.95 119.49,137.51 119.2,137.22 119.2,135.74 UC1.AV3
  BOTTOM w0.114: v1(139.17,150.36) 139.22,150.31 139.22,147.17 139.87,146.53 139.87,142.97 139.22,142.33 139.22,136.04 v1(139.31,135.96) 140.96,135.96 141.12,136.13 143.81,136.13 144.22,135.73 144.22,135.09 143.55,134.42 v1(142.91,134.42)
SPI_SI_4MB: length 8.9
  TOP w0.114: UC4M1.5 144.38,127.54 144.93,128.09 144.93,129.92 144.81,130.03 144.25,130.03 144.14,130.15 144.14,130.52 144.28,130.66 144.81,130.66 144.93,130.77 144.93,131.13 144.62,131.44 143.3,131.44 142.6,132.14 RPC24.3
SPI_SI_8MB: length 40.4
  TOP w0.114: UC8M1.5 134.22,126.03 133.86,125.67 130.36,125.67 130.21,125.52 130.21,125.27 130.32,125.15 134.36,125.15 134.47,125.04 134.47,124.63 134.36,124.52 130.98,124.52 130.87,124.4 130.87,123.99 130.98,123.87 133.94,123.87 134.05,123.76 134.05,123.31 133.94,123.2 131.67,123.2 131.55,123.08 131.55,122.63 131.74,122.44 133.99,122.44 136.44,124.88 136.44,127.22 135.81,127.86 134.23,127.86 133.89,128.2 RC312.2 133.89,129.52 134.74,130.37 138.06,130.37 138.92,131.22 RPC23.3
SPI_SI_R: length 3.8
  TOP w0.114: v4(134.45,160.54) 132.9,160.54 132.62,160.26 R263.2 132.61,160.04 UTPM1.21
SPI_SO: length 90.4
  TOP w0.114: R264.1 133.83,163.48 134.84,162.47 134.84,156.76 135.88,155.73 135.88,155 139.66,151.22 v1(139.67,151.22) ; v2(120.32,139.54) 120.47,139.39 121.96,139.39 123.83,141.26 130.34,141.26 RC308.1 130.92,141.76 131.38,141.3 135.72,141.3 136.79,140.23 140.31,140.23 v1(141.23,139.3) 142.17,139.3 v4(142.36,139.49) 142.55,139.3 143.54,139.3 143.88,138.96 143.88,135.99 145.41,134.46 145.41,118.82 143.39,116.8 RC102.2 142.28,116.48 135.43,116.48 RC103.2
  BOTTOM w0.076: UC1.AW3 119.84,136.17 119.84,136.56 120,136.71 120,137.17 120.35,137.52 120.35,137.85 120.29,137.91 120.29,138.19 120.52,138.41 120.52,139.34 v2(120.32,139.54)
  BOTTOM w0.114: v1(139.67,151.22) 139.75,151.22 140.76,150.22 140.76,149.07 141.65,148.18 141.65,139.72 v1(141.23,139.3)
SPI_SO_4MB: length 2.1
  TOP w0.114: UC4M1.2 141.84,118.47 RC102.1
SPI_SO_8MB: length 4.8
  TOP w0.114: RC103.1 RC313.2 133.78,118.15 131.93,118.15 131.68,118.4 UC8M1.2
SPI_SO_R: length 5.2
  TOP w0.114: UTPM1.24 130.98,161.54 130.98,162.91 131.55,163.48 R264.2 132.62,163.7 v4(133.84,164.92)
SPK_L1-: length 2.1
  TOP w0.254: RA8.1 188.05,61.16 187.63,60.73 UA1.14
SPK_L1-_CON: length 70.6
  IN3 w1.27: 190.23,62.64 191.75,62.64 193.53,64.42 193.53,68.65 197.37,72.49 201.34,72.49 208.03,79.18 v1(215.88,79.18) v1(217.28,79.18)
  BOTTOM w1.27: 240.9,96.93 240.9,93.76 231.01,83.87 v4(227.58,83.87) 222.5,83.87 217.81,79.18 v1(217.28,79.18) v1(215.88,79.18)
  vias: v1(188.7,64.29) v1(189.47,64.29)
SPK_L2+: length 3.3
  TOP w0.254: RA9.1 190.19,61.08 189.52,60.41 188.64,60.41 188.43,60.2 UA1.12
SPK_L2+_CON: length 63.8
  IN3 w1.27: 191.24,65.56 191.24,68.88 196.67,74.3 200.62,74.3 v1(203.37,77.06) v1(204.33,78.01)
  BOTTOM w1.27: v1(203.37,77.06) v1(204.33,78.01) 207.28,80.96 217.05,80.96 221.85,85.76 v4(223.77,85.76) 230.38,85.76 239.12,94.5 239.12,95.16
  vias: v1(190.86,64.29) v1(191.5,64.29)
SPK_R1-: length 2.1
  TOP w0.254: UA1.15 187.23,61.06 RA10.1
SPK_R1-_CON: length 64.5
  IN3 w1.27: 189.34,65.95 189.34,69.49 195.93,76.08 199.88,76.08 v1(200.91,77.11) v1(201.86,78.06)
  BOTTOM w1.27: v1(200.91,77.11) v1(201.86,78.06) 207.37,83.56 v4(210.84,83.56) 217.04,83.56 221.14,87.66 229.77,87.66 237.34,95.23 237.34,96.17
  vias: v1(186.8,64.24) v1(186.8,63.61)
SPK_R2+: length 3.2
  TOP w0.203: RA12.1 185.05,61.42 185.41,61.07 185.48,61.07 186.43,60.12 UA1.17
SPK_R2+_CON: length 69.2
  IN3 w1.27: v1(199.89,78.78) v1(198.97,77.86) 195.2,77.86 187.44,70.11 187.44,68.88 184.64,66.07 184.64,64.8
  BOTTOM w1.27: v1(198.97,77.86) v1(199.89,78.78) 206.65,85.54 v4(209.44,85.54) 216.51,85.54 220.4,89.44 227.37,89.44 232,94.07 232,97.43 232.9,98.33 235.19,98.33
  vias: v1(184.26,63.53) v1(184.89,63.53)
SPKR_MUTE#: length 34.4
  TOP w0.203: UA1.39 188.43,53.7 v1(188.47,53.65)
  BOTTOM w0.203: RA29.2 182.53,68.56 182.73,68.36 v4(189.6,68.36) 194.42,68.36 195.18,67.6 195.18,57.49 192.33,54.64 189.21,54.64 188.47,53.91 v1(188.47,53.65)
  BOTTOM w0.254: DA5.2 RA29.2
SPLL_PVDD: length 17
  TOP w0.381: v2(47.77,158.19) 47.77,158.21 48.36,158.8 48.36,159.2 47.98,159.57 47.64,159.57 47.29,159.92 47.29,163.55 48.14,164.4 48.14,164.84 45.38,167.6 v4(45.38,168.14) 45.38,169.31 CV21.1 44.84,169.63 44.61,169.4 43.94,169.4 CV20.1 42.7,169.39 LV4.2
  BOTTOM w0.381: UV3.H7 48.14,158.58 47.77,158.21 v2(47.77,158.19)
SPLL_VDDC: length 39.3
  IN3 w0.127: v2(48.53,158.16) 48.53,157.42 48.13,157.03 48.13,156.37 48.31,156.2 49.55,156.2 49.8,155.95 49.8,155.52
  IN3 w0.254: v1(48.98,129.85) 49.12,129.71 49.68,129.71 52.22,132.25 52.22,133.12 53.13,134.03 53.13,144.57 51.73,145.97 51.73,146.61 51.61,146.73 51.61,148.25 51.55,148.31 51.55,149.14 51.58,149.18 51.58,150.39 51.61,150.41 51.61,152.85 50.61,153.84 50.61,154.71 49.8,155.52
  BOTTOM w0.254: CV25.1 48.09,131.88 47.78,131.58 47.78,130.59 47.96,130.41 48.47,130.41 48.85,130.03 48.85,129.98 v1(48.98,129.85)
  BOTTOM w0.381: CV25.1 CV24.1 50.15,131.88 LV5.2 ; v2(48.53,158.16) 48.5,158.16 UV3.H8
SRN: length 2.2
  BOTTOM w0.203: PU101.19 219.81,115.01 219.31,115.5 PR128.2
SRP: length 1.9
  BOTTOM w0.203: PU101.20 220.21,114.29 220.43,114.51 PR125.2
SSD_DEVSLP1: length 19.8
  TOP w0.114: TP117.1 88.53,139.61 89.59,138.54 91.9,138.54 93.14,137.3 102.05,137.3 102.68,137.94 102.68,138.29 v2(103.27,138.88)
  BOTTOM w0.076: UC1.J2 103.62,136.56 103.77,136.71 103.77,136.71 103.77,136.71 103.89,136.96 103.89,138.26 v2(103.27,138.88)
SUS_STAT#: length 11.1
  TOP w0.114: RC47.1 129.63,133.8 125.9,133.8 v1(125.54,133.45)
  BOTTOM w0.076: UC1.BA11 121.03,130.67 122.21,130.67 122.77,131.23 122.77,131.51
  BOTTOM w0.114: 122.77,131.51 122.77,132.45 123.77,133.45 v1(125.54,133.45)
SUSACK#: length 3.8
  TOP w0.114: RC109.1 119.49,130.79 117.23,130.79 v2(116.73,130.29)
  BOTTOM w0.076: v2(116.73,130.29) 116.35,130.67 UC1.AP11
SUSCLK_32K: length 197.3
  IN1 w0.14: v1(180,137.54) 180.36,137.54 181.98,139.16 185.96,139.16 187.24,137.88 189.69,137.88 190.31,137.26 193.85,137.26 194.47,137.88 200.77,137.88 200.99,138.1 213.6,138.1 214.11,137.59 214.11,135.01 216.07,133.06 224.7,133.06 v1(226.05,134.41)
  IN3 w0.114: v1(240.66,152.95) 226.05,138.35 v1(226.05,134.41)
  BOTTOM w0.076: UC1.BA17 120.97,127.33 121.24,127.59 123.44,127.59 124.92,129.07 125.05,129.07
  BOTTOM w0.114: v1(180,137.54) 179.93,137.54 179.29,138.17 179.29,142.4 176.91,144.79 176.91,156.28 175.09,158.09 148.34,158.09 147.19,156.95 139.8,156.95 138.88,156.03 138.88,153.24 136.2,150.56 136.2,148.19 136.81,147.57 136.81,145.32 136.16,144.67 136.16,135.96 130.96,130.76 129.27,130.76 127.84,129.33 125.34,129.33 125.08,129.07 125.05,129.07 ; v1(240.66,152.95) 247.79,152.95 249.81,150.94 254.7,150.94 257.09,153.33 257.09,154.15 256.7,154.54 JWLBT.50
SUSP: length 181
  TOP w0.114: v1(193.92,144.06) 193.39,144.6 184.98,144.6 182.49,142.11 180.88,142.11 180.76,142.22 R157.2 R156.2 179.82,143.68 179.36,143.22 Q28.6 179.36,141.99 179.25,141.88 178.83,141.88 178.71,142 Q28.5
  IN1 w0.14: v1(215.77,115.87) 205.35,115.87 202.43,118.79 v1(201.16,118.79)
  IN3 w0.114: v1(193.92,144.06) 193.92,142.66 200.07,136.51 200.07,128.88 200.83,128.12 200.83,122.63 201.59,121.87 201.59,119.22 v1(201.16,118.79) ; v1(253.13,86.51) 252.9,86.51 251.35,88.06 250.66,88.06 249.54,89.19 249.54,90.65 243.4,96.79 235.27,96.79 233.97,98.09 228.08,98.09 227.07,99.11 225.8,99.11 224.88,100.02 223.44,100.02 223,100.45 223,101.49 222.57,101.93 220.49,101.93 218.31,104.11 218.31,107.62 216.02,109.9 216.02,115.62 v1(215.77,115.87)
  BOTTOM w0.114: v1(253.13,86.51) 252.98,86.36 252.98,85.12 257.53,80.56 262.88,80.56 265.17,78.28 270.83,78.28 280.78,68.33 v4(280.78,65.45) 280.78,53.01 279.39,51.62 279.39,46.48 Q22.2
SUSP#: length 362.1
  TOP w0.114: U11.3 218.82,137.21 218.86,137.25 218.86,137.66 218.43,138.09 ; v1(200.2,139.59) 200.22,139.62 v4(201.34,139.62) 203.45,139.62 204.08,140.25 218.05,140.25 218.43,139.87 218.43,138.09 ; U11.5 218.02,137.24 217.98,137.27 217.98,137.64 218.43,138.09 ; v1(79.99,81.19) 81.63,82.82 81.63,94.86 80.51,95.98 80.51,102.11 81.63,103.22 81.63,109.85 79.43,112.05 D23.1 ; D62.2 178.83,141.37 178.6,141.14 177.58,141.14 D61.2 177.35,143.12 v1(177.54,143.3) 178.55,143.3 178.71,143.46 Q28.2 178.71,144.82 RE48.2
  TOP w0.254: PR311.2 v1(185.3,166.05) ; v1(149.7,164.69) 149.5,164.69 149.14,164.33 149.14,160.38 148.8,160.04 147.91,160.04 147.66,160.29 147.66,160.47 147.31,160.81 147.31,160.98 147.18,161.12 Q24.2
  IN3 w0.114: v1(187.85,96.85) 187.8,96.9 187.8,97.05 186.6,98.25 186.6,103.57 187.69,104.66 187.69,117.91 186.32,119.28 186.32,122.11 187.19,122.98 187.19,125.29 188.82,126.92 v1(188.89,126.92) 188.89,127.67 187.19,129.37 187.19,130.91 184.94,133.16 184.94,135.44 181.44,138.94 181.44,139.95 178.3,143.09 177.75,143.09 v1(177.54,143.3)
  IN3 w0.254: v1(185.3,166.05) 186.98,164.36 186.98,162.28 188.61,160.65 191.53,160.65 196.21,155.97 196.21,152.7 v1(196.46,152.45) 196.46,143.05 199.92,139.59 v1(200.2,139.59)
  BOTTOM w0.114: v1(187.85,96.85) 187.85,90.96 181.67,84.78 178.81,84.78 177.08,83.05 173.3,83.05 168.22,77.98 162.24,77.98 161.31,77.05 141.71,77.05 140.17,75.51 111.01,75.51 108.31,72.82 103.08,72.82 101.5,74.4 95.76,74.4 94.44,75.72 88.02,75.72 82.56,81.19 v1(79.99,81.19) ; v1(200.2,139.59) 199.83,139.59 197.15,136.92 197.15,135.43 195.85,134.13 193.43,134.13 190.58,131.28 189.87,131.28 188.57,129.99 188.57,127.24 v1(188.89,126.92)
  BOTTOM w0.254: v1(149.7,164.69) 149.7,163.93 151.76,161.87 162.82,161.87 163.77,162.82 167.3,162.82 168.34,163.86 180.82,163.86 186.68,158 186.68,155.06 188.78,152.97 195.43,152.97 195.95,152.45 v1(196.46,152.45)
SUSP#_EC: length 31.3
  TOP w0.114: v1(188.96,132.11) 188.96,132.19 189.65,132.89 192.98,132.89 193.39,133.3 RPE4.8 ; v1(178.15,135.4) 179.01,135.4 179.42,135 179.42,133.19 v4(179.8,132.81) 179.95,132.81 181.06,131.71 UE1.124 181.06,129.32 181.44,128.94 187.57,128.94 187.81,129.18 v1(187.81,129.45) ; D61.1 175.92,140.89 v1(175.63,140.89)
  BOTTOM w0.114: v1(187.81,129.45) 187.81,130.97 v1(188.96,132.11) ; v1(178.15,135.4) 175.48,138.07 175.48,140.74 v1(175.63,140.89)
SUSWARN#: length 3.1
  TOP w0.114: v2(117.36,129.38) 117.46,129.38 117.96,129.88 119.49,129.88 RC109.2
  BOTTOM w0.076: UC1.AR13 117,129.74 v2(117.36,129.38)
SVI2_SVC: length 139.5
  TOP w0.114: v1(42.78,175.67) 42.78,175.55 40.04,172.8 40.04,172.12 36.86,168.94 30.44,168.94 v4(29.14,170.23) v1(28.23,171.15) 27.01,171.15 RV116.1
  IN1 w0.14: v1(42.78,175.67) 43.12,176.02 47.94,176.02 47.97,175.99 51.32,175.99 54.02,173.3 56.43,173.3 59.14,170.59 59.14,167.91 60.75,166.3 65.03,166.3 69.15,162.19 70.34,162.19 72.84,159.69 72.84,158.95 v1(74.53,157.26)
  IN3 w0.254: v1(124.44,172.88) 124.31,172.75 124.31,168.15 124.95,167.51 124.95,166.56 123.39,165.01 119.58,165.01 118.7,164.12 116.03,164.12 115.33,163.42 115.33,162.15 113.93,160.74 113.93,157.98 112.83,156.88 108.85,156.88 108.09,157.64 104.98,157.64 103.65,156.31 78.79,156.31 77.97,155.49 76.55,155.49 74.78,157.26 v1(74.53,157.26)
  BOTTOM w0.114: RV109.2 70.02,158.26 71.44,158.26 RV126.2 RV125.1 73.06,158.12 73.29,158.35 74.28,158.35 74.43,158.2 74.43,157.36 v1(74.53,157.26) 75.04,157.77 RV120.1 ; RV97.2 27.7,170.63 v1(28.23,171.15)
  BOTTOM w0.254: PR609.1 125.09,173.53 v1(124.44,172.88)
SVI2_SVD: length 142.4
  TOP w0.114: v1(42.04,175.67) 42.04,175.19 39.71,172.85 39.71,172.13 36.76,169.18 30.99,169.18 v1(28.94,171.23) 28.56,171.61 26.55,171.61 RV117.1
  IN1 w0.14: v1(42.04,175.67) 42.65,176.28 48.05,176.28 48.08,176.26 51.43,176.26 54.13,173.57 56.54,173.57 59.4,170.7 59.4,168.02 60.86,166.57 65.14,166.57 69.26,162.45 70.45,162.45 73.32,159.58 73.32,159.1 75.98,156.44 75.98,154.92 v1(75.99,154.91)
  IN3 w0.254: v1(124.06,173.64) 124.7,173.64 125.08,173.26 125.08,172.63 124.7,172.24 124.7,168.31 125.33,167.67 125.33,166.4 123.55,164.62 119.74,164.62 118.85,163.74 116.19,163.74 115.71,163.26 115.71,161.99 114.31,160.59 114.31,157.82 112.99,156.5 108.69,156.5 107.93,157.26 105.14,157.26 103.81,155.93 80.31,155.93 78.72,154.34 76.49,154.34 75.99,154.84 v1(75.99,154.91)
  BOTTOM w0.114: RV107.2 70.39,155.25 72.63,155.25 RV121.1 73.97,155.63 RV122.2 RV118.1 75.79,154.91 v1(75.99,154.91) ; v1(28.94,171.23) 27.45,169.74 RV96.2
  BOTTOM w0.254: v1(124.06,173.64) 123.58,173.64 PR615.1
SVI2_SVT: length 71.1
  IN3 w0.254: v1(123.77,171.72) 123.77,171.24 123.87,171.14 123.87,167.96 124.5,167.33 124.5,166.75 123.21,165.45 119.4,165.45 118.51,164.57 115.94,164.57 114.95,163.58 114.95,162.31 113.54,160.9 113.54,158.13 112.67,157.26 109.01,157.26 108.25,158.02 104.82,158.02 103.5,156.69 78.28,156.69 77.59,156 v1(77.08,156)
  BOTTOM w0.114: v1(77.08,156) 76.74,156 76.6,156.14 75.85,156.14 RV119.1 75.36,156.35 75.12,156.12 73.41,156.12 73.07,156.46 RV123.1 RV124.2 71.96,156.2 72.07,156.09 v4(72.07,155.66) 71.74,155.66 71.25,156.14 69.88,156.14 69.54,156.48 RV108.2
  BOTTOM w0.254: v1(123.77,171.72) 123.74,171.72 123.44,171.42 PR611.1
SW_1.00VS:
  vias: v1(142.2,172.3) v1(142.83,172.32) v4(140.2,175.43)
SW_1A: length 48.2
  TOP w0.254: v1(54.67,56.73) 54.26,57.13 53.25,57.13 52.28,58.1 52.28,61.02 v4(55.19,63.93) 58.78,67.52 58.78,79.87 59.69,80.79 59.69,84.16 60.86,85.33 67.04,85.33 70.42,81.95 70.42,79.99 70.83,79.57 PR451.2
  BOTTOM w0.254: PR412.2 v1(54.67,56.73)
SW_1B: length 48.7
  TOP w0.254: PR459.2 65.31,104.99 59.98,104.99 59.09,104.1 59.09,103.74 v1(59.8,103.03)
  IN1 w0.254: v1(59.8,103.03) 59.29,102.52 59.29,98.56 59.84,98.02 59.84,90.58 60.27,90.14 60.27,84.63 59.67,84.03 59.67,81.51 59.05,80.9 59.05,68.54 60.45,67.15 v1(62.22,67.15)
  BOTTOM w0.254: v1(62.22,67.15) 62.49,66.88 PR438.2
SW_1PH: length 9.9
  TOP w0.254: v1(68.61,106.23) 67.61,105.23 PR459.1
  IN3 w0.762: 68.51,102.47 70.31,100.67 72.37,100.67
  BOTTOM w0.254: PL408.1 v1(68.61,106.23)
  vias: v1(67.65,102.8) v1(68.31,102.8) v1(72.5,100.79) v1(73.16,100.66)
SW_A1: length 4
  TOP w0.254: v1(73.21,79.78) 73.2,79.76 72.19,79.76 PR451.1
  BOTTOM w0.254: PL403.1 v1(73.21,79.78)
  vias: v1(65.74,73.95) v1(66.4,73.95) v4(69.83,75.28)
SW_B1: length 7.8
  TOP w0.254: v1(89.72,63.08) 85.45,63.08 85.06,62.68 PR455.1
  BOTTOM w0.254: PL406.1 v1(89.72,63.08)
  vias: v1(84.77,55.35) v1(85.07,54.77) v4(85.84,58.31)
SYS_RESET#: length 12.1
  BOTTOM w0.076: 97.14,136.18 97.64,136.18 98.5,135.32 98.5,135.29 98.7,135.09 99.15,135.09 UC1.B5
  BOTTOM w0.114: 97.14,136.18 93.52,136.18 v4(93.33,135.99) 92.73,135.99 92.09,135.36 89.99,135.36 88.85,136.5 RC108.2
SYSON: length 270
  TOP w0.114: v1(77.15,119.91) 76.92,119.68 R9492.1 ; RE49.2 199.92,127.71 v1(199.56,127.71) 199.56,129.23 197.86,130.93 197.86,135.92 196.93,136.85 193.8,136.85 D63.2 193.14,136.19 D64.2
  TOP w0.254: v1(189.48,159.56) 189.22,159.81 v4(185.72,159.81) 184.27,159.81 182.17,157.71 U17.4 ; PR312.1 185.78,171.25 v1(185.91,171.13)
  IN1 w0.14: v1(186.08,95.08) 185.57,95.6 185.57,96.54 196.84,107.81 198.19,107.81 198.7,108.32 198.7,109.93 198.65,109.98 v1(198.65,110.23)
  IN1 w0.254: v1(193.67,154.86) 191.57,156.95 191.57,157.46 v1(189.48,159.56) 186.81,162.23 186.81,164.26 186.3,164.77 186.3,166.54 185.34,167.51 185.34,170.55 v1(185.91,171.13)
  IN3 w0.114: v1(193.67,154.86) 193.67,154.1 194.87,152.9 194.87,150.9 194.98,150.78 194.98,146.65 192.75,144.42 192.75,142.8 199.34,136.21 199.34,127.93 v1(199.56,127.71) 199.05,127.2 199.05,126.77 198.72,126.44 197.78,126.44 196.79,125.45 196.79,113.34 198.75,111.38 198.75,110.33 v1(198.65,110.23)
  BOTTOM w0.114: v1(186.08,95.08) 185.9,94.89 185.9,93.75 184.74,92.59 182.48,92.59 181.35,93.72 177.14,93.72 175.41,91.99 175.41,90.01 166.98,81.59 160.86,81.59 160.34,81.07 127.89,81.07 126.64,79.82 104.5,79.82 104.18,80.13 103.46,80.13 102.92,80.67 102.12,80.67 101.71,80.26 90.49,80.26 82.2,88.54 82.2,113.22 80.76,114.65 80.76,115.98 77.15,119.59 v1(77.15,119.91)
SYSON_EC: length 8.4
  TOP w0.114: D64.1 191.43,136.17 191.43,134.15 RPE4.5 190.74,133.7 CE14.1 190.18,133.13 189.34,133.13 v4(188.96,132.75) 187.86,131.65 UE1.107
TEST: length 2.3
  TOP w0.114: R51.1 224.36,98.64 v4(224.54,98.46) 224.51,98.42 U6.14
TEST_1: length 2.3
  TOP w0.114: U5.14 207.11,98.47 v3(206.99,98.58) 206.86,98.71 R38.1
TEST_2: length 2.5
  TOP w0.114: U16.14 267.06,124.43 267.77,125.14 268.04,125.14 R244.1
THRMTRIP#: length 12.4
  BOTTOM w0.076: 97.17,101.78 97.35,101.59 98.9,101.59 99.01,101.54 99.16,101.54 99.35,101.59 99.53,101.59 99.78,101.51 UC1.C63
  BOTTOM w0.114: RC54.2 88.96,101.61 89.3,101.95 90.85,101.95 91.37,101.43 RC53.2 91.99,101.25 92.52,101.78 v4(92.83,101.78) 97.17,101.78
TON_1.35V: length 2.6
  TOP w0.229: PU301.9 182.7,170.66
  TOP w0.254: PR309.2 183.88,171.84 v4(183.18,171.14) 182.7,170.66
TOPAZ_VDDC_RTN: length 15.2
  TOP w0.254: v2(61.67,147.47) v3(62.97,147.47) 63.04,147.47 67.89,152.33 71.93,152.33 RV4.2
  BOTTOM w0.114: UV3.AD20 61.14,148 v2(61.67,147.47)
TOPAZ_VDDC_SEN: length 16.6
  TOP w0.114: RV3.2 72.84,154.12 72.84,153.92 v3(72.42,153.51) 71.84,152.92 67.62,152.92 63.02,148.32 61.86,148.32 61.06,147.52 v2(61.06,147.42)
  BOTTOM w0.114: v2(61.06,147.42) 61,147.42 60.42,148 UV3.AC20
TP_CLK2: length 48.1
  TOP w0.114: v1(152.2,59.72) JTP.6 ; v1(127,58.71) 126.6,59.1 126.6,66.01 125.95,66.66 125.15,66.66 124.89,66.4 123.7,66.4 123.27,65.97 v1(123.27,65.97) 123.27,65.97 v4(122.5,65.2) 121.61,64.31 121.61,64.26 121.61,63.87 121.16,63.43 JCP.8
  IN1 w0.14: v1(127,58.71) 127.56,59.27 151.75,59.27 v1(152.2,59.72)
  BOTTOM w0.114: R63.2 126.43,67.99 124.43,67.99 123.27,66.83 v1(123.27,65.97)
TP_DATA2: length 43.1
  TOP w0.114: JTP.1 v1(147.2,59.72) ; v1(126.36,58.71) 126.36,64.59 v4(126.18,64.77) 126.36,64.94 126.36,65.91 125.87,66.4 125.23,66.4 124.79,65.96 v1(124.02,65.96) 123.26,65.2 123.1,65.2 122.03,64.12 122.03,63.79 121.66,63.42 JCP.9
  IN1 w0.14: v1(147.2,59.72) 147.02,59.54 127.19,59.54 v1(126.36,58.71)
  BOTTOM w0.114: v1(124.02,65.96) 124.02,67.24 124.53,67.75 126.53,67.75 127.51,68.73 128.06,68.73 R65.2
TP_RESET: length 69.6
  TOP w0.114: R59.2 R60.2 144.43,62.9 v4(144.49,62.96) 146.61,62.96 148.2,61.37 JTP.2 148.2,59.73 v1(148.19,59.72)
  IN1 w0.14: v1(148.19,59.72) 148.19,59.91 147.85,60.26 146.82,60.26 146.36,59.8 124.77,59.8 124.31,60.26 111.46,60.26 v1(104.76,66.96)
  BOTTOM w0.114: R64.2 117.38,66.96 v1(104.76,66.96)
TP_REST: length 263.5
  TOP w0.114: RC407.2 109.57,143.94 109.24,144.27 109.24,145.74 108.93,146.05 108.22,146.05 v2(107.82,146.45) ; JCP.2 118.16,65.48 v1(121.39,68.71)
  IN3 w0.114: v2(107.82,146.45) 107.38,146.89 107.38,152.6 109.15,154.37 114.69,154.37 119.09,158.77 125.37,158.77 126.62,160.02 143.83,160.02 144.65,160.84 161.04,160.84 161.61,161.41 180.77,161.41 192.03,150.16 192.03,142.5 198.62,135.91 198.62,128.39 196.07,125.84 196.07,113.01 197.55,111.53 197.55,110.46 v1(197.35,110.26)
  BOTTOM w0.114: R64.1 120.12,68.49 120.36,68.25 120.93,68.25 v1(121.39,68.71) 121.6,68.92 R66.1 121.6,71.74 123.75,73.89 140.98,73.89 142.82,75.73 162.15,75.73 162.95,76.53 168.53,76.53 173.78,81.78 180.58,81.78 189.43,90.63 189.43,97.43 196.23,104.24 196.23,107.61 197.12,108.5 197.12,110.03 v1(197.35,110.26) 197.38,110.26 197.86,110.74 200.78,110.74 200.96,110.92 RE52.2
TP_REST_EC: length 17.7
  TOP w0.114: UE1.72 194.31,119.57 195.12,118.77 197.81,118.77 197.99,118.59 198.65,118.59 198.9,118.33 201.36,118.33 201.77,117.93 201.77,117.52 201.59,117.34 v1(201.59,116.86)
  BOTTOM w0.114: RE52.1 203.6,111.4 203.6,112.42 203.04,112.97 202.05,112.97 201.59,113.43 v1(201.59,116.86)
TP_REST_R: length 12.8
  TOP w0.114: RC407.1 110.03,142.25 110.03,141.43 109.16,140.56 109.16,138.93 v2(109.58,138.51)
  BOTTOM w0.076: v2(109.58,138.51) 109.21,138.14 109.21,137.51 109.36,137.36 109.36,136.93 109.19,136.52 109.19,135.38 UC1.W4
  BOTTOM w0.114: v3(107.43,141.73) 107.43,141.58 108.73,140.28 108.73,139.42 109.58,138.56 v2(109.58,138.51)
TS_OFF#: length 7.7
  TOP w0.114: D25.2 251.83,150.22 252.82,150.22 D22.2 252.93,150.33 R113.2 252.9,151.18 252.16,151.18 251.98,151.36 251.98,151.52 v4(252.01,151.56) 252.08,151.62 252.08,153.96 251.1,154.93 JTOUCH1.2
USB3_RX4_N_OD: length 5.2
  TOP w0.114: L15.3 279.19,116.23 280.13,116.23 280.26,116.36 D17.2 D17.8 281.9,116.36 282.06,116.52 v1(282.44,116.52) 283.63,116.52 JLINK.16
USB3_RX4_P_OD: length 5.3
  TOP w0.114: L15.2 279.16,116.46 v1(279.8,116.46) 280.04,116.46 280.43,116.86 D17.1 D17.9 281.9,116.86 282.01,116.75 283.6,116.75 JLINK.14
USB3_TX1+_REIN: length 2.1
  TOP w0.114: C30.2 202.8,96.6 202.95,96.45 203.71,96.45 203.87,96.61 U5.19
USB3_TX1+_REOUT: length 129.2
  TOP w0.114: v1(210.87,97.28) 210.6,97.01 209.56,97.01 209,96.45 208.92,96.45 208.76,96.61 U5.12
  IN1 w0.14: v1(210.87,97.28) 210.87,97.17 210.98,97.06 213.34,97.06 214.74,95.66 219.29,95.66 220.18,94.77 220.66,94.77 222.78,92.65 222.78,91.16 224.24,89.69 226.32,89.69 238.75,77.26 245.43,77.26 245.85,77.69 258.07,77.69 258.83,78.45 262.25,78.45 264.65,76.05 268.53,76.05 270.89,73.7 274.48,73.7 277.49,70.68 277.49,45.99 280.33,43.15 280.33,34.26 279.02,32.95 277.37,32.95 276.97,33.35 276.97,36.81 v1(276.71,37.07)
  BOTTOM w0.114: C121.1 276.71,37.27 v1(276.71,37.07)
USB3_TX1-_REIN: length 2
  TOP w0.114: U5.20 203.96,96.11 203.84,96.22 202.93,96.22 202.83,96.12 C32.2
USB3_TX1-_REOUT: length 129.1
  TOP w0.114: v1(210.87,96.51) 210.6,96.78 v1(210.04,96.78) 209.66,96.78 209.1,96.22 208.91,96.22 208.79,96.11 U5.11
  IN1 w0.14: v1(210.87,96.51) 211.16,96.81 213.24,96.81 214.63,95.41 219.18,95.41 220.07,94.52 220.56,94.52 222.53,92.55 222.53,91.05 224.14,89.44 226.22,89.44 238.65,77.01 245.53,77.01 245.96,77.43 258.17,77.43 258.94,78.2 262.14,78.2 264.54,75.8 268.43,75.8 270.78,73.44 274.37,73.44 277.24,70.58 277.24,45.89 280.08,43.04 280.08,34.37 278.92,33.2 277.48,33.2 277.22,33.46 277.22,36.91 277.6,37.29 278.59,37.29 v1(278.8,37.09)
  BOTTOM w0.114: v1(278.8,37.09) 278.87,37.17 C124.1
USB3_TX2+_REIN: length 2.5
  TOP w0.114: C36.2 219.95,97.01 220.1,96.86 220.55,96.86 220.99,96.42 221.15,96.42 221.24,96.51 U6.19
USB3_TX2+_REOUT: length 138
  TOP w0.114: v1(229.03,97.2) 228.76,96.93 227.24,96.93 226.68,96.37 226.32,96.37 226.19,96.51 U6.12
  IN1 w0.14: v1(229.03,97.2) 229.2,97.03 229.97,97.03 232.28,94.73 232.28,86.59 240.05,78.81 244.78,78.81 245.21,79.24 252.47,79.24 254.31,81.07 255.99,81.07 257.07,80 262.89,80 265.29,77.6 269.18,77.6 271.53,75.25 275.44,75.25 279.74,70.94 279.74,47.25 282.07,44.92 282.07,42.96 282.44,42.59 282.44,36.88 282.24,36.67 282.24,30.31 282.07,30.15 282.07,16.32 279.39,13.64 278,13.64 277.25,14.38 277.25,16.32 277.6,16.67 277.6,16.85 277.43,17.02 v1(277.25,17.02)
  BOTTOM w0.114: v1(277.25,17.02) 277.71,17.48 C125.1
USB3_TX2-_REIN: length 2.5
  TOP w0.114: U6.20 221.33,96.01 221.14,96.19 220.9,96.19 220.46,96.63 220.09,96.63 219.97,96.51 C37.2
USB3_TX2-_REOUT: length 137.9
  TOP w0.114: v1(229.03,96.44) 228.76,96.7 v1(228.09,96.7) 227.34,96.7 226.78,96.15 226.3,96.15 226.16,96.01 U6.11
  IN1 w0.14: v1(279.46,16.95) 278.24,16.95 277.5,16.21 277.5,14.49 278.1,13.89 279.29,13.89 281.82,16.42 281.82,30.25 281.98,30.41 281.98,36.78 282.19,36.98 282.19,42.49 281.82,42.85 281.82,44.81 279.49,47.14 279.49,70.84 275.33,74.99 271.42,74.99 269.07,77.35 265.18,77.35 262.79,79.74 256.96,79.74 255.89,80.82 254.41,80.82 252.58,78.98 245.31,78.98 244.89,78.56 239.95,78.56 232.02,86.48 232.02,94.62 229.87,96.78 229.22,96.78 229.03,96.59 v1(229.03,96.44)
  BOTTOM w0.114: v1(279.46,16.95) 279.23,17.18 C126.1
USB3_TX4_N_C: length 1.6
  TOP w0.114: C85.2 273.53,114.63 274.58,114.63 L16.4
USB3_TX4_N_OD: length 8.7
  TOP w0.114: JLINK.22 283.63,114.12 283.32,114.12 282.46,114.98 282.04,114.98 281.92,114.86 D17.6 D17.5 280.38,114.86 280.27,114.96 v1(278.78,114.96) 277.54,114.96 277.34,114.76 276.2,114.76 L16.3
USB3_TX4_P_C: length 1.7
  TOP w0.114: C86.2 273.6,114.85 274.44,114.85 L16.1
USB3_TX4_P_OD: length 8.7
  TOP w0.114: JLINK.20 283.6,114.35 283.41,114.35 282.55,115.21 282.09,115.21 281.95,115.36 D17.7 D17.4 280.4,115.36 280.23,115.19 277.45,115.19 277.25,114.99 v1(276.9,114.99) 276.06,114.99 L16.2
USB3P1_RXN: length 223.4
  TOP w0.114: v1(197.91,93.78) 197.91,94.13 198.13,94.34 198.3,94.34 198.63,94.01 v1(199.8,94.01) 201.56,94.01 201.71,93.86 R31.1
  IN1 w0.076: v2(103.22,132.12) 103.03,132.12 102.86,131.95 102.86,131.73 102.69,131.56 100.93,131.56 100.55,131.17 99.52,131.17 99.23,131.46 99.17,131.46 99.16,131.48
  IN1 w0.14: v1(197.91,93.78) 197.77,93.92 197.77,94.11 197.95,94.3 198.34,94.3 199.24,93.4 199.24,89.88 172.28,62.92 126.17,62.92 125.15,61.89 112.19,61.89 104.95,69.13 104.19,69.13 99.93,73.39 94.78,73.39 82.39,85.78 82.39,93.98 79.73,96.64 79.73,109.27 77.77,111.23 77.77,114.14 76.69,115.22 76.69,122.04 77.83,123.18 77.83,126.44 82.6,131.21 83.62,131.21 85.67,133.27 86.88,133.27 87.37,133.76 95.14,133.76 96.66,132.24 98.39,132.24 98.74,131.89 99.16,131.48
  BOTTOM w0.076: v2(103.22,132.12) 103.07,132.27 103.07,132.43 103.21,132.58 UC1.H8
USB3P1_RXN_CON: length 7.2
  BOTTOM w0.114: L10.3 281.54,35.19 282.27,35.19 282.39,35.31 D7.5 D7.6 283.78,35.31 283.97,35.11 285.05,35.11 285.43,35.49 285.93,35.49 286.57,36.13 286.82,36.13 287.09,36.39 JUSB1.5
USB3P1_RXN_R: length 2.1
  TOP w0.114: R74.2 209.79,94.24 209.63,94.39 209.28,94.39 208.98,94.7 208.77,94.7 208.68,94.61 U5.8
USB3P1_RXP: length 223.4
  TOP w0.114: v1(197.92,94.77) 198.13,94.57 198.39,94.57 v1(198.59,94.37) 198.72,94.24 201.48,94.24 201.73,94.5 R28.1
  IN1 w0.076: 99.34,131.66 99.35,131.64 99.35,131.58 99.59,131.34 100.48,131.34 100.86,131.73 102.62,131.73 102.7,131.8 102.7,131.98 v2(102.56,132.12)
  IN1 w0.14: 99.34,131.66 98.5,132.49 96.77,132.49 95.25,134.02 87.27,134.02 86.77,133.52 85.57,133.52 83.51,131.47 82.49,131.47 77.58,126.55 77.58,123.28 76.44,122.14 76.44,115.11 77.51,114.04 77.51,111.13 79.48,109.16 79.48,96.53 82.14,93.87 82.14,85.67 94.67,73.14 99.82,73.14 104.08,68.88 104.85,68.88 112.08,61.64 125.25,61.64 126.28,62.66 172.38,62.66 199.5,89.78 199.5,93.5 198.45,94.56 198.14,94.56 v1(197.92,94.77)
  BOTTOM w0.076: v2(102.56,132.12) 102.81,132.36 UC1.G8
USB3P1_RXP_CON: length 7.2
  BOTTOM w0.114: JUSB1.6 287.09,35.73 286.93,35.9 286.66,35.9 286.03,35.26 285.52,35.26 285.14,34.88 283.93,34.88 283.85,34.81 D7.7 D7.4 282.43,34.81 282.28,34.96 281.39,34.96 L10.2
USB3P1_RXP_R: length 2.1
  TOP w0.114: U5.9 208.77,95.11 208.92,94.95 209.05,94.95 209.38,94.62 209.66,94.62 209.76,94.72 R72.2
USB3P1_TXN: length 213.4
  TOP w0.114: C32.1 201.91,95.97 201.67,96.21 200.45,96.21 v1(200.29,96.04)
  IN1 w0.14: v1(200.29,96.04) 200.15,96.18 199.74,96.18 199.37,96.55 197.72,96.55 195.83,94.66 195.83,88.63 171.41,64.21 125.6,64.21 124.58,63.19 119.6,63.19 116.79,66 111.02,66 106.59,70.43 104.73,70.43 100.34,74.81 95.19,74.81 83.81,86.2 83.81,94.47 82.16,96.11 82.16,108.67 80.26,110.58 80.26,113.11 79.37,114 79.37,125.79 80.61,127.03 82.96,127.03 84.56,128.63 84.56,130.26 86.24,131.94 91.32,131.94 91.76,132.38 93.82,132.38 94.95,131.25 94.95,130.91 v1(95.12,130.74)
  BOTTOM w0.076: UC1.C13 99.78,129.75 99.53,129.67 99.35,129.67 99.16,129.73 99.01,129.73 98.9,129.67 98.48,129.67 98.24,129.92 96.68,129.92 96.65,129.95 96.63,129.95
  BOTTOM w0.114: 96.63,129.95 95.23,129.95 94.95,130.23 94.95,130.56 v1(95.12,130.74)
USB3P1_TXN_C: length 8.9
  BOTTOM w0.114: L9.4 279.74,33.38 v1(278.77,33.38) 277.83,33.38 277.31,33.9 277.31,36.44 278.21,37.34 278.21,38.69 278.36,38.84 C130.2
USB3P1_TXN_CON: length 9.2
  BOTTOM w0.114: L9.3 281.41,33.53 282.12,33.53 282.4,33.81 D7.2 D7.8 283.73,33.81 283.88,33.66 284.36,33.66 284.74,33.28 284.74,31.55 285.15,31.15 285.58,31.15 286.57,30.16 286.93,30.16 287.09,30.32 JUSB1.8
USB3P1_TXN_R: length 135.3
  TOP w0.114: v1(254.88,79.65) 254.65,79.42 254.37,79.42 253.24,78.28 236.95,78.28 229.16,86.07 201.24,86.07 v1(195.51,91.81) 194.48,92.83 194.48,95.14 195.77,96.43 199.44,96.43 199.66,96.2 199.66,95.78 199.93,95.51 200.79,95.51 R33.2
  IN3 w0.114: v1(254.88,79.65) 255.1,79.43 255.5,79.43 256.22,78.71 261.9,78.71 264.58,76.03 269.68,76.03 272.72,72.98 274.82,72.98 277.44,70.36 277.44,44.71 278.43,43.72 278.43,41.59 278.28,41.44 278.28,40.86 v1(278.47,40.67)
  BOTTOM w0.114: C130.1 278.87,39.78 278.37,39.78 278.25,39.9 278.25,40.46 v1(278.47,40.67)
USB3P1_TXP: length 213.4
  TOP w0.114: v1(200.29,96.68) 200.53,96.44 201.72,96.44 201.89,96.61 R27.1
  IN1 w0.14: v2(94.48,130.74) 94.69,130.95 94.69,131.14 93.71,132.12 91.86,132.12 91.42,131.69 86.35,131.69 84.81,130.15 84.81,128.52 83.07,126.78 80.72,126.78 79.62,125.68 79.62,114.11 80.51,113.22 80.51,110.68 82.42,108.78 82.42,96.22 84.06,94.57 84.06,86.3 95.3,75.07 100.45,75.07 104.83,70.68 106.69,70.68 111.13,66.25 116.9,66.25 119.71,63.44 124.47,63.44 125.5,64.47 171.31,64.47 195.57,88.73 195.57,94.77 197.62,96.81 199.48,96.81 199.85,96.44 200.04,96.44 v1(200.29,96.68)
  BOTTOM w0.076: UC1.D13 100.47,129.76 100.06,129.65 100.03,129.65 99.55,129.51 99.3,129.51 99.21,129.54 99.02,129.54 98.92,129.51 98.41,129.51 98.17,129.75 96.68,129.75 96.65,129.72 96.63,129.72
  BOTTOM w0.114: 96.63,129.72 95.14,129.72 94.72,130.13 94.72,130.5 v2(94.48,130.74)
USB3P1_TXP_C: length 8.9
  BOTTOM w0.114: L9.1 279.94,33.15 277.74,33.15 v1(277.29,33.6) 277.08,33.81 277.08,36.54 277.98,37.44 277.98,38.28 C121.2
USB3P1_TXP_CON: length 9.2
  BOTTOM w0.114: L9.2 281.52,33.31 D7.1 D7.9 283.75,33.31 283.88,33.43 284.27,33.43 284.51,33.19 284.51,31.46 285.05,30.92 285.48,30.92 286.47,29.93 286.9,29.93 287.09,29.74 JUSB1.9
USB3P1_TXP_R: length 135.2
  TOP w0.114: v1(254.88,79.01) 254.71,79.19 254.46,79.19 253.33,78.05 236.86,78.05 229.07,85.85 201.15,85.85 v1(200.33,86.66) 195.79,91.2 195.79,91.2 195.28,91.71 195.28,91.71 194.25,92.74 194.25,95.24 195.67,96.66 199.4,96.66 199.93,97.19 200.78,97.19 R27.2
  IN3 w0.114: v1(277.83,40.67) 278.07,40.91 278.07,41.52 278.22,41.68 278.22,43.63 277.23,44.62 277.23,70.28 274.73,72.78 272.64,72.78 269.59,75.82 264.5,75.82 261.81,78.51 256.14,78.51 255.41,79.23 255.1,79.23 v1(254.88,79.01)
  BOTTOM w0.114: v1(277.83,40.67) 278.02,40.48 278.02,39.9 277.91,39.78 C122.1
USB3P2_RXN: length 240.1
  TOP w0.114: v1(218.78,92.9) 219.23,92.45 C39.1
  IN1 w0.076: v2(103.83,133.03) 103.59,132.8 103.59,132.67 103.39,132.47 100.51,132.47 100.46,132.43 100.44,132.43
  IN1 w0.14: 100.44,132.43 99.89,132.43 99.19,133.13 96.87,133.13 95.46,134.54 86.38,134.54 85.95,134.11 83.38,134.11 82.48,133.21 82.48,132.19 76.95,126.66 76.95,123.49 76.07,122.6 75.81,122.6 75.13,121.92 75.13,115.64 76.99,113.77 76.99,110.91 78.96,108.95 78.96,96.31 81.62,93.66 81.62,85.46 94.45,72.62 99.61,72.62 103.87,68.36 104.63,68.36 111.87,61.12 124.83,61.12 125.37,60.58 145.87,60.58 146.41,61.12 171.58,61.12 201.08,90.62 211.62,90.62 214.78,93.78 218.26,93.78 218.55,93.49 218.55,93.13 v1(218.78,92.9)
  BOTTOM w0.076: v2(103.83,133.03) 104.11,133.27 UC1.J6
USB3P2_RXN_R: length 2.6
  TOP w0.114: R76.2 227.72,94.27 227.59,94.39 227.19,94.39 226.96,94.62 226.27,94.62 226.15,94.51 U6.8
USB3P2_RXP: length 240.1
  TOP w0.114: v1(218.14,92.88) 217.7,92.44 R34.1
  IN1 w0.076: 100.44,132.68 100.46,132.68 100.51,132.64 103.33,132.64 103.4,132.72 103.4,132.82 v2(103.19,133.03)
  IN1 w0.14: 100.44,132.68 99.99,132.68 99.3,133.38 96.98,133.38 95.57,134.79 86.27,134.79 85.84,134.36 83.28,134.36 82.23,133.31 82.23,132.3 76.7,126.77 76.7,123.6 75.96,122.86 75.71,122.86 74.88,122.03 74.88,115.53 76.74,113.67 76.74,110.81 78.7,108.84 78.7,96.21 81.36,93.55 81.36,85.35 94.35,72.37 99.5,72.37 103.76,68.1 104.52,68.1 111.76,60.87 124.72,60.87 125.26,60.33 145.98,60.33 146.51,60.87 171.68,60.87 201.19,90.37 211.73,90.37 214.89,93.53 218.16,93.53 218.29,93.39 218.29,93.03 v1(218.14,92.88)
  BOTTOM w0.076: UC1.H6 103.46,133.27 v2(103.19,133.03)
USB3P2_RXP_R: length 2.6
  TOP w0.114: U6.9 226.14,95.01 226.3,94.85 227.06,94.85 227.29,94.62 227.54,94.62 227.72,94.8 R75.2
USB3P2_TXN: length 235.4
  TOP w0.114: C37.1 219.06,96.27 218.73,96.6 217.25,96.6 v1(217.04,96.39)
  IN1 w0.14: v2(97.02,130.83) 96.92,130.93 96.92,131.24 95.01,133.15 91.44,133.15 91.03,132.75 85.93,132.75 83.76,130.58 83.76,129.95 83.71,129.9 83.71,129.9 83.08,129.26 81.39,129.26 78.35,126.23 78.35,122.96 77.32,121.93 77.32,121.09 77.77,120.64 77.77,118.11 77.39,117.73 77.39,115.27 78.29,114.37 78.29,111.45 80.7,109.04 80.7,96.48 82.91,94.26 82.91,85.99 94.96,73.95 100.11,73.95 104.4,69.65 106.27,69.65 110.72,65.2 116.49,65.2 119.28,62.41 124.9,62.41 125.92,63.44 171.88,63.44 196.7,88.26 196.7,94.39 197.85,95.54 198.99,95.54 199.5,95.03 201.28,95.03 203.44,97.19 205.47,97.19 206.36,98.08 213.36,98.08 214.85,96.59 216.83,96.59 v1(217.04,96.39)
  BOTTOM w0.076: v2(97.02,130.83) 96.88,130.69 96.88,130.54 97,130.42 99.12,130.42 99.32,130.22 99.32,130.05 UC1.B13
USB3P2_TXN_C: length 8.9
  BOTTOM w0.114: v1(278.77,13.72) 278.77,13.72 ; 278.77,13.72 278.52,13.47 277.76,13.47 277.35,13.88 277.35,15.87 278.56,17.08 278.56,18.44 278.69,18.57 C132.2 ; 278.77,13.72 279.17,14.12 279.66,14.12 L12.4
USB3P2_TXN_R: length 131.5
  TOP w0.114: v1(241.79,82.07) 241.68,81.96 236.95,81.96 231.74,87.17 220.69,87.17 215.67,92.19 215.67,96.98 215.81,97.13 216.25,97.13 216.42,96.95 216.42,96.25 216.85,95.82 217.84,95.82 R62.2
  IN3 w0.114: v1(278.35,23.64) 278.1,23.89 278.1,25.57 277.48,26.19 277.48,39.53 276.71,40.29 276.71,70 274.43,72.28 272.43,72.28 269.39,75.33 262.86,75.33 261.83,74.3 260.66,74.3 257.85,77.1 250.18,77.1 245.29,81.99 241.88,81.99 v1(241.79,82.07)
  BOTTOM w0.114: v1(278.35,23.64) 278.2,23.49 278.2,23.43 278.17,23.4 278.17,20.77 v1(278.29,20.65) 278.67,20.27 278.67,19.64 278.82,19.49 C132.1
USB3P2_TXP: length 235.3
  TOP w0.114: C36.1 219.03,96.95 218.92,96.83 217.23,96.83 217.04,97.02 v1(217.04,97.28)
  IN1 w0.14: v1(217.04,97.28) 217.04,96.99 216.9,96.85 214.95,96.85 213.47,98.33 206.25,98.33 205.36,97.44 203.33,97.44 201.17,95.28 199.6,95.28 199.1,95.79 197.74,95.79 196.45,94.5 196.45,88.37 171.77,63.69 125.82,63.69 124.79,62.67 119.39,62.67 116.6,65.46 110.82,65.46 106.37,69.91 104.51,69.91 100.21,74.2 95.06,74.2 83.17,86.1 83.17,94.37 80.95,96.59 80.95,109.15 78.54,111.55 78.54,114.47 77.64,115.38 77.64,117.62 78.02,118 78.02,120.74 77.57,121.19 77.57,121.82 78.61,122.86 78.61,126.12 81.49,129.01 83.18,129.01 83.96,129.79 83.96,129.8 84.02,129.85 84.02,130.47 86.04,132.49 91.13,132.49 91.54,132.9 94.91,132.9 96.67,131.14 96.67,131.04 v2(96.41,130.78)
  BOTTOM w0.076: UC1.A13 99.08,129.94 99.16,130.01 99.16,130.15 99.05,130.26 96.94,130.26 96.72,130.47 96.72,130.63 96.56,130.78 v2(96.41,130.78)
USB3P2_TXP_C: length 8.9
  BOTTOM w0.114: L12.1 279.77,13.89 279.27,13.89 278.62,13.24 277.66,13.24 v1(277.44,13.47) 277.12,13.78 277.12,15.96 278.33,17.17 278.33,18 C131.2
USB3P2_TXP_R: length 131.5
  TOP w0.114: v1(241.79,81.44) 241.5,81.73 236.85,81.73 231.65,86.94 220.6,86.94 215.44,92.1 215.44,97.08 215.71,97.35 216.23,97.35 216.7,97.82 217.74,97.82 R44.2
  IN3 w0.114: v1(241.79,81.44) 242.13,81.78 245.21,81.78 250.09,76.9 257.77,76.9 260.57,74.09 261.91,74.09 262.94,75.12 269.31,75.12 272.35,72.08 274.35,72.08 276.51,69.92 276.51,40.21 277.27,39.44 277.27,26.11 277.9,25.48 277.9,23.83 v1(277.7,23.64)
  BOTTOM w0.114: C131.1 278.31,19.54 278.44,19.67 278.44,20.17 277.94,20.68 v1(277.94,22.49) 277.94,23.4 v1(277.7,23.64)
USB3P3_RXN: length 126.4
  TOP w0.114: v1(115.51,68.63) 115.31,68.63 115.18,68.75 115.18,69.34 117.37,71.52 126.07,71.52 132.58,65.02 134.82,65.02 135.23,64.61 135.23,64 L17.4
  IN1 w0.076: 96.65,129.22 96.67,129.22 96.71,129.26 97.34,129.26 97.83,129.76 102.16,129.76 103.04,130.65 103.34,130.65 103.52,130.83 103.52,131.04 103.62,131.14 v2(103.83,131.14)
  IN1 w0.14: 96.65,129.22 93.48,129.22 92.9,128.64 92.18,128.64 92,128.82 88.76,128.82 84.4,124.46 83.94,124.46 82.51,123.03 82.51,121.03 81.95,120.47 81.95,115.07 82.85,114.16 82.85,111.63 84.98,109.51 84.98,100.73 85.59,100.12 85.59,96.33 87.1,94.82 87.1,86.55 96.26,77.39 101.57,77.39 102.34,76.61 103.11,76.61 106.64,73.08 107.83,73.08 110.25,70.66 113.68,70.66 115.16,69.19 115.16,68.82 115.35,68.63 v1(115.51,68.63)
  BOTTOM w0.076: UC1.J10 103.87,131.66 103.68,131.47 103.68,131.29 v2(103.83,131.14)
USB3P3_RXN_C: length 7.5
  TOP w0.114: JU3AC.8 132.16,57.25 132.29,57.39 132.29,59.57 v1(134.1,61.39) 134.76,62.05 135.13,62.05 135.25,62.16 135.25,62.33 L17.3
USB3P3_RXP: length 126.5
  TOP w0.114: v1(114.75,68.63) 114.95,68.83 114.95,69.43 117.27,71.75 126.17,71.75 132.67,65.25 134.92,65.25 135.46,64.71 135.46,63.97 L17.1
  IN1 w0.076: 96.65,129.47 96.67,129.47 96.71,129.43 97.27,129.43 97.76,129.92 102.09,129.92 102.98,130.81 103.27,130.81 103.36,130.9 103.36,131.04 v2(103.19,131.2)
  IN1 w0.14: 96.65,129.47 93.38,129.47 92.79,128.89 92.29,128.89 92.11,129.07 88.65,129.07 84.29,124.71 83.83,124.71 82.26,123.13 82.26,121.14 81.69,120.57 81.69,114.96 82.6,114.06 82.6,111.52 84.72,109.4 84.72,100.63 85.34,100.01 85.34,96.22 86.85,94.71 86.85,86.44 96.15,77.14 101.46,77.14 102.24,76.36 103,76.36 106.53,72.83 107.72,72.83 110.14,70.41 113.57,70.41 114.9,69.08 114.9,68.78 v1(114.75,68.63)
  BOTTOM w0.076: v2(103.19,131.2) 103.46,131.47 UC1.H10
USB3P3_RXP_C: length 7.5
  TOP w0.114: JU3AC.9 132.66,57.25 132.52,57.39 v1(132.52,59.22) 132.52,59.48 134.86,61.82 135.23,61.82 135.48,62.07 135.48,62.4 L17.2
USB3P3_TXN: length 117.6
  TOP w0.114: v1(116.65,69.62) 116.88,69.39 116.88,69.08 117.34,68.63 118.18,68.63 119.59,70.04 126.35,70.04 128.29,68.11 128.29,63.76 129.51,62.53 130.05,62.53 L18.4
  IN1 w0.14: v1(116.65,69.62) 116.91,69.87 116.91,70.1 115.82,71.19 110.63,71.19 108.17,73.64 106.84,73.64 104.35,76.13 104.35,76.95 103.72,77.58 102.21,77.58 100.69,79.1 97.85,79.1 97.64,78.9 95.49,78.9 87.66,86.73 87.66,95 86.11,96.55 86.11,100.33 85.5,100.95 85.5,109.72 83.37,111.84 83.37,115.21 82.47,116.12 82.47,120.25 83.03,120.81 83.03,122.81 84.15,123.93 84.61,123.93 88.98,128.3 91.79,128.3 92.03,128.05 93.22,128.05 93.73,128.56 94.6,128.56 95.01,128.14 95.01,127.33 v2(95.12,127.22)
  BOTTOM w0.076: UC1.B15 99.32,128.47 99.32,128.25 99.07,128 97.04,128 97.01,127.97 96.99,127.97
  BOTTOM w0.114: v2(95.12,127.22) 94.96,127.38 94.96,127.72 95.21,127.97 96.99,127.97
USB3P3_TXN_C: length 9.1
  TOP w0.114: JU3AC.5 130.66,57.25 130.93,57.52 130.93,59.48 133.37,61.92 133.37,62.38 133.04,62.71 v1(132.53,62.71) 131.88,62.71 131.51,62.34 L18.3
USB3P3_TXP: length 117.5
  TOP w0.114: L18.1 130.07,62.76 129.61,62.76 129.35,63.02 129.35,63.12 129.35,63.12 129.35,63.22 129.11,63.46 129.01,63.46 128.91,63.46 128.52,63.85 128.52,64.25 128.64,64.38 128.64,64.72 128.52,64.85 128.52,65.19 128.64,65.32 128.64,65.66 128.52,65.79 128.52,66.13 128.64,66.26 128.64,66.6 128.52,66.73 128.52,68.2 126.45,70.27 119.5,70.27 118.08,68.85 117.44,68.85 117.11,69.18 117.11,69.53 117.23,69.64 v1(117.47,69.64)
  IN1 w0.14: v1(117.47,69.64) 117.16,69.95 117.16,70.2 115.92,71.44 110.73,71.44 108.27,73.9 106.94,73.9 104.6,76.23 104.6,77.06 103.82,77.84 102.31,77.84 100.79,79.36 97.74,79.36 97.54,79.15 95.59,79.15 87.91,86.83 87.91,95.11 86.37,96.65 86.37,100.44 85.75,101.05 85.75,109.83 83.63,111.95 83.63,115.32 82.72,116.22 82.72,120.14 83.29,120.71 83.29,122.71 84.26,123.68 84.72,123.68 89.08,128.04 91.68,128.04 91.93,127.79 93.33,127.79 93.83,128.3 94.49,128.3 94.76,128.03 94.76,127.52 v2(94.45,127.21)
  BOTTOM w0.076: 96.99,128.2 97.01,128.2 97.04,128.17 99,128.17 99.15,128.32 99.15,128.48 99.05,128.59 UC1.A15
  BOTTOM w0.114: v2(94.45,127.21) 94.73,127.5 94.73,127.83 95.1,128.2 96.99,128.2
USB3P3_TXP_C: length 9.2
  TOP w0.114: L18.2 133.14,62.94 133.6,62.48 133.6,61.83 131.16,59.39 v1(131.16,58.16) JU3AC.6
USB3P4_RE_RXN: length 291.1
  TOP w0.114: v1(211.69,104.43) 211.47,104.65 211.47,104.65 211.47,104.88 212.5,105.9 212.5,114.51 229.39,131.4 251.18,131.4 253.57,129 253.57,126.51 258.59,121.5 258.59,121.11 259.18,120.52 260.91,120.52 261.03,120.4 C188.1
  IN1 w0.076: v2(101.29,131.2) 101.45,131.04 101.45,130.87 101.39,130.81 99.21,130.81 99.16,130.86 99.14,130.86
  IN1 w0.14: v1(211.69,104.43) 211.5,104.23 211.5,103.62 207.74,99.87 198.84,99.87 194.28,95.3 194.28,89.27 170.77,65.76 127.32,65.76 125.32,67.76 114.29,67.76 112.66,69.39 110,69.39 107.34,72.04 105.41,72.04 101.09,76.36 95.83,76.36 85.43,86.76 85.43,95.03 84.55,95.92 84.55,98.29 83.73,99.1 83.73,109.29 81.83,111.2 81.83,113.73 80.92,114.64 80.92,122.98 83.42,125.48 83.97,125.48 86.68,128.19 86.68,129 87.63,129.95 88.78,129.95 89.09,130.27 97.22,130.27 97.81,130.86 99.14,130.86
  BOTTOM w0.076: UC1.E10 101.51,131.43 v2(101.29,131.2)
USB3P4_RE_RXN_R: length 3.3
  TOP w0.114: U16.23 263.67,121.22 263.53,121.35 263.37,121.35 v1(263.08,121.07) 262.53,120.52 262.06,120.52 261.94,120.4 C188.2
USB3P4_RE_RXP: length 291
  TOP w0.114: v1(210.93,104.43) 210.99,104.43 211.24,104.68 211.24,104.97 212.27,106 212.27,114.6 229.3,131.63 251.27,131.63 253.8,129.1 253.8,126.61 258.82,121.59 258.82,121.2 259.28,120.75 260.91,120.75 261.03,120.86 C187.1
  IN1 w0.076: 99.14,130.6 99.16,130.6 99.21,130.65 101.46,130.65 101.62,130.81 101.62,131.08 101.74,131.2 v2(101.92,131.2)
  IN1 w0.14: v1(210.93,104.43) 211.1,104.43 211.24,104.29 211.24,103.73 207.64,100.12 198.74,100.12 194.02,95.41 194.02,89.37 170.67,66.02 127.42,66.02 125.42,68.02 114.39,68.02 112.77,69.64 110.1,69.64 107.45,72.3 105.52,72.3 101.2,76.62 95.94,76.62 85.69,86.87 85.69,95.14 84.8,96.02 84.8,98.4 83.99,99.21 83.99,109.4 82.08,111.31 82.08,113.84 81.17,114.75 81.17,122.88 83.53,125.23 84.08,125.23 86.93,128.09 86.93,128.89 87.74,129.7 88.88,129.7 89.2,130.02 97.33,130.02 97.91,130.6 99.14,130.6
  BOTTOM w0.076: v2(101.92,131.2) 101.82,131.31 101.82,131.51 101.98,131.66 UC1.F10
