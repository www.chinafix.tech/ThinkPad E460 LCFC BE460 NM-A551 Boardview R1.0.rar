# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA10: length 60.7
  IN1 w0.076: 130.34,109.93 130.13,109.93 129.96,110.11 123.16,110.11 120.42,107.37 119.46,107.37 119,106.92 118.27,106.92 118,107.19 v5(118,108.34)
  IN1 w0.165: 130.34,109.93 132.47,109.93 132.98,109.43 138.99,109.43 151.54,121.98 157.18,121.98 159.28,124.07 160.73,124.07 161.11,123.69 164.01,123.69 164.73,124.41 165.4,124.41 v1(165.79,124.03)
  BOTTOM w0.076: UC1.AT50 v5(118,108.34)
  BOTTOM w0.178: v1(165.79,124.03) 165.79,124.37 165.43,124.73 164.83,124.73 164.65,124.55 JDIMM1.107
DDR_A_MA11: length 59.8
  IN1 w0.076: v5(128.73,105.66) 129.51,104.88 130.93,104.88 131.73,104.07
  IN1 w0.165: 131.73,104.07 141.63,104.07 151.61,114.05 155.28,114.05 155.69,114.47 157.99,114.47 161.2,117.67 165.95,117.67 167.08,118.81 v1(167.23,118.81)
  BOTTOM w0.076: v5(128.73,105.66) 128.73,105.09 128.48,104.85 125.14,104.85 124.51,105.48 124.26,105.48 123,106.74 121.24,106.74 120.98,106.47 UC1.BA54
  BOTTOM w0.178: JDIMM1.84 168.85,117.65 167.69,118.81 v1(167.23,118.81)
DDR_A_MA12: length 61.4
  IN1 w0.076: v2(128.08,105.66) 129.02,104.72 130.8,104.72 131.89,103.63
  IN1 w0.165: v1(166.78,117.79) 166.78,117.39 166.62,117.23 161.39,117.23 157.23,113.07 156.84,113.07 156.68,113.24 156.68,113.35 156.51,113.51 156.18,113.51 156.02,113.35 156.02,113.24 155.85,113.07 154.58,113.07 154.04,113.61 151.79,113.61 141.81,103.63 131.89,103.63
  BOTTOM w0.076: v2(128.08,105.66) 127.47,105.05 125.24,105.05 124.65,105.64 124.33,105.64 123.07,106.91 120.76,106.91 120.54,106.69 119.99,106.69 119.68,106.38 UC1.AW54
  BOTTOM w0.178: v1(166.78,117.79) 166.78,116.69 166.39,116.3 165.45,116.3 164.41,117.35 JDIMM1.83
DDR_A_MA13: length 63.8
  IN1 w0.076: 130.57,112.61 129.58,112.61 129.41,112.44 125.05,112.44 124.75,112.13 121.38,112.13 119.42,110.17 v2(118.63,110.17)
  IN1 w0.165: 130.57,112.61 138.4,112.61 150.57,124.78 150.57,125.15 151.44,126.02 152.76,126.02 152.92,126.18 156.61,126.18 157.19,126.77 161.5,126.77 161.98,127.25 167.23,127.25 167.66,126.82 167.66,126 v1(167.73,125.93)
  BOTTOM w0.076: UC1.AU46 v2(118.63,110.17)
  BOTTOM w0.178: JDIMM1.119 164.65,128.15 164.79,128.01 166.97,128.01 167.73,127.25 v1(167.73,125.93)
DDR_A_MA14: length 62.4
  IN1 w0.165: v2(127.17,103.57) 127.17,102.53 127.82,101.88 130.1,101.88 131.93,100.06 132.44,100.06 132.44,100.06 143.58,100.06 151.23,107.72 157.35,107.72 157.72,108.09 157.72,108.51 161.05,111.84 161.75,111.84 163.31,113.4 167.36,113.4 168.76,114.79 168.86,114.79 v1(169.62,115.55)
  BOTTOM w0.076: 125.21,104.44 125.03,104.44 124.32,105.15 124.13,105.15 122.86,106.41 121.77,106.41 121.57,106.2 121.32,106.2 121.19,106.26 121.05,106.26 120.82,106.2 120.69,106.2 120.47,106.27 120.22,106.27 UC1.AY54
  BOTTOM w0.102: 125.21,104.44 126.78,104.44 127.17,104.05 v2(127.17,103.57)
  BOTTOM w0.178: JDIMM1.80 170.52,116.45 v1(169.62,115.55)
DDR_A_MA15: length 61.1
  IN1 w0.165: v2(125.22,103.82) 127.54,101.5 130.02,101.5 131.91,99.61 143.76,99.61 151.42,107.27 157.53,107.27 158.16,107.9 158.16,108.33 161.23,111.4 161.94,111.4 163.49,112.95 167.92,112.95 v1(169.22,114.25)
  BOTTOM w0.076: v2(125.22,103.82) 125.05,104 124.94,104 124.12,104.82 123.99,104.82 123.1,105.7 122.42,105.7 122.15,105.44 121.83,105.44 121.69,105.58 121.28,105.58 121.14,105.53 121.04,105.53 120.91,105.58 120.67,105.58 UC1.BA55
  BOTTOM w0.178: JDIMM1.78 170.81,115.85 v1(169.22,114.25)
DDR_A_RAS#: length 61.5
  IN1 w0.076: v2(118.63,108.34) 120.41,108.34 122.77,110.7 130.08,110.7 130.21,110.82 130.34,110.82
  IN1 w0.165: 130.34,110.82 139.13,110.82 151.17,122.86 156.81,122.86 158.94,124.99 161.07,124.99 161.48,124.58 163.64,124.58 164.36,125.3 166.6,125.3 167.08,124.82 v1(168.25,124.82)
  BOTTOM w0.076: UC1.AU50 v2(118.63,108.34)
  BOTTOM w0.178: v1(168.25,124.82) 169.26,124.82 169.71,125.27 170.53,125.27 170.71,125.45 JDIMM1.110
DDR_A_WE#: length 61
  IN1 w0.076: v5(118,110.17) 118.43,109.74 119.3,109.74 121.44,111.88 124.79,111.88 125.13,112.22 130.17,112.22 130.23,112.16 130.47,112.16
  IN1 w0.165: v1(165.03,126.68) 164.91,126.8 163.59,126.8 163.43,126.64 163.43,126.31 163.26,126.14 162.93,126.14 162.77,126.31 162.77,126.64 162.6,126.8 162.16,126.8 161.68,126.32 158.38,126.32 157.09,125.02 151.44,125.02 138.58,112.16 130.47,112.16
  BOTTOM w0.076: UC1.AT46 v5(118,110.17)
  BOTTOM w0.178: v1(165.03,126.68) 165.44,127.09 165.82,127.09 166.01,126.9 166.01,125.86 165.83,125.68 165.17,125.68 164.5,126.35 JDIMM1.113
DDR_B_BS0: length 49.9
  IN3 w0.165: v2(128.9,111.6) 128.9,111.37 129.14,111.13 131.53,111.13 131.84,110.82 136.07,110.82 148.44,123.19 148.44,124.01 149,124.57 150.69,124.57 150.92,124.81 151.15,124.81 151.34,124.61 151.58,124.61 151.83,124.87 151.83,125.03 152.04,125.25 152.21,125.25 152.52,125.55 v1(152.53,125.55)
  BOTTOM w0.076: 127.29,112.05 127.01,112.05 126.86,112.19 124.99,112.19 124.92,112.12 123.32,112.12 123.32,112.12 122.86,112.12 122.76,112.22 122.76,112.22 121.52,112.22 UC1.BB44
  BOTTOM w0.178: JDIMM2.109 151.39,125.15 151.43,125.11 151.93,125.11 152.02,125.19 152.07,125.19 152.43,125.55 v1(152.53,125.55) ; v2(128.9,111.6) 129.72,111.6 130.04,111.27 130.04,109.77 130.21,109.59 131.18,109.59 131.43,109.84 131.43,111.49 130.65,112.27 128.79,112.27 128.57,112.05 127.29,112.05
DDR_B_BS1: length 49.9
  IN3 w0.076: v2(126.88,111.6) 126.88,111.84 127.07,112.03 128.98,112.03 129.39,111.61 131.67,111.61
  IN3 w0.165: v1(155.13,125.71) 155.34,125.71 155.81,126.18 155.81,126.41 155.62,126.6 155.15,126.6 154.77,126.22 154.39,126.22 154,126.6 153.69,126.6 153.3,126.21 151.7,126.21 150.5,125.02 148.81,125.02 147.99,124.2 147.99,123.37 135.88,111.27 132.02,111.27 131.67,111.61
  BOTTOM w0.076: UC1.BA44 121.03,112.05 122.69,112.05 122.79,111.95 123.25,111.95 125.04,111.95 125.09,112 126.47,112 v2(126.88,111.6)
  BOTTOM w0.178: JDIMM2.108 157.14,124.85 156.88,124.59 156.57,124.59 156.32,124.84 156.32,125 156.14,125.18 155.78,125.18 155.6,125 155.6,124.81 155.4,124.61 155.1,124.61 154.86,124.85 154.86,125.44 v1(155.13,125.71)
DDR_B_BS2: length 50.6
  IN3 w0.076: 122.77,104.91 121.1,104.91 120.41,105.6 120.41,105.92 120,106.32 119.69,106.32 118.93,107.08 117.08,107.08 v2(116.73,107.43)
  IN3 w0.165: 122.77,104.91 124.66,103.01 125.44,103.01 125.79,103.36 126.39,103.36 126.75,103.01 130.68,103.01 131.6,102.09 139.29,102.09 151.61,114.41 153.64,114.41 153.81,114.57 153.81,114.81 v1(153.65,114.97)
  BOTTOM w0.076: UC1.AP52 116.35,107.81 v2(116.73,107.43)
  BOTTOM w0.178: JDIMM2.79 151.2,116.15 151.7,115.65 152.08,115.65 153.29,114.44 153.56,114.44 153.74,114.62 153.74,114.87 v1(153.65,114.97)
DDR_B_CAS#: length 51.4
  IN3 w0.076: 128.93,112.72 127.86,112.72 127.73,112.85 127.73,113.04 127.86,113.17 v2(128.04,113.17)
  IN3 w0.165: 128.93,112.72 129.15,112.95 132.63,112.95 132.8,112.78 132.8,112.76 132.96,112.6 133.29,112.6 133.46,112.76 133.46,112.78 133.62,112.95 133.95,112.95 134.12,112.78 134.12,112.76 134.28,112.6 134.61,112.6 134.78,112.76 134.78,112.78 134.94,112.95 135.49,112.95 135.78,113.24 145.72,123.17 145.72,123.57 145.98,123.84 146.38,123.84 146.66,124.12 146.66,124.75 148.26,126.35 149.85,126.35 151.56,128.06 152.48,128.06 153.11,128.69 154.25,128.69 154.48,128.47 154.48,128.16 153.86,127.54 v1(153.73,127.54)
  BOTTOM w0.076: UC1.AY43 120.08,112.79 120.18,112.79 120.34,112.71 120.52,112.71 120.68,112.77 120.83,112.77 121.04,112.7 121.16,112.7 121.24,112.74 121.27,112.75 121.65,112.75 121.83,112.56 122.91,112.56 123.03,112.45 123.46,112.45 124.59,112.45 124.72,112.57 128.14,112.57 128.33,112.76 128.33,113.02 128.17,113.17 v2(128.04,113.17)
  BOTTOM w0.178: v1(153.73,127.54) 154.12,127.14 154.12,126.81 153.94,126.64 153.53,126.64 153.11,127.05 152.81,127.05 152.4,126.64 152.08,126.64 151.77,126.95 JDIMM2.115
DDR_B_D0: length 67.2
  IN3 w0.114: v2(111.32,92.11) 110.86,92.11 110.45,91.71 110.45,86.52 115.47,81.5 144.16,81.5 148.95,86.29 150.46,86.29 152.54,88.37 152.54,89.55 v1(154.39,91.4)
  BOTTOM w0.076: UC1.AF70 111.94,96.87 111.47,96.4 111.47,95.56 110.79,94.88 110.79,92.64 v2(111.32,92.11)
  BOTTOM w0.114: JDIMM2.5 152.29,91.55 152.86,90.98 153.97,90.98 v1(154.39,91.4)
DDR_B_D1: length 69.1
  IN3 w0.114: v2(111.32,90.81) 110.84,90.34 110.84,86.59 115.61,81.83 144.02,81.83 148.82,86.62 150.32,86.62 150.95,87.25 150.95,87.41 150.37,87.99 150.37,88.16 150.53,88.32 150.69,88.32 151.27,87.74 151.44,87.74 151.6,87.9 151.6,88.06 150.99,88.67 150.99,88.83 151.15,88.99 151.31,88.99 151.79,88.51 151.95,88.51 152.21,88.77 152.21,89.68 153.32,90.79 153.32,91.15 v1(153.05,91.42)
  BOTTOM w0.114: JDIMM2.7 151.43,92.15 151.57,92.01 152.31,92.01 152.89,91.42 v1(153.05,91.42) ; UC1.AF68 111.69,98.04 111.69,97.41 111.25,96.97 111.25,95.78 110.37,94.91 110.37,91.76 v2(111.32,90.81)
DDR_B_D2: length 66.6
  IN3 w0.114: v1(155.16,94.84) 154.74,94.43 152.83,94.43 146.44,88.03 146.44,87.22 143.93,84.71 140.33,84.71 140.15,84.53 140.15,84.35 140.04,84.24 139.81,84.24 139.69,84.35 139.69,84.53 139.58,84.64 139.35,84.64 139.24,84.53 139.24,84.35 139.12,84.24 138.89,84.24 138.78,84.35 138.78,84.53 138.67,84.64 138.44,84.64 138.32,84.53 138.32,84.35 138.21,84.24 137.98,84.24 137.87,84.35 137.87,84.53 137.75,84.64 137.52,84.64 137.41,84.53 137.41,84.35 137.29,84.24 137.07,84.24 136.95,84.35 136.95,84.53 136.84,84.64 136.61,84.64 136.49,84.53 136.49,84.35 136.38,84.24 136.15,84.24 136.04,84.35 136.04,84.53 135.92,84.64 135.69,84.64 135.58,84.53 135.58,84.35 135.47,84.24 135.24,84.24 135.12,84.35 135.12,84.53 135.01,84.64 134.78,84.64 134.67,84.53 134.67,84.35 134.55,84.24 121.68,84.24 121.37,83.93 116.48,83.93 113.15,87.26 113.15,91.94 v2(112.45,92.64)
  BOTTOM w0.076: 113.11,93.3 113.17,93.35 113.17,96.34 UC1.AH71
  BOTTOM w0.114: 113.11,93.3 v2(112.45,92.64) ; v1(155.16,94.84) 154.74,94.43 153.66,94.43 153.53,94.55 JDIMM2.15
DDR_B_D3: length 68.9
  IN3 w0.114: v1(153.83,94.87) 152.8,94.87 146.11,88.17 146.11,87.35 143.79,85.04 134.54,85.04 134.07,84.57 132.09,84.57 131.97,84.68 131.97,84.86 131.86,84.97 131.63,84.97 131.52,84.86 131.52,84.68 131.4,84.57 131.17,84.57 131.06,84.68 131.06,84.86 130.95,84.97 130.72,84.97 130.6,84.86 130.6,84.68 130.49,84.57 130.26,84.57 130.15,84.68 130.15,84.86 130.03,84.97 129.8,84.97 129.69,84.86 129.69,84.68 129.57,84.57 129.35,84.57 129.23,84.68 129.23,84.86 129.12,84.97 128.89,84.97 128.77,84.86 128.77,84.68 128.66,84.57 128.43,84.57 128.32,84.68 128.32,84.86 128.2,84.97 127.97,84.97 127.86,84.86 127.86,84.68 127.75,84.57 127.52,84.57 127.4,84.68 127.4,84.86 127.29,84.97 127.06,84.97 126.95,84.86 126.95,84.68 126.83,84.57 126.6,84.57 126.49,84.68 126.49,84.86 126.37,84.97 126.15,84.97 126.03,84.86 126.03,84.68 125.92,84.57 125.69,84.57 125.57,84.68 125.57,84.86 125.46,84.97 125.23,84.97 125.12,84.86 125.12,84.68 125,84.57 124.77,84.57 124.66,84.68 124.66,84.86 124.55,84.97 124.32,84.97 124.2,84.86 124.2,84.68 124.09,84.57 123.86,84.57 123.74,84.68 123.74,84.86 123.63,84.97 123.4,84.97 123.29,84.86 123.29,84.68 123.17,84.57 122.94,84.57 122.83,84.68 122.83,84.86 122.72,84.97 122.49,84.97 122.37,84.86 122.37,84.68 122.26,84.57 116.32,84.57 113.49,87.4 113.49,92.8 113.06,93.23 v2(112.44,93.23)
  BOTTOM w0.076: UC1.AH68 112.62,98.39 112.41,98.18 112.41,97.74 112.34,97.63 112.34,97.32 112.38,97.19 112.38,96.97 112.38,96.96 112.37,96.95 112.37,96.95 112.34,96.86 112.34,96.66 112.37,96.57 112.37,96.21 111.97,95.81 111.97,94.92 111.88,94.83
  BOTTOM w0.114: JDIMM2.17 151.58,95.15 151.67,95.06 153.65,95.06 v1(153.83,94.87) ; 111.88,94.83 111.88,93.79 v2(112.44,93.23)
DDR_B_D4: length 68.5
  IN3 w0.114: v2(111.32,94.05) 109.79,92.52 109.79,86.24 115.2,80.83 144.43,80.83 149.23,85.63 150.73,85.63 153.2,88.1 153.2,88.92 154.26,89.97 155.69,89.97 v1(157.12,91.4)
  BOTTOM w0.076: UC1.AF69 112.14,97.64 112.14,97.37 112.19,97.24 112.19,96.94 112.17,96.89 112.17,96.63 112.19,96.58 112.19,96.26 111.8,95.88 111.8,95.15 111.32,94.67 v2(111.32,94.05)
  BOTTOM w0.114: JDIMM2.4 157.27,91.25 v1(157.12,91.4)
DDR_B_D5: length 66.9
  IN3 w0.114: v2(111.32,92.77) 111,92.77 110.12,91.88 110.12,86.38 115.34,81.16 144.3,81.16 149.09,85.96 150.59,85.96 152.87,88.24 152.87,89.05 154.12,90.3 154.51,90.3 v1(155.73,91.52)
  BOTTOM w0.076: v2(111.32,92.77) 110.95,93.13 110.95,94.62 111.64,95.31 111.64,96.13 UC1.AF71
  BOTTOM w0.114: JDIMM2.6 157.43,91.85 157.37,91.91 156.29,91.91 155.9,91.52 v1(155.73,91.52)
DDR_B_D6: length 68.7
  IN3 w0.114: v1(157.08,94.84) 156.01,93.77 153.11,93.77 147.1,87.76 147.1,86.94 143.42,83.27 140.37,83.27 140.26,83.38 140.26,83.44 140.14,83.56 139.91,83.56 139.8,83.44 139.8,83.38 139.68,83.27 139.46,83.27 139.34,83.38 139.34,83.44 139.23,83.56 139,83.56 138.88,83.44 138.88,83.38 138.77,83.27 138.54,83.27 138.43,83.38 138.43,83.44 138.31,83.56 138.08,83.56 137.97,83.44 137.97,83.38 137.86,83.27 137.63,83.27 137.51,83.38 137.51,83.44 137.4,83.56 137.17,83.56 137.06,83.44 137.06,83.38 136.94,83.27 136.71,83.27 136.6,83.38 136.6,83.44 136.48,83.56 136.26,83.56 136.14,83.44 136.14,83.38 136.03,83.27 135.8,83.27 135.68,83.38 135.68,83.44 135.57,83.56 135.34,83.56 135.23,83.44 135.23,83.38 135.11,83.27 134.88,83.27 134.77,83.38 134.77,83.44 134.66,83.56 134.43,83.56 134.31,83.44 134.31,83.38 134.2,83.27 133.97,83.27 133.86,83.38 133.86,83.44 133.74,83.56 133.51,83.56 133.4,83.44 133.4,83.38 133.28,83.27 133.06,83.27 132.94,83.38 132.94,83.44 132.83,83.56 132.6,83.56 132.48,83.44 132.48,83.38 132.37,83.27 132.14,83.27 132.03,83.38 132.03,83.44 131.91,83.56 131.68,83.56 131.57,83.44 131.57,83.38 131.45,83.27 131.23,83.27 131.11,83.38 131.11,83.44 131,83.56 130.77,83.56 130.65,83.44 130.65,83.38 130.54,83.27 130.31,83.27 130.2,83.38 130.2,83.44 130.08,83.56 129.85,83.56 129.74,83.44 129.74,83.38 129.63,83.27 129.4,83.27 129.28,83.38 129.28,83.44 129.17,83.56 128.94,83.56 128.83,83.44 128.83,83.38 128.71,83.27 116.21,83.27 112.31,87.17 112.31,89.76 112.01,90.06 112.01,90.34 112.43,90.76 v2(112.43,90.81)
  BOTTOM w0.076: UC1.AH69 113.27,97.52 113.66,97.12 113.66,96.65 113.7,96.58 113.7,96.22 113.5,96.02 113.5,92.95
  BOTTOM w0.114: 113.5,92.95 113.5,91.83 112.48,90.81 v2(112.43,90.81) ; v1(157.08,94.84) 157.09,94.85 JDIMM2.16
DDR_B_D7: length 67.7
  IN3 w0.114: v5(112.46,91.45) 112.81,91.11 112.81,87.14 116.35,83.6 121.51,83.6 121.82,83.91 122.26,83.91 122.37,83.79 122.37,83.71 122.49,83.6 122.72,83.6 122.83,83.71 122.83,83.79 122.94,83.91 123.17,83.91 123.29,83.79 123.29,83.71 123.4,83.6 123.63,83.6 123.74,83.71 123.74,83.79 123.86,83.91 124.09,83.91 124.2,83.79 124.2,83.71 124.32,83.6 124.55,83.6 124.66,83.71 124.66,83.79 124.77,83.91 125,83.91 125.12,83.79 125.12,83.71 125.23,83.6 125.46,83.6 125.57,83.71 125.57,83.79 125.69,83.91 125.92,83.91 126.03,83.79 126.03,83.71 126.15,83.6 126.37,83.6 126.49,83.71 126.49,83.79 126.6,83.91 126.83,83.91 126.95,83.79 126.95,83.71 127.06,83.6 127.29,83.6 127.4,83.71 127.4,83.79 127.52,83.91 127.75,83.91 127.86,83.79 127.86,83.71 127.97,83.6 128.2,83.6 128.32,83.71 128.32,83.79 128.43,83.91 140.6,83.91 140.71,84.02 140.71,84.26 140.83,84.37 141.05,84.37 141.17,84.26 141.17,84.02 141.28,83.91 141.51,83.91 141.63,84.02 141.63,84.26 141.74,84.37 141.97,84.37 142.08,84.26 142.08,84.02 142.2,83.91 142.43,83.91 142.54,84.02 142.54,84.26 142.65,84.37 142.88,84.37 143,84.26 143,84.02 143.11,83.91 143.6,83.91 146.77,87.08 146.77,87.89 152.97,94.1 155.06,94.1 v1(155.8,94.84)
  BOTTOM w0.076: UC1.AH70 113.27,96.94 113.41,96.8 113.41,96.79 113.42,96.79 113.53,96.54 113.53,96.29 113.33,96.09 113.33,93.14 113.09,92.89 113.09,92.84
  BOTTOM w0.114: v1(155.8,94.84) 156.41,95.45 JDIMM2.18 ; 113.09,92.84 113.09,92.07 v5(112.46,91.45)
DDR_B_D8: length 64.6
  IN3 w0.076: v5(112.71,99.38) 112.71,98.97 113.1,98.57 113.1,97.97 114.11,96.96
  IN3 w0.114: v1(155.04,97.6) 153.7,96.26 152.37,96.26 142.8,86.68 122.76,86.68 122.21,87.22 121.3,87.22 120.25,86.16 116.69,86.16 114.94,87.91 114.94,90.56 115.36,90.98 115.36,92.2 114.97,92.59 114.97,96.27 114.28,96.96 114.11,96.96
  BOTTOM w0.076: UC1.AF67 v5(112.71,99.38)
  BOTTOM w0.114: v1(155.04,97.6) 153.92,96.48 151.49,96.48 151.37,96.35 JDIMM2.21
DDR_B_D9: length 64.1
  IN3 w0.076: v2(112.71,101.29) 112.71,101.29 113.09,100.91 113.09,98.97 113.36,98.69 113.36,97.94 113.98,97.31 114.15,97.31
  IN3 w0.114: 114.15,97.31 114.42,97.31 115.92,95.81 115.92,95.09 116.6,94.41 116.6,94.25 116.29,93.93 116.29,93.77 116.41,93.65 116.65,93.65 116.92,93.93 117.09,93.93 117.25,93.76 117.25,93.6 117.03,93.38 117.03,93.22 117.19,93.06 117.35,93.06 117.57,93.28 117.73,93.28 118.29,92.72 118.64,92.72 119.12,92.23 119.59,92.23 122.3,89.52 122.3,89.02 122.1,88.82 122.1,88.66 122.25,88.51 122.44,88.51 122.63,88.7 122.79,88.7 122.95,88.54 122.95,88.38 122.45,87.88 122.45,87.72 122.59,87.58 122.8,87.58 123.27,88.05 123.44,88.05 123.6,87.89 123.6,87.73 123.2,87.34 123.2,87.17 123.36,87.01 123.53,87.01 123.92,87.41 124.08,87.41 124.48,87.01 142.66,87.01 152.24,96.59 153.56,96.59 154.06,97.09 154.06,97.3 v1(153.76,97.6)
  BOTTOM w0.076: UC1.AF64 v2(112.71,101.29)
  BOTTOM w0.114: JDIMM2.23 151.32,96.95 151.47,96.81 152.97,96.81 v1(153.76,97.6)
DDR_B_D10: length 63.8
  IN3 w0.076: v2(114.54,100.02) 114.9,99.65 114.9,98.78 116.22,97.46 116.95,97.46 118.36,96.05 118.36,96.02 118.38,96
  IN3 w0.114: v1(155.14,101.11) 155.68,101.11 155.8,101 155.8,100.53 155.64,100.37 154.71,100.37 154.6,100.49 154.6,100.57 154.49,100.68 154.26,100.68 154.14,100.57 154.14,100.49 154.03,100.37 153.05,100.37 142.77,90.09 134.01,90.09 133.89,89.97 133.89,89.57 133.78,89.45 133.55,89.45 133.44,89.57 133.44,89.97 133.32,90.09 133.09,90.09 132.98,89.97 132.98,89.57 132.87,89.45 132.64,89.45 132.52,89.57 132.52,89.97 132.41,90.09 132.18,90.09 132.07,89.97 132.07,89.57 131.95,89.45 131.72,89.45 131.61,89.57 131.61,89.97 131.49,90.09 131.27,90.09 131.15,89.97 131.15,89.57 131.04,89.45 130.81,89.45 130.69,89.57 130.69,89.97 130.58,90.09 130.35,90.09 130.24,89.97 130.24,89.57 130.12,89.45 129.89,89.45 129.78,89.57 129.78,89.97 129.66,90.09 129.44,90.09 129.32,89.97 129.32,89.57 129.21,89.45 128.98,89.45 128.86,89.57 128.86,89.97 128.75,90.09 128.22,90.09 127.72,90.6 124.91,90.6 122.59,92.92 121.66,92.92 120.89,93.69 120.89,93.8 119.39,95.29 118.84,95.29 118.38,95.76 118.38,96
  BOTTOM w0.076: UC1.AK66 v2(114.54,100.02)
  BOTTOM w0.114: JDIMM2.33 151.43,99.95 151.58,100.09 154.12,100.09 v1(155.14,101.11)
DDR_B_D11: length 64.7
  IN3 w0.076: 120.57,95.41 119.93,96.04 118.73,96.04 117.15,97.62 116.34,97.62 115.09,98.87 115.09,100.1 v2(114.54,100.65)
  IN3 w0.114: v1(153.86,101.13) 153.86,100.9 153.67,100.71 152.91,100.71 143.14,90.93 142.61,90.93 142.49,90.81 142.49,90.53 142.38,90.42 142.15,90.42 142.03,90.53 142.03,90.81 141.92,90.93 141.69,90.93 141.58,90.81 141.58,90.53 141.46,90.42 141.23,90.42 141.12,90.53 141.12,90.81 141.01,90.93 140.78,90.93 140.66,90.81 140.66,90.53 140.55,90.42 140.32,90.42 140.21,90.53 140.21,90.81 140.09,90.93 139.86,90.93 139.75,90.81 139.75,90.53 139.63,90.42 139.41,90.42 139.29,90.53 139.29,90.81 139.18,90.93 138.95,90.93 138.83,90.81 138.83,90.53 138.72,90.42 138.49,90.42 138.38,90.53 138.38,90.81 138.26,90.93 138.03,90.93 137.92,90.81 137.92,90.53 137.8,90.42 137.58,90.42 137.46,90.53 137.46,90.81 137.35,90.93 137.12,90.93 137,90.81 137,90.53 136.89,90.42 136.66,90.42 136.55,90.53 136.55,90.81 136.43,90.93 136.2,90.93 136.09,90.81 136.09,90.53 135.98,90.42 135.75,90.42 135.63,90.53 135.63,90.81 135.52,90.93 135.29,90.93 135.18,90.81 135.18,90.53 135.06,90.42 134.83,90.42 134.72,90.53 134.72,90.81 134.6,90.93 134.38,90.93 134.26,90.81 134.26,90.53 134.15,90.42 133.92,90.42 133.8,90.53 133.8,90.81 133.69,90.93 133.46,90.93 133.35,90.81 133.35,90.53 133.23,90.42 133,90.42 132.89,90.53 132.89,90.81 132.78,90.93 132.55,90.93 132.43,90.81 132.43,90.53 132.32,90.42 132.09,90.42 131.98,90.53 131.98,90.81 131.86,90.93 131.63,90.93 131.52,90.81 131.52,90.53 131.4,90.42 131.18,90.42 131.06,90.53 131.06,90.81 130.95,90.93 130.72,90.93 130.6,90.81 130.6,90.53 130.49,90.42 130.26,90.42 130.15,90.53 130.15,90.81 130.03,90.93 129.8,90.93 129.69,90.81 129.69,90.53 129.58,90.42 129.35,90.42 129.23,90.53 129.23,90.81 129.12,90.93 128.89,90.93 128.78,90.81 128.78,90.61 128.64,90.47 128.43,90.47 128.32,90.58 128.32,90.81 128.2,90.93 125.05,90.93 120.57,95.41
  BOTTOM w0.076: UC1.AK65 v2(114.54,100.65)
  BOTTOM w0.114: JDIMM2.35 151.44,100.55 151.57,100.42 153.16,100.42 v1(153.86,101.13)
DDR_B_D12: length 64.3
  IN3 w0.076: v2(112.71,100.02) 112.33,99.64 112.33,98.99 112.83,98.49 112.83,97.99 114.1,96.71
  IN3 w0.114: 114.1,96.71 114.1,96.65 114.65,96.1 114.65,92.47 114.9,92.22 114.9,91.03 114.61,90.74 114.61,87.77 116.55,85.83 120.45,85.83 121.51,86.89 122.08,86.89 122.62,86.35 142.93,86.35 152.49,95.9 154.1,95.9 v1(154.6,96.41)
  BOTTOM w0.076: UC1.AF66 v2(112.71,100.02)
  BOTTOM w0.114: v1(154.6,96.41) 155.19,95.82 156.72,95.82 157.56,96.65 JDIMM2.22
DDR_B_D13: length 64.7
  IN3 w0.076: 114,96.43 112.57,97.86 112.57,98.39 112.17,98.79 112.17,100.12 v5(112.71,100.65)
  IN3 w0.114: 114,96.43 114.3,96.13 114.3,90.86 114.28,90.85 114.28,87.64 116.42,85.5 121.22,85.5 121.73,86.02 143.07,86.02 152.62,95.57 155.58,95.57 v1(156.42,96.42)
  BOTTOM w0.076: UC1.AF65 v5(112.71,100.65)
  BOTTOM w0.114: v1(156.42,96.42) 156.43,96.43 156.75,96.43 157.57,97.25 JDIMM2.24
DDR_B_D14: length 65.6
  IN3 w0.076: 114.87,97.45 113.26,99.06 113.26,101.45 113.47,101.66 114.16,101.66 v2(114.54,101.29)
  IN3 w0.114: 114.87,97.45 116.31,96.01 116.31,95.23 118.47,93.07 118.75,93.07 119.29,92.54 119.75,92.54 122.8,89.49 122.8,89.27 123.77,88.3 124.2,88.3 124.31,88.19 124.31,87.84 124.42,87.73 124.65,87.73 124.77,87.84 124.77,88.19 124.88,88.3 125.13,88.3 126.09,87.34 142.52,87.34 152.1,96.92 152.66,96.92 153.07,97.33 153.07,97.87 153.25,98.05 157.82,98.05 157.93,98.17 157.93,98.57 157.74,98.76 156.6,98.76 156.41,98.95 v1(156.41,99.4)
  BOTTOM w0.076: UC1.AK64 v2(114.54,101.29)
  BOTTOM w0.114: JDIMM2.34 156.82,100.25 156.41,99.83 v1(156.41,99.4)
DDR_B_D15: length 62.6
  IN3 w0.076: 118.07,95.97 116.77,97.26 116.05,97.26 114.54,98.78 v2(114.54,99.38)
  IN3 w0.114: 118.07,95.97 118.07,95.74 118.78,95.03 119.37,95.03 120.12,94.28 120.12,94.01 121.52,92.62 122.31,92.62 124.66,90.27 127.58,90.27 127.93,89.91 127.93,89.51 128.34,89.1 133.89,89.1 134.55,89.76 134.81,89.76 134.93,89.64 134.93,89.21 135.04,89.1 135.27,89.1 135.39,89.21 135.39,89.64 135.5,89.76 135.73,89.76 135.84,89.64 135.84,89.21 135.96,89.1 136.19,89.1 136.3,89.21 136.3,89.64 136.41,89.76 136.64,89.76 136.76,89.64 136.76,89.21 136.87,89.1 137.1,89.1 137.21,89.21 137.21,89.64 137.33,89.76 142.9,89.76 153.19,100.04 156.52,100.04 156.63,100.16 156.63,100.41 156.75,100.53 156.98,100.53 157.09,100.41 157.09,100.16 157.2,100.04 157.47,100.04 157.85,100.43 157.85,101.19 157.45,101.6 156.94,101.6 v1(156.45,101.11)
  BOTTOM w0.076: UC1.AK67 v2(114.54,99.38)
  BOTTOM w0.114: JDIMM2.36 157.59,100.85 157.42,100.68 156.63,100.68 156.45,100.86 v1(156.45,101.11)
DDR_B_D16: length 49.4
  IN3 w0.076: v2(118,101.94) 118.1,101.94 118.61,101.43 120.08,101.43 121.33,100.19 122.66,100.19 123.49,99.36 123.49,98.64 124.48,97.65 128.2,97.65
  IN3 w0.114: v1(153.78,108.19) 153.99,107.98 153.99,107.65 153.78,107.44 151.74,107.44 141.11,96.81 129.03,96.81 128.2,97.65
  BOTTOM w0.076: v2(118,101.94) 117.65,102.29 UC1.AT61
  BOTTOM w0.114: JDIMM2.57 154.15,107.15 154.36,107.36 154.36,107.6 v1(153.78,108.19)
DDR_B_D17: length 48.9
  IN3 w0.076: v2(118.63,101.94) 119.16,101.94 119.49,101.62 120.19,101.62 121.45,100.35 122.79,100.35 123.7,99.44 123.7,98.7 124.58,97.83 128.4,97.83
  IN3 w0.114: v1(152.47,108.2) 152.47,107.92 152.32,107.77 151.6,107.77 141.27,97.45 140.79,97.45 140.68,97.33 140.68,97.26 140.57,97.14 140.34,97.14 140.22,97.26 140.22,97.33 140.11,97.45 139.88,97.45 139.77,97.33 139.77,97.26 139.65,97.14 139.42,97.14 139.31,97.26 139.31,97.33 139.19,97.45 138.96,97.45 138.85,97.33 138.85,97.26 138.74,97.14 138.51,97.14 138.39,97.26 138.39,97.33 138.28,97.45 138.05,97.45 137.94,97.33 137.94,97.26 137.82,97.14 137.59,97.14 137.48,97.26 137.48,97.33 137.36,97.45 137.14,97.45 137.02,97.33 137.02,97.26 136.91,97.14 136.68,97.14 136.56,97.26 136.56,97.33 136.45,97.45 136.22,97.45 136.11,97.33 136.11,97.26 135.99,97.14 135.76,97.14 135.65,97.26 135.65,97.33 135.54,97.45 135.31,97.45 135.19,97.33 135.19,97.26 135.08,97.14 134.85,97.14 134.74,97.26 134.74,97.33 134.62,97.45 134.39,97.45 134.28,97.33 134.28,97.26 134.16,97.14 133.94,97.14 133.82,97.26 133.82,97.33 133.71,97.45 133.48,97.45 133.36,97.33 133.36,97.26 133.25,97.14 133.02,97.14 132.91,97.26 132.91,97.33 132.79,97.45 132.56,97.45 132.45,97.33 132.45,97.26 132.34,97.14 132.11,97.14 131.99,97.26 131.99,97.33 131.88,97.45 131.65,97.45 131.54,97.33 131.54,97.26 131.42,97.14 131.19,97.14 131.08,97.26 131.08,97.33 130.96,97.45 130.74,97.45 130.62,97.33 130.62,97.26 130.51,97.14 130.28,97.14 130.16,97.26 130.16,97.33 130.05,97.45 129.82,97.45 129.71,97.33 129.71,97.26 129.59,97.14 129.36,97.14 129.25,97.26 129.25,97.33 129.14,97.45 128.78,97.45 128.4,97.83
  BOTTOM w0.076: UC1.AU61 118.3,102.28 v2(118.63,101.94)
  BOTTOM w0.114: JDIMM2.59 151.57,107.75 151.78,107.55 152.63,107.55 152.75,107.66 152.75,107.92 v1(152.47,108.2)
DDR_B_D18: length 52.7
  IN3 w0.076: 126.55,100.17 126.22,100.17 125.77,99.72 125.33,99.72 122.83,102.21 121.83,102.21 120.59,103.45 118.46,103.45 118.23,103.22 117.09,103.22 v2(116.73,102.86)
  IN3 w0.114: 126.55,100.17 128.83,100.17 129.45,99.55 140.38,99.55 151.73,110.89 152.92,110.89 153.04,111 153.04,111.35 153.15,111.47 153.38,111.47 153.49,111.36 153.49,111 153.61,110.89 154.15,110.89 154.31,111.05 154.31,111.22 v1(153.93,111.61)
  BOTTOM w0.076: UC1.AP60 116.35,103.24 v2(116.73,102.86)
  BOTTOM w0.114: v1(153.93,111.61) 154.33,111.2 154.33,110.83 152.79,109.29 152.07,109.29 151.22,110.15 JDIMM2.67
DDR_B_D19: length 53
  IN3 w0.076: v2(116.09,102.86) 116.09,103.22 116.27,103.39 117.64,103.39 118.31,104.06 118.76,104.06 119.14,103.68 120.66,103.68 121.9,102.44 122.87,102.44 124.81,100.5 126.55,100.5
  IN3 w0.114: v1(152.63,111.62) 152.63,111.41 152.44,111.22 151.59,111.22 140.25,99.88 129.52,99.88 128.9,100.5 126.55,100.5
  BOTTOM w0.076: v2(116.09,102.86) 115.7,103.25 UC1.AN60
  BOTTOM w0.114: JDIMM2.69 151.61,110.75 151.75,110.61 151.75,110.08 152.08,109.75 152.25,109.75 152.39,109.88 152.39,110.95 152.5,111.06 152.75,111.06 152.88,110.93 152.88,110.37 153.02,110.24 153.27,110.24 153.48,110.45 153.48,111.87 153.31,112.05 152.84,112.05 152.63,111.84 v1(152.63,111.62)
DDR_B_D20: length 51.1
  IN3 w0.076: 129.06,96.48 128.11,97.43 124.43,97.43 123.31,98.56 123.31,99.3 122.58,100.02 121.24,100.02 120.02,101.24 118.55,101.24 118.2,101.59 117.08,101.59 v2(116.73,101.94)
  IN3 w0.114: 129.06,96.48 141.25,96.48 151.88,107.11 154.54,107.11 155.14,107.71 v1(155.14,108.18)
  BOTTOM w0.076: v2(116.73,101.94) 116.35,102.32 UC1.AP61
  BOTTOM w0.114: JDIMM2.56 157.42,106.85 157.26,107.02 155.77,107.02 155.14,107.64 v1(155.14,108.18)
DDR_B_D21: length 51.7
  IN3 w0.076: 129.11,96.15 128.01,97.25 124.33,97.25 123.11,98.47 123.11,99.23 122.51,99.84 121.18,99.84 119.95,101.07 118.49,101.07 118.16,101.41 116.63,101.41 v2(116.09,101.94)
  IN3 w0.114: 129.11,96.15 141.38,96.15 152.01,106.78 154.68,106.78 155.09,107.19 156.34,107.19 156.52,107.38 v1(156.52,108.18)
  BOTTOM w0.076: UC1.AN61 115.7,102.34 v2(116.09,101.94)
  BOTTOM w0.114: JDIMM2.58 157.25,107.45 v1(156.52,108.18)
DDR_B_D22: length 51.3
  IN3 w0.076: 126.55,99.84 126.25,99.84 125.95,99.54 125.2,99.54 122.72,102.02 121.63,102.02 120.4,103.25 118.5,103.25 118.11,102.86 v2(118,102.86)
  IN3 w0.114: v1(155.21,111.6) 155.87,110.93 155.87,110.67 155.76,110.56 155.25,110.56 155.13,110.67 155.13,110.94 155.02,111.05 154.79,111.05 154.67,110.94 154.67,110.67 154.56,110.56 151.86,110.56 140.52,99.22 129.37,99.22 128.75,99.84 126.55,99.84
  BOTTOM w0.076: UC1.AT60 117.65,103.21 v2(118,102.86)
  BOTTOM w0.114: v1(155.21,111.6) 155.21,111.14 155.36,110.98 156.72,110.98 157.25,110.45 JDIMM2.68
DDR_B_D23: length 50.6
  IN3 w0.076: v2(118.63,102.86) 118.84,103.07 120.18,103.07 121.42,101.83 122.55,101.83 125.01,99.36 126.2,99.36 126.34,99.51 126.47,99.51
  IN3 w0.114: 126.47,99.51 126.49,99.48 128.63,99.48 129.23,98.89 140.66,98.89 152,110.23 157.44,110.23 157.56,110.34 157.56,110.61 157.43,110.73 156.65,110.73 156.49,110.9 v1(156.49,111.59)
  BOTTOM w0.076: v2(118.63,102.86) 118.3,103.19 UC1.AU60
  BOTTOM w0.114: JDIMM2.70 157.6,111.05 157.34,111.31 156.77,111.31 v1(156.49,111.59)
DDR_B_D24: length 50.5
  IN3 w0.076: v2(118,99.2) 118,98.06 119.46,96.59 121.58,96.59 122.06,96.12 122.06,95.57
  IN3 w0.114: v1(154.31,103.37) 154.31,102.8 154.03,102.53 152.87,102.53 142.55,92.21 125.65,92.21 125.27,92.58 125.02,92.58 122.06,95.55 122.06,95.57
  BOTTOM w0.076: UC1.AT66 117.65,99.55 v2(118,99.2)
  BOTTOM w0.114: v1(154.31,103.37) 154.31,103.15 152.9,101.75 JDIMM2.39
DDR_B_D25: length 50.1
  IN3 w0.076: 124.84,93.04 122.4,95.49 122.4,96 121.39,97.01 120.16,97.01 119.7,97.47 119.17,97.47 118.63,98 v2(118.63,99.2)
  IN3 w0.114: v1(153.67,103.36) 153.77,103.26 153.77,103.01 153.62,102.86 152.65,102.86 142.49,92.7 141.67,92.7 141.54,92.56 141.22,92.56 141.08,92.7 140.76,92.7 140.62,92.56 140.3,92.56 140.16,92.7 139.84,92.7 139.71,92.56 139.39,92.56 139.25,92.7 138.93,92.7 138.79,92.56 138.47,92.56 138.34,92.7 138.01,92.7 137.88,92.56 137.56,92.56 137.42,92.7 137.1,92.7 136.96,92.56 136.64,92.56 136.51,92.7 136.19,92.7 136.05,92.56 135.73,92.56 135.59,92.7 135.27,92.7 135.13,92.56 134.81,92.56 134.68,92.7 134.36,92.7 134.22,92.56 133.9,92.56 133.76,92.7 133.44,92.7 133.31,92.56 132.99,92.56 132.85,92.7 132.53,92.7 132.39,92.56 132.07,92.56 131.93,92.7 131.61,92.7 131.48,92.56 131.16,92.56 131.02,92.7 130.7,92.7 130.56,92.56 130.24,92.56 130.11,92.7 129.79,92.7 129.65,92.56 129.33,92.56 129.19,92.7 128.87,92.7 128.73,92.56 128.41,92.56 128.28,92.7 127.96,92.7 127.82,92.56 127.5,92.56 127.36,92.7 127.04,92.7 126.91,92.56 126.58,92.56 126.45,92.7 126.13,92.7 125.99,92.56 125.77,92.56 125.28,93.04 124.84,93.04
  BOTTOM w0.076: UC1.AU66 v2(118.63,99.2)
  BOTTOM w0.114: v1(153.67,103.36) 153.67,102.98 153.04,102.35 JDIMM2.41
DDR_B_D26: length 52.9
  IN3 w0.076: v2(116.73,100.12) 116.73,100.4 116.83,100.5 118.24,100.5 118.41,100.67 119.75,100.67 121.74,98.68 122.33,98.68 123.12,97.88 123.12,96.96 124.04,96.04 124.45,96.04 124.47,96.06 124.65,96.06
  IN3 w0.114: v1(154.21,106.16) 153.74,106.16 152.96,105.38 152.15,105.38 141.61,94.84 141.46,94.84 141.35,94.95 141.35,95.07 141.23,95.19 141,95.19 140.89,95.07 140.89,94.95 140.77,94.84 128.8,94.84 128.48,95.16 127.36,95.16 126.46,96.06 124.65,96.06
  BOTTOM w0.076: UC1.AP65 116.35,100.49 v2(116.73,100.12)
  BOTTOM w0.114: JDIMM2.51 151.55,105.35 154.56,105.35 154.79,105.58 154.79,106.4 154.64,106.55 154.32,106.55 154.21,106.44 v1(154.21,106.16)
DDR_B_D27: length 53.4
  IN3 w0.076: 124.65,96.41 124.05,96.41 123.37,97.09 123.37,97.88 121.69,99.56 121.15,99.56 119.86,100.85 118.36,100.85 118.16,100.66 116.63,100.66 v2(116.09,100.12)
  IN3 w0.114: 124.65,96.41 126.74,96.41 127.62,95.53 128.97,95.53 129.15,95.36 129.48,95.36 129.66,95.53 129.88,95.53 130,95.42 130,95.29 130.11,95.18 130.34,95.18 130.46,95.29 130.46,95.42 130.57,95.53 130.8,95.53 130.91,95.42 130.91,95.29 131.03,95.18 131.26,95.18 131.37,95.29 131.37,95.42 131.48,95.53 131.71,95.53 131.83,95.42 131.83,95.29 131.94,95.18 132.17,95.18 132.28,95.29 132.28,95.42 132.4,95.53 132.63,95.53 132.74,95.42 132.74,95.29 132.86,95.18 133.08,95.18 133.2,95.29 133.2,95.42 133.31,95.53 133.54,95.53 133.66,95.42 133.66,95.29 133.77,95.18 134,95.18 134.11,95.29 134.11,95.42 134.23,95.53 134.46,95.53 134.57,95.42 134.57,95.29 134.69,95.18 134.91,95.18 135.03,95.29 135.03,95.42 135.14,95.53 135.37,95.53 135.49,95.42 135.49,95.29 135.6,95.18 135.83,95.18 135.94,95.29 135.94,95.42 136.06,95.53 136.29,95.53 136.4,95.42 136.4,95.29 136.51,95.18 136.74,95.18 136.86,95.29 136.86,95.42 136.97,95.53 137.2,95.53 137.31,95.42 137.31,95.29 137.43,95.18 137.66,95.18 137.77,95.29 137.77,95.42 137.89,95.53 138.11,95.53 138.23,95.42 138.23,95.29 138.34,95.18 138.57,95.18 138.69,95.29 138.69,95.42 138.8,95.53 139.03,95.53 139.14,95.42 139.14,95.29 139.26,95.18 139.49,95.18 139.6,95.29 139.6,95.42 139.71,95.53 139.94,95.53 140.06,95.42 140.06,95.29 140.18,95.17 140.39,95.17 140.51,95.29 140.51,95.42 140.63,95.53 141.84,95.53 152.03,105.73 152.5,105.73 v1(152.93,106.16)
  BOTTOM w0.076: UC1.AN65 115.7,100.51 v2(116.09,100.12)
  BOTTOM w0.114: JDIMM2.53 151.41,105.95 151.68,105.68 152.85,105.68 153.02,105.85 153.02,106.07 v1(152.93,106.16)
DDR_B_D28: length 51.8
  IN3 w0.076: v2(116.73,99.2) 116.73,99.1 119.4,96.43 121.41,96.43 121.82,96.02 121.82,95.5
  IN3 w0.114: v1(155.07,103.32) 155.31,103.08 155.31,102.58 154.93,102.2 153,102.2 142.68,91.88 125.45,91.88 121.82,95.5
  BOTTOM w0.076: UC1.AP66 v2(116.73,99.2)
  BOTTOM w0.114: v1(155.07,103.32) 156.34,102.05 JDIMM2.40
DDR_B_D29: length 52.6
  IN3 w0.076: 121.62,95.31 121.62,95.97 121.32,96.27 119.33,96.27 116.84,98.76 116.53,98.76 v2(116.09,99.2)
  IN3 w0.114: v1(156.41,103.38) 156.41,102.23 156.02,101.85 153.12,101.85 142.82,91.55 125.31,91.55 124.28,92.57 124.28,92.65 121.62,95.31
  BOTTOM w0.076: UC1.AN66 115.7,99.59 v2(116.09,99.2)
  BOTTOM w0.114: JDIMM2.42 157.14,102.65 v1(156.41,103.38)
DDR_B_D30: length 51.8
  IN3 w0.076: 124.65,95.72 124.03,95.72 122.84,96.92 122.84,97.88 122.22,98.5 121.64,98.5 119.77,100.37 118.93,100.37 118.81,100.5 118.5,100.5 118.12,100.12 v2(118,100.12)
  IN3 w0.114: 124.65,95.72 126.29,95.72 127.24,94.77 128.38,94.77 128.38,94.78 128.65,94.51 141.75,94.51 152.28,105.04 153.09,105.04 153.59,105.55 154.33,105.55 v1(155.34,106.56)
  BOTTOM w0.076: UC1.AT65 117.65,100.46 v2(118,100.12)
  BOTTOM w0.114: v1(155.34,106.56) 155.12,106.34 155.12,105.51 155.4,105.23 155.63,105.23 155.75,105.34 155.75,105.68 155.86,105.79 156.09,105.79 156.2,105.68 156.2,105.34 156.32,105.23 157.2,105.23 157.38,105.05 JDIMM2.50
DDR_B_D31: length 50.7
  IN3 w0.076: 124.65,95.39 124.1,95.39 121.32,98.17 121.32,98.49 119.7,100.12 v2(118.63,100.12)
  IN3 w0.114: 124.65,95.39 126.12,95.39 127.06,94.44 128.19,94.44 128.5,94.14 141.85,94.14 152.41,104.71 153.22,104.71 153.72,105.21 155.04,105.21 155.16,105.32 155.16,105.89 155.27,106 155.5,106 155.61,105.89 155.61,105.32 155.73,105.21 156.01,105.21 156.2,105.39 v1(156.2,106.58)
  BOTTOM w0.076: UC1.AU65 118.3,100.45 v2(118.63,100.12)
  BOTTOM w0.114: v1(156.2,106.58) 157.13,105.65 JDIMM2.52
DDR_B_D32: length 48.8
  IN3 w0.076: 131.5,117.58 131.41,117.58 130.33,116.51 123.74,116.51 121.63,114.39 120.54,114.39 119.98,113.83 v2(118.63,113.83)
  IN3 w0.114: 131.5,117.58 133.71,117.58 134.41,118.28 134.59,118.28 137.24,120.93 137.69,120.93 141.55,124.79 141.55,125.24 142.58,126.26 142.58,126.45 146.57,130.44 147.5,130.44 149.21,132.15 150.04,132.15 151.13,133.24 152.51,133.24 152.55,133.21 153.21,133.21 v1(153.96,132.47)
  BOTTOM w0.076: UC1.AU40 v2(118.63,113.83)
  BOTTOM w0.114: JDIMM2.129 152.64,131.15 v1(153.96,132.47)
DDR_B_D33: length 49.4
  IN3 w0.076: 131.31,117.23 130.38,116.3 123.82,116.3 121.64,114.13 120.63,114.13 120.06,113.55 118.91,113.55 118.78,113.43 118.52,113.43 118.11,113.83 v2(118,113.83)
  IN3 w0.114: 131.31,117.23 133.82,117.23 134.54,117.95 135.18,117.95 136.52,119.3 136.52,119.46 136.48,119.5 136.48,119.66 136.64,119.82 136.8,119.82 136.84,119.78 137.01,119.78 137.17,119.94 137.17,120.1 137.13,120.15 137.13,120.31 137.29,120.47 137.45,120.47 137.49,120.43 137.65,120.43 141.88,124.65 141.88,125.1 142.91,126.13 142.91,126.31 146.7,130.11 148.29,130.11 148.46,130.28 148.46,130.44 148.29,130.61 148.29,130.77 148.45,130.93 148.62,130.93 148.78,130.77 148.94,130.77 149.11,130.93 149.11,131.09 148.94,131.25 148.94,131.42 149.1,131.58 149.26,131.58 149.43,131.41 149.59,131.41 150,131.82 150.18,131.82 151.27,132.91 152.22,132.91 v1(152.67,132.47)
  BOTTOM w0.076: UC1.AT40 v2(118,113.83)
  BOTTOM w0.114: JDIMM2.131 151.63,131.75 151.81,131.57 152.53,131.57 152.96,132.01 152.96,132.17 v1(152.67,132.47)
DDR_B_D34: length 50.5
  IN3 w0.076: 129.86,118.27 129.68,118.27 129.64,118.23 123.6,118.23 122.47,117.1 120.56,117.1 119.68,116.23 118.56,116.23 v2(118,115.66)
  IN3 w0.114: 129.86,118.27 131.69,120.1 132.78,120.1 133.39,120.71 133.58,120.71 140.15,127.28 140.15,127.47 141.52,128.83 141.52,129.4 143.28,131.16 143.84,131.16 147.35,134.67 148.3,134.67 150.03,136.39 153.63,136.39 153.79,136.23 v1(153.79,135.94)
  BOTTOM w0.076: UC1.AT37 v2(118,115.66)
  BOTTOM w0.114: JDIMM2.141 153.62,134.75 154,135.13 154,135.73 v1(153.79,135.94)
DDR_B_D35: length 50.1
  IN3 w0.076: 129.86,118.03 123.71,118.03 122.6,116.92 120.73,116.92 119.83,116.02 119,116.02 v2(118.65,115.66)
  IN3 w0.114: v1(152.42,135.94) 150.85,135.94 150.55,135.64 150.39,135.64 150.15,135.88 149.99,135.88 149.83,135.72 149.83,135.56 150.07,135.32 150.07,135.16 149.91,134.99 149.74,134.99 149.51,135.23 149.34,135.23 149.18,135.07 149.18,134.91 149.42,134.67 149.42,134.51 149.25,134.34 148.42,134.34 147.95,133.87 147.79,133.87 147.5,134.16 147.33,134.16 147.17,133.99 147.17,133.83 147.46,133.54 147.46,133.38 147.3,133.22 147.14,133.22 146.85,133.51 146.69,133.51 146.53,133.35 146.53,133.19 146.82,132.9 146.82,132.73 146.69,132.61 145.76,132.61 143.98,130.83 143.41,130.83 141.85,129.26 141.85,128.7 140.48,127.33 140.48,127.14 133.71,120.38 133.53,120.38 132.92,119.77 131.72,119.77 129.98,118.03 129.86,118.03
  BOTTOM w0.076: UC1.AU37 v2(118.65,115.66)
  BOTTOM w0.114: JDIMM2.143 151.48,135.35 151.75,135.08 152.36,135.08 152.6,135.33 152.6,135.75 v1(152.42,135.94)
DDR_B_D36: length 50.8
  IN3 w0.076: v2(117.36,113.83) 117.37,113.83 117.73,113.47 118.24,113.47 118.46,113.25 120.18,113.25 120.8,113.86 121.68,113.86 123.87,116.05 130.38,116.05 131.23,116.9
  IN3 w0.114: v1(155.35,132.47) 154.92,132.03 150.85,132.03 150.31,131.49 150.14,131.49 148.43,129.78 146.84,129.78 143.24,126.18 143.24,125.99 142.21,124.96 142.21,124.52 135.31,117.62 134.68,117.62 133.96,116.9 131.23,116.9
  BOTTOM w0.076: UC1.AR40 v2(117.36,113.83)
  BOTTOM w0.114: v1(155.35,132.47) 156.37,131.45 JDIMM2.130
DDR_B_D37: length 51.7
  IN3 w0.076: v5(116.73,113.83) 117.26,113.3 118.14,113.3 118.46,112.97 120.26,112.97 120.95,113.66 123.19,113.66 124.54,115 129.76,115 130.24,115.49 130.24,115.63 131.18,116.57 131.51,116.57
  IN3 w0.114: 131.51,116.57 134.09,116.57 134.82,117.29 135.45,117.29 142.54,124.38 142.54,124.83 143.57,125.85 143.57,126.04 146.98,129.45 148.56,129.45 150.27,131.16 150.45,131.16 150.99,131.7 156.01,131.7 156.45,132.14 v1(156.45,132.47)
  BOTTOM w0.076: UC1.AP40 v5(116.73,113.83)
  BOTTOM w0.114: JDIMM2.132 156.86,132.05 v1(156.45,132.47)
DDR_B_D38: length 52.4
  IN3 w0.076: v5(116.73,115.66) 117.24,115.15 119.3,115.15 119.66,115.51 119.93,115.51 120.94,116.52 122.89,116.52 123.42,117.05 130.19,117.05 130.65,117.51 130.65,117.93 131.52,118.79
  IN3 w0.114: 131.52,118.79 131.78,119.06 133.14,119.06 133.8,119.72 133.99,119.72 141.14,126.87 141.14,127.06 142.51,128.42 142.51,128.99 143.69,130.17 144.25,130.17 146.03,131.95 146.96,131.95 148.61,133.6 149.44,133.6 150.99,135.15 154.1,135.15 v1(155.42,133.83)
  BOTTOM w0.076: UC1.AP37 v5(116.73,115.66)
  BOTTOM w0.114: v1(155.42,133.83) 156.03,134.45 JDIMM2.140
DDR_B_D39: length 51.6
  IN3 w0.076: 130.18,117.8 123.78,117.8 122.7,116.72 120.89,116.72 119.98,115.81 119.74,115.81 119.24,115.31 117.71,115.31 v2(117.36,115.66)
  IN3 w0.114: v1(155.11,135.88) 155.11,135.51 154.88,135.27 154.44,135.27 154.24,135.48 150.85,135.48 149.39,134.01 148.55,134.01 146.83,132.28 145.89,132.28 144.11,130.5 143.55,130.5 142.18,129.12 142.18,128.56 140.81,127.2 140.81,127.01 133.85,120.05 133.66,120.05 133.03,119.41 131.79,119.41 130.18,117.8
  BOTTOM w0.076: UC1.AR37 v2(117.36,115.66)
  BOTTOM w0.114: JDIMM2.142 155.94,135.05 v1(155.11,135.88)
DDR_B_D40: length 53
  IN3 w0.076: 129.97,120.14 129.9,120.06 123.39,120.06 121.35,118.02 118.53,118.02 v2(118,117.49)
  IN3 w0.114: 129.97,120.14 132.26,122.42 133.01,122.42 138.48,127.89 138.48,128.15 139.9,129.58 139.9,130.07 142.61,132.77 143.17,132.77 147.5,137.1 148.31,137.1 149.77,138.55 154.43,138.55 154.66,138.31 154.66,138.05 154.4,137.79 v1(154.3,137.79)
  BOTTOM w0.076: v2(118,117.49) 117.86,117.67 UC1.AT33
  BOTTOM w0.114: v1(154.3,137.79) 154.83,137.25 154.83,136.79 154.59,136.55 JDIMM2.147
DDR_B_D41: length 52.7
  IN3 w0.076: v2(118.63,117.49) 118.88,117.74 121.35,117.74 123.35,119.74
  IN3 w0.114: 123.35,119.74 128.46,119.74 128.58,119.63 128.58,119.47 128.69,119.35 128.92,119.35 129.03,119.47 129.03,119.63 129.15,119.74 130.05,119.74 132.4,122.09 133.15,122.09 138.81,127.75 138.81,128.02 140.23,129.44 140.23,129.93 142.74,132.44 143.31,132.44 147.64,136.77 148.45,136.77 149.9,138.22 150.88,138.22 151,138.11 151,137.81 151.11,137.7 151.34,137.7 151.46,137.81 151.46,138.11 151.57,138.22 152.73,138.22 152.87,138.08 v1(152.87,137.79)
  BOTTOM w0.076: UC1.AU33 118.5,117.67 v2(118.63,117.49)
  BOTTOM w0.114: v1(152.87,137.79) 152.87,138.82 153.05,138.99 153.54,138.99 153.66,138.88 153.66,137.04 153.49,136.88 151.82,136.88 151.55,137.15 JDIMM2.149
DDR_B_D42: length 51.4
  IN3 w0.076: v2(118.63,119.32) 119.16,119.32 119.48,119.63 121.04,119.63 121.52,120.11 122.45,120.11 123.15,120.81 123.15,121.17 123.53,121.55 130.21,121.55 131.15,122.49 131.15,123.35
  IN3 w0.114: 131.15,123.35 131.71,123.91 132.46,123.91 136.82,128.27 136.82,129.02 142.46,134.66 142.53,134.66 143.6,135.73 144.03,135.73 148.29,140 154.1,140 154.21,140.11 154.21,140.39 v1(153.82,140.78)
  BOTTOM w0.076: UC1.AU30 v2(118.63,119.32)
  BOTTOM w0.114: v1(153.82,140.78) 154,140.6 154,140.06 153.49,139.55 JDIMM2.157
DDR_B_D43: length 52.6
  IN3 w0.076: v2(118,119.32) 118.12,119.32 118.52,119.71 119.12,119.71 119.24,119.83 120.99,119.83 121.45,120.29 122.37,120.29 122.79,120.71 122.79,121.14 123.54,121.89 130.23,121.89 130.88,122.55 130.88,123.43
  IN3 w0.114: 130.88,123.43 130.88,123.55 131.68,124.35 132.43,124.35 136.49,128.41 136.49,129.16 140.87,133.54 140.87,134.35 142.1,135.57 142.9,135.57 144.42,137.09 144.58,137.09 144.64,137.04 144.8,137.04 144.97,137.2 144.97,137.36 144.91,137.42 144.91,137.58 145.07,137.74 145.23,137.74 145.29,137.68 145.45,137.68 145.61,137.84 145.61,138.01 145.55,138.06 145.55,138.23 145.72,138.39 145.88,138.39 145.94,138.33 146.1,138.33 146.26,138.49 146.26,138.65 146.2,138.71 146.2,138.87 146.36,139.03 146.52,139.03 146.58,138.98 146.74,138.98 146.91,139.14 146.91,139.3 146.85,139.36 146.85,139.52 147.01,139.68 147.17,139.68 147.23,139.62 147.39,139.62 147.55,139.78 147.55,139.95 147.5,140 147.5,140.17 147.66,140.33 148.69,140.33 148.81,140.44 148.81,140.8 148.92,140.92 149.15,140.92 149.26,140.8 149.26,140.44 149.38,140.33 149.61,140.33 149.72,140.44 149.72,140.8 149.84,140.92 150.06,140.92 150.18,140.8 150.18,140.44 150.29,140.33 150.52,140.33 150.64,140.44 150.64,140.8 150.75,140.92 150.98,140.92 151.09,140.8 151.09,140.44 151.21,140.33 152,140.33 v1(152.48,140.8)
  BOTTOM w0.076: UC1.AT30 v2(118,119.32)
  BOTTOM w0.114: v1(152.48,140.8) 151.82,140.15 JDIMM2.159
DDR_B_D44: length 53.5
  IN3 w0.076: v2(117.36,117.49) 117.37,117.49 117.73,117.13 118.24,117.13 118.46,116.91 118.99,116.91 119.66,117.58 121.47,117.58 122.51,118.62 128.84,118.62
  IN3 w0.114: v1(155.67,137.71) 156.22,137.16 156.22,136.87 156.04,136.68 154.7,136.68 154.03,137.35 149.64,137.35 148.73,136.44 147.77,136.44 143.44,132.11 142.88,132.11 140.56,129.79 140.56,129.31 139.14,127.88 139.14,127.62 133.28,121.76 132.53,121.76 129.7,118.93 129.14,118.93 128.84,118.62
  BOTTOM w0.076: v2(117.36,117.49) 117.22,117.67 UC1.AR33
  BOTTOM w0.114: v1(155.67,137.71) 157.13,136.25 JDIMM2.146
DDR_B_D45: length 54.5
  IN3 w0.076: 129.04,118.42 128.65,118.42 128.61,118.46 122.66,118.46 121.54,117.33 119.67,117.33 119.04,116.7 118.41,116.7 118.16,116.96 117.27,116.96 116.73,117.49 v5(116.73,117.49)
  IN3 w0.114: 129.04,118.42 129.22,118.6 129.84,118.6 132.67,121.43 133.42,121.43 139.47,127.48 139.47,127.74 140.89,129.17 140.89,129.66 143.02,131.78 143.58,131.78 147.91,136.11 148.86,136.11 149.77,137.02 153.9,137.02 154.56,136.35 156.94,136.35 157.19,136.6 157.19,136.98 v1(156.48,137.69)
  BOTTOM w0.076: UC1.AP33 116.58,117.67 v5(116.73,117.49)
  BOTTOM w0.114: JDIMM2.148 157.33,136.85 v1(156.48,137.69)
DDR_B_D46: length 53.1
  IN3 w0.076: v2(117.36,119.32) 117.74,119.69 118.25,119.69 118.57,120.01 120.58,120.01 121.67,121.09 122.31,121.09 123.31,122.09 130.14,122.09 130.6,122.54 130.6,123.43
  IN3 w0.114: v1(155.24,140.77) 154.74,141.27 148.13,141.27 142.77,135.9 141.96,135.9 140.54,134.48 140.54,133.68 136.16,129.3 136.16,128.54 132.29,124.68 131.54,124.68 130.6,123.73 130.6,123.43
  BOTTOM w0.076: UC1.AR30 v2(117.36,119.32)
  BOTTOM w0.114: v1(155.24,140.77) 156.16,139.85 JDIMM2.158
DDR_B_D47: length 54.1
  IN3 w0.076: 130.29,123.43 130.29,122.52 130.06,122.29 123.23,122.29 122.2,121.26 121.52,121.26 120.44,120.19 118.51,120.19 118.19,119.87 117.28,119.87 116.73,119.32 v5(116.73,119.32)
  IN3 w0.114: 130.29,123.43 130.29,123.89 131.4,125.01 132.15,125.01 135.83,128.68 135.83,129.43 139.65,133.25 139.65,134.22 140.2,134.77 140.36,134.77 141.82,136.23 142.63,136.23 147.99,141.6 155.46,141.6 v1(156.33,140.73)
  BOTTOM w0.076: UC1.AP30 v5(116.73,119.32)
  BOTTOM w0.114: JDIMM2.160 157.56,140.45 157.38,140.27 156.79,140.27 v1(156.33,140.73)
DDR_B_D48: length 56.2
  IN3 w0.076: v2(118.65,121.15) 118.86,120.93 120.02,120.93 121.12,122.03 121.63,122.03 123.81,124.21 128.87,124.21 129.06,124.4
  IN3 w0.114: v1(154.1,142.99) 154.1,143.26 153.81,143.56 152.98,143.56 152.75,143.78 146.33,143.78 145.98,143.43 145.98,143.27 146.2,143.05 146.2,142.89 146.04,142.73 145.87,142.73 145.66,142.95 145.5,142.95 145.33,142.78 145.33,142.62 145.55,142.41 145.55,142.24 145.39,142.08 145.23,142.08 145.01,142.3 144.85,142.3 144.69,142.14 144.69,141.98 144.9,141.76 144.9,141.6 144.74,141.44 144.58,141.44 144.36,141.65 144.2,141.65 139.9,137.35 139.6,137.35 137.64,135.39 137.64,133.52 137.01,132.9 135.69,131.57 135.03,130.91 134.22,130.1 134.22,129.35 131.49,126.62 130.73,126.62 129.06,124.94 129.06,124.4
  BOTTOM w0.076: UC1.AU27 v2(118.65,121.15)
  BOTTOM w0.114: v1(154.1,142.99) 154.62,142.47 154.62,141.73 154.3,141.41 151.73,141.41 151.67,141.35 JDIMM2.163
DDR_B_D49: length 56.9
  IN3 w0.076: v2(118,121.15) 118.11,121.15 118.5,120.75 120.12,120.75 121.21,121.85 121.67,121.85 123.75,123.93 128.96,123.93 129.37,124.34
  IN3 w0.114: 129.37,124.34 129.37,124.79 130.46,125.88 130.87,126.29 131.62,126.29 134.55,129.21 134.55,129.96 135.36,130.78 136.68,132.1 137.97,133.38 137.97,135.25 139.74,137.02 140.79,137.02 140.95,137.18 140.95,137.34 140.76,137.52 140.76,137.68 140.93,137.85 141.09,137.85 141.27,137.66 141.43,137.66 141.6,137.82 141.6,137.98 141.41,138.17 141.41,138.33 141.57,138.49 141.73,138.49 141.92,138.31 142.08,138.31 142.24,138.47 142.24,138.63 142.06,138.82 142.06,138.98 142.22,139.14 142.38,139.14 142.57,138.95 142.73,138.95 142.89,139.12 142.89,139.28 142.7,139.46 142.7,139.62 142.87,139.79 143.03,139.79 143.21,139.6 143.37,139.6 143.54,139.76 143.54,139.92 143.35,140.11 143.35,140.27 143.51,140.43 143.67,140.43 143.86,140.25 144.02,140.25 144.18,140.41 144.18,140.57 144,140.76 144,140.92 144.16,141.08 144.32,141.08 144.51,140.89 144.67,140.89 147.23,143.45 147.4,143.45 147.51,143.34 147.51,143 147.63,142.89 147.86,142.89 147.97,143 147.97,143.34 148.08,143.45 148.31,143.45 148.43,143.34 148.43,143 148.54,142.89 148.77,142.89 148.88,143 148.88,143.34 149,143.45 149.23,143.45 149.34,143.34 149.34,143 149.46,142.89 149.68,142.89 149.8,143 149.8,143.34 149.91,143.45 152.37,143.45 v1(152.83,142.99)
  BOTTOM w0.076: UC1.AT27 v2(118,121.15)
  BOTTOM w0.114: v1(152.83,142.99) 152.83,142.67 152.11,141.95 JDIMM2.165
DDR_B_D50: length 55.2
  IN3 w0.076: 125.57,126.18 124.35,126.18 122.85,124.67 122.85,124.4 122.46,124.02 121.6,124.02 120.02,122.44 118.47,122.44 118.09,122.06 v2(118,122.06)
  IN3 w0.114: v1(154.02,145.67) 153.53,146.16 146.21,146.16 144.42,144.37 144.25,144.37 144.14,144.49 143.98,144.49 143.81,144.33 143.81,144.17 143.93,144.05 143.93,143.89 143.77,143.73 143.61,143.73 143.49,143.84 143.33,143.84 143.17,143.68 143.17,143.52 143.28,143.4 143.28,143.24 143.12,143.08 142.96,143.08 142.84,143.2 142.68,143.2 142.52,143.04 142.52,142.87 142.64,142.76 142.64,142.6 142.48,142.43 142.31,142.43 142.2,142.55 142.04,142.55 141.87,142.39 141.87,142.23 141.99,142.11 141.99,141.95 141.83,141.79 141.67,141.79 141.55,141.9 141.39,141.9 141.23,141.74 141.23,141.58 141.34,141.46 141.34,141.3 141.13,141.08 140.54,141.08 135.18,135.72 135.18,135.24 134.53,134.59 134.53,132.98 131.33,129.78 131.33,129.04 130.73,128.44 129.98,128.44 127.72,126.18 125.57,126.18
  BOTTOM w0.076: UC1.AT25 v2(118,122.06)
  BOTTOM w0.114: JDIMM2.175 151.55,144.95 153.29,144.95 v1(154.02,145.67)
DDR_B_D51: length 54.7
  IN3 w0.076: v2(118.63,122.06) 119.27,122.06 119.43,122.22 120.05,122.22 121.66,123.84 122.51,123.84 123.07,124.4 123.07,124.66 124.31,125.91 125.96,125.91
  IN3 w0.114: v1(152.72,145.69) 152.58,145.69 152.16,145.28 151.37,145.28 151.25,145.39 151.25,145.66 151.14,145.77 150.91,145.77 150.8,145.66 150.8,145.39 150.68,145.28 150.45,145.28 150.34,145.39 150.34,145.66 150.22,145.77 150,145.77 149.88,145.66 149.88,145.39 149.77,145.28 149.54,145.28 149.42,145.39 149.42,145.66 149.31,145.77 149.08,145.77 148.97,145.66 148.97,145.39 148.85,145.28 148.62,145.28 148.51,145.39 148.51,145.66 148.4,145.77 148.17,145.77 148.05,145.66 148.05,145.39 147.94,145.28 147.71,145.28 147.6,145.39 147.6,145.66 147.48,145.77 147.25,145.77 147.14,145.66 147.14,145.39 147.02,145.28 145.79,145.28 141.26,140.75 140.73,140.75 136.19,136.21 136.19,134.49 135.9,134.19 135.74,134.19 135.29,134.65 135.12,134.65 134.96,134.48 134.96,134.32 135.41,133.87 135.41,133.71 134.86,133.15 134.86,132.84 132.56,130.54 132.56,130.38 132.74,130.2 132.74,130.04 132.58,129.87 132.42,129.87 132.23,130.06 132.07,130.06 131.66,129.65 131.66,128.9 130.87,128.11 130.12,128.11 127.92,125.91 125.96,125.91
  BOTTOM w0.076: UC1.AU25 v2(118.63,122.06)
  BOTTOM w0.114: v1(152.72,145.69) 152.31,145.28 151.68,145.28 151.41,145.55 JDIMM2.177
