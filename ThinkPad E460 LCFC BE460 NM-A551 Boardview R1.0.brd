# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3P4_RE_RXP_R: length 3.3
  TOP w0.114: U16.22 263.67,121.72 263.53,121.58 263.27,121.58 262.44,120.75 262.06,120.75 261.94,120.86 C187.2
USB3P4_RE_TXN: length 11.8
  TOP w0.114: v1(271.52,122.98) 271.09,122.55 R243.2 ; v1(271.61,114.46) 271.8,114.65 272,114.65 C85.1
  IN1 w0.14: v1(271.52,122.98) 271.38,122.84 271.38,118.55 272.79,117.14 272.79,115.11 272.33,114.65 271.8,114.65 v1(271.61,114.46)
USB3P4_RE_TXN_R: length 2.3
  TOP w0.114: U16.11 268.96,122.72 269.09,122.85 269.74,122.85 270.17,122.42 R243.1
USB3P4_RE_TXP: length 11.8
  TOP w0.114: v1(270.88,122.98) 271.07,123.17 R242.2 ; C86.1 272.01,114.91 271.72,114.91 271.61,115.02 v1(271.61,115.27)
  IN1 w0.14: v1(270.88,122.98) 271.12,122.74 271.12,118.44 272.53,117.03 272.53,115.21 272.23,114.91 271.75,114.91 271.61,115.04 v1(271.61,115.27)
USB3P4_RE_TXP_R: length 2.3
  TOP w0.114: U16.12 268.96,123.22 269.09,123.08 269.71,123.08 270.15,123.52 R242.1
USB3P4_RXN: length 9.3
  TOP w0.114: R241.1 271.09,120.02 271.2,120.14 272.64,120.14 272.85,119.93 272.85,119.17 v1(273.41,118.61) 275.75,116.26 277.51,116.26 L15.4
USB3P4_RXN_C: length 3.4
  TOP w0.114: U16.8 268.74,121.22 268.87,121.35 269.14,121.35 269.26,121.24 269.26,120.45 269.59,120.12 270.04,120.12 270.17,119.99 R241.2
USB3P4_RXN_R: length 16.3
  TOP w0.114: R258.2 271.98,119.11 v1(272.23,118.86) ; v1(259.45,119.9) 260.1,119.9 R260.1
  IN3 w0.114: v1(259.45,119.9) 259.45,120.42 259.57,120.53 264.11,120.53 264.91,119.73 272.32,119.73 272.43,119.62 272.43,119.06 v1(272.23,118.86)
USB3P4_RXP: length 9.3
  TOP w0.114: R240.1 271.09,120.48 271.2,120.37 272.74,120.37 273.08,120.02 273.08,119.26 275.85,116.49 v1(276.24,116.49) 277.6,116.49 L15.1
USB3P4_RXP_C: length 3.4
  TOP w0.114: U16.9 268.85,121.72 268.98,121.58 269.24,121.58 269.49,121.33 269.49,120.54 269.69,120.35 270,120.35 270.17,120.52 R240.2
USB3P4_RXP_R: length 16.3
  TOP w0.114: R259.1 260.1,121.37 v1(259.45,121.37) ; R257.2 272.01,120.99 v1(272.66,120.99)
  IN3 w0.114: v1(259.45,121.37) 259.45,120.85 259.57,120.73 264.19,120.73 264.99,119.93 272.18,119.93 272.66,120.42 v1(272.66,120.99)
USB3P4_TXN: length 297.9
  TOP w0.114: C186.1 261.03,122.69 260.91,122.8 258.55,122.8 254.42,126.93 254.42,129.36 251.53,132.25 229.04,132.25 211.65,114.86 211.65,106.35 211.36,106.07 211,106.07 210.81,105.88 v1(210.81,105.53)
  IN1 w0.14: v2(93.02,130.8) 93.32,130.8 93.46,130.95 93.46,131.16 93.27,131.35 92.18,131.35 91.75,130.91 87.43,130.91 87.14,130.63 87.14,130.55 85.59,129 85.59,127.84 83.75,126 83.19,126 80.4,123.21 80.4,114.43 81.3,113.52 81.3,110.98 83.21,109.08 83.21,96.52 84.87,94.86 84.87,86.59 95.62,75.84 100.77,75.84 105.15,71.46 107.02,71.46 111.45,67.02 117.22,67.02 119,65.24 170.99,65.24 194.8,89.05 194.8,95.09 199.06,99.35 208.13,99.35 212.29,103.5 212.29,105.3 211.52,106.07 211.03,106.07 210.81,105.84 v1(210.81,105.53)
  BOTTOM w0.076: UC1.C15 100.26,128.42 100.36,128.42 100.45,128.5 100.45,128.82 100.37,128.9 100.1,128.94 99.88,128.8 99.68,128.8 99.57,128.84 99.5,128.85 99.34,128.85 99.15,128.8 99.05,128.8 99.05,128.8 99.04,128.8 98.81,128.87 98.79,128.88 98.6,128.88 98.54,128.87 98.43,128.76 97.38,128.76 97.24,128.89 96.68,128.89 96.65,128.86 96.63,128.86
  BOTTOM w0.114: v2(93.02,130.8) 93.36,130.8 93.48,130.68 93.48,130.16 94.78,128.86 96.63,128.86
USB3P4_TXN_C: length 3
  TOP w0.114: C186.2 261.94,122.69 262.06,122.8 262.55,122.8 262.59,122.85 263.53,122.85 263.66,122.72 U16.20
USB3P4_TXN_R: length 16.5
  TOP w0.114: R256.1 271.98,122.55 272.25,122.83 272.41,122.83 v1(272.66,122.58) ; R254.2 260.1,122.18 v1(259.45,122.18)
  IN3 w0.114: v1(272.66,122.58) 272.3,122.94 272.19,122.94 271.46,123.67 264.79,123.67 263.94,122.82 259.57,122.82 259.45,122.7 v1(259.45,122.18)
USB3P4_TXP: length 298
  TOP w0.114: C185.1 261.03,123.36 260.7,123.03 258.64,123.03 254.65,127.02 254.65,129.45 251.62,132.48 228.94,132.48 211.42,114.95 211.42,106.44 211.27,106.29 211.02,106.29 v1(210.84,106.47)
  IN1 w0.14: v2(93.87,130.82) 93.72,130.98 93.72,131.26 93.37,131.6 92.08,131.6 91.64,131.17 87.32,131.17 86.89,130.73 86.89,130.66 85.33,129.1 85.33,127.94 83.65,126.26 83.08,126.26 80.14,123.32 80.14,114.32 81.05,113.41 81.05,110.88 82.96,108.97 82.96,96.41 84.61,94.76 84.61,86.49 95.51,75.59 100.66,75.59 105.05,71.2 106.91,71.2 111.34,66.77 117.12,66.77 118.9,64.99 171.09,64.99 195.05,88.95 195.05,94.98 199.16,99.09 208.24,99.09 212.54,103.39 212.54,105.41 211.63,106.32 210.99,106.32 v1(210.84,106.47)
  BOTTOM w0.076: UC1.D15 100.61,128.71 100.61,128.89 100.45,129.06 100.06,129.11 99.84,128.97 99.71,128.97 99.61,129.01 99.58,129.01 99.57,129.02 99.31,129.02 99.13,128.97 99.07,128.97 98.86,129.03 98.81,129.04 98.58,129.04 98.45,129.02 98.36,128.92 97.44,128.92 97.31,129.06 96.68,129.06 96.65,129.09 96.63,129.09
  BOTTOM w0.114: 96.63,129.09 94.87,129.09 93.7,130.25 93.7,130.66 v2(93.87,130.82)
USB3P4_TXP_C: length 3
  TOP w0.114: C185.2 261.94,123.16 262.07,123.03 262.45,123.03 262.5,123.08 v1(263.05,123.08) 263.05,123.08 263.53,123.08 263.67,123.22 U16.19
USB3P4_TXP_R: length 16.5
  TOP w0.114: R253.2 260.1,123.66 v1(259.45,123.66) ; R255.1 271.98,123.39 272.25,123.11 272.41,123.11 v1(272.66,123.36)
  IN3 w0.114: v1(272.66,123.36) 272.44,123.14 272.28,123.14 271.54,123.87 264.7,123.87 263.85,123.02 259.57,123.02 259.45,123.13 v1(259.45,123.66)
USB20_N0: length 321.5
  TOP w0.114: v1(282.58,43.23) 282.87,42.94 282.87,41.46 L11.4
  IN1 w0.076: 110.55,135.84 110.55,135.82 110.51,135.78 110.51,135.35 110.01,134.84 110.01,132.53 110.16,132.37 110.28,132.37 110.43,132.52 v2(110.43,132.69)
  IN1 w0.14: v1(237.02,141.42) 237.25,141.42 237.42,141.6 237.42,142.19 234.28,145.33 189.3,145.33 173.85,160.78 164.79,160.78 164.22,160.2 147.05,160.2 146.15,159.3 134.38,159.3 133.87,159.81 130.87,159.81 130.21,159.15 120.93,159.15 115.42,153.64 115.42,151.56 111.61,147.75 111.61,144.83 110.55,143.77 110.55,135.84
  IN3 w0.114: v1(282.58,43.23) 282.77,43.23 282.92,43.38 282.92,43.54 278.63,47.83 278.63,70.86 275.31,74.18 273.22,74.18 270.17,77.22 265.08,77.22 262.27,80.03 256.59,80.03 252.19,84.43 251.48,84.43 251.05,84.86 244.44,84.86 244.2,85.09 244.2,85.1 243.94,85.36 243.94,88.93 244.77,89.76 244.77,91.21 240.66,95.32 228.97,95.32 225.91,98.38 224.89,98.38 224.08,99.2 222.02,99.2 219.44,101.77 218.88,101.77 211.75,108.91 211.75,115.01 237.42,140.69 237.42,141.3 237.3,141.42 v1(237.02,141.42)
  BOTTOM w0.076: UC1.AB9 110.2,132.34 110.38,132.45 v2(110.43,132.69)
USB20_N0_CON: length 12.6
  TOP w0.114: L11.3 282.77,39.78 282.77,39.62 v1(282.2,39.05) 281.59,38.44 281.59,37.9 D8.6 281.59,37.45 281.59,37.12 280.91,36.43 280.91,34.45 282.44,32.92 285.35,32.92 285.39,32.87 285.59,32.68 JUSB1.2
USB20_N1: length 346.2
  TOP w0.114: v1(277.61,12.04) 277.61,12.19 277.73,12.3 278.48,12.3 L14.4
  IN1 w0.076: 111.18,134.97 111.18,134.95 111.13,134.91 111.13,134.48 111.32,134.29 111.53,134.29 111.63,134.4 v2(111.63,134.61)
  IN1 w0.14: v1(235.67,141.25) 235.91,141.49 235.91,141.98 233.33,144.56 188.94,144.56 174.11,159.39 174.11,159.43 173.6,159.94 165.09,159.94 164.58,159.43 147.68,159.43 146.71,158.45 130.82,158.45 130.14,157.77 127,157.77 126.39,158.38 121.25,158.38 116.31,153.44 116.31,151.36 113.3,148.35 113.3,144.22 111.36,142.28 111.36,136.18 111.18,135.99 111.18,134.97
  IN3 w0.114: v1(277.61,12.04) 277.61,12.14 277.38,12.38 277.19,12.38 276.95,12.61 276.95,15.93 278.3,17.28 278.3,19.69 280.41,21.8 280.41,26.04 278.07,28.38 278.07,38.98 279.23,40.14 279.23,43.75 277.93,45.04 277.93,70.57 275.02,73.48 272.93,73.48 269.88,76.52 264.79,76.52 261.98,79.33 256.3,79.33 251.9,83.73 251.19,83.73 250.8,84.12 244.15,84.12 243.24,85.03 243.24,88.49 241.9,89.83 241.9,91.27 240.57,92.6 230.6,92.6 226.81,96.39 225.6,96.39 224.3,97.68 221.88,97.68 211.04,108.52 211.04,115.3 235.88,140.14 235.88,141.03 v1(235.67,141.25)
  BOTTOM w0.076: UC1.AD6 111.4,134.24 111.56,134.34 v2(111.63,134.61)
USB20_N1_CON: length 9.1
  TOP w0.114: L14.3 280.24,12.26 280.78,12.26 281.12,11.91 281.12,11.36 281.54,10.94 283.56,10.94 283.75,10.75 D9.6 284.52,9.88 284.73,10.08 284.73,10.55 285.11,10.94 285.48,10.94 285.59,10.82 JUSB2.2
USB20_N2: length 130.9
  TOP w0.114: U14.2 137.21,69.88 137.07,70.03 137.07,73.04 139.13,75.11 139.13,76.45 v1(139.31,76.63)
  IN1 w0.14: v1(139.31,76.63) 139.13,76.45 139.13,75.99 138.75,75.61 137.66,75.61 136.11,77.16 113.52,77.16 107.24,83.44 106.54,83.44 104.26,85.72 104.26,88.27 98.92,93.62 95.46,93.62 94.41,94.67 94.41,96.4 95.31,97.3 95.31,102.31 91.52,106.1 91.52,113.53 92.49,114.49 92.49,117.18 96.63,121.32 96.63,121.68 98.05,123.1 100.43,123.1 100.82,123.48 102.05,123.48 102.56,123.98 105.15,123.98 105.59,123.54 107.91,123.54 108.73,124.36 108.73,124.52 109.6,125.39 110,125.39 110.6,125.99 110.6,128.76 111.02,129.18 111.02,129.64 110.79,129.87 110.79,130.43 111.75,131.39 112.51,131.39 114.32,133.2 114.32,133.89 114.92,134.49 114.92,136.22 114.32,136.82 114.32,138.54 114.61,138.83 114.9,138.83 v2(115.05,138.98)
  BOTTOM w0.076: v2(115.05,138.98) 114.89,138.82 114.53,138.82 114.25,138.54 114.25,137.72 113.82,137.28 113.82,135.98 113.7,135.57 UC1.AH3
USB20_N2_C: length 2.4
  TOP w0.114: L6.1 137.15,64.18 v1(137.15,65.27) 137.15,65.83 137.21,65.89 U14.11
USB20_N2_CONN: length 12.5
  TOP w0.114: v1(129.79,58.09) 129.51,57.81 129.51,57.22 129.66,57.07 JU3AC.3 ; v1(136.72,61.42) 136.52,61.61 136.52,61.77 137.1,62.35 137.1,62.63 L6.2
  IN3 w0.114: v1(129.79,58.09) 129.52,58.35 129.52,58.51 130.6,59.58 135.05,59.58 136.37,60.9 136.37,61.06 v1(136.72,61.42)
USB20_N3: length 213.4
  TOP w0.114: v1(193.74,146.21) 193.74,146.65 193.85,146.77 194.32,146.77 199.56,141.52 227.3,141.52 234.77,134.06 251.05,134.06 255.27,129.84 255.27,127.35 257.92,124.7 261.62,124.7 264.87,127.95 270.16,127.95 273.85,124.26 v1(273.85,123.69) 273.85,122.74 L20.4
  IN1 w0.14: v1(193.74,146.21) 193.84,146.31 193.84,146.58 193.66,146.76 188.96,146.76 174.17,161.56 164.3,161.56 163.72,160.98 135.13,160.98 134.94,160.8 130.75,160.8 129.88,159.93 120.61,159.93 110.73,150.04 110.73,147.23 109.07,145.57 109.07,143.44 109.08,143.43 109.08,142.87 109.07,142.86 109.07,136.3 109,136.23 109,134.3 109.39,133.9 109.39,131.97 109.91,131.45 110.41,131.45 110.85,131.9 110.85,132.14 111.16,132.45 111.51,132.45 111.64,132.59 v2(111.64,132.69)
  BOTTOM w0.114: v2(111.64,132.69) 111.64,132.55 111.48,132.39 UC1.AD9
USB20_N3_OD: length 14.8
  TOP w0.114: L20.3 273.71,121.1 273.71,119.66 274.41,118.96 275.01,118.96 275.72,118.24 D15.6 277.4,118.24 277.65,118.5 277.65,118.92 277.73,118.99 277.84,118.99 277.98,118.85 277.98,117.95 278.51,117.42 280,117.42 280.71,118.12 280.91,118.32 281.09,118.5 281.09,118.5 281.48,118.9 v1(282.05,118.9) 283.65,118.9 JLINK.10
USB20_N4_TPANEL: length 170.8
  TOP w0.114: v1(241.58,156.41) 241.75,156.41 241.86,156.3 241.86,154.19 241.58,153.91 L19.4
  IN1 w0.14: v1(241.58,156.41) 241.76,156.41 241.9,156.27 241.9,153.48 239.64,151.22 239.64,141.4 238.26,140.01 231.82,140.01 230.22,141.61 196.93,141.61 196.33,141 194.09,141 193.79,141.3 189.24,141.3 182.02,148.53 180.53,148.53 171.7,157.36 153.29,157.36 152.72,156.79 147.97,156.79 147.57,156.38 133.36,156.38 132.6,155.62 128.84,155.62 128.21,154.99 128.01,154.99 127.3,155.7 121.63,155.7 120.99,155.05 120.99,152.71 120.38,152.1 120.38,146.84 121.28,145.94 121.28,142.37 119.92,141.02 119.28,141.02 116.56,138.29 116.29,138.29 116.06,138.52 v2(116.06,138.55)
  BOTTOM w0.076: v2(116.06,138.55) 116.06,138.43 115.95,138.32 115.69,138.32 114.7,137.33 114.56,137.03 114.46,136.94 114.36,136.94 UC1.AJ1
USB20_N4_TPANEL_C: length 12.3
  TOP w0.114: JTOUCH1.4 250.3,154.85 250.22,154.77 250.22,154.26 v1(249.94,153.98) 249.67,153.72 247.64,153.72 244.98,151.05 242.11,151.05 241.7,151.46 241.7,151.88 241.58,152 L19.3
USB20_N5: length 203.9
  IN1 w0.076: v2(112.58,133.97) 112.58,133.8 112.73,133.65 112.86,133.65 113.01,133.81 113.01,134.89 112.97,134.93 112.97,134.95
  IN1 w0.14: v1(267.88,161.37) 268.11,161.14 268.11,160.72 266.55,159.16 257.82,159.16 257.17,159.81 243.5,159.81 238.75,155.06 238.75,141.6 237.94,140.79 232.14,140.79 230.55,142.38 197.99,142.38 196.96,143.42 189.35,143.42 173.85,158.91 147.9,158.91 146.92,157.93 131.04,157.93 130.35,157.25 126.79,157.25 126.18,157.86 121.47,157.86 117.08,153.46 117.08,151.38 113.84,148.14 113.84,143.97 111.88,142.01 111.88,138.96 112.97,137.87 112.97,134.95
  BOTTOM w0.076: UC1.AF6 112.27,134.05 v2(112.58,133.97)
  BOTTOM w0.114: v1(267.88,161.37) 268.08,161.58 268.08,161.83 267.95,161.96 JWLBT.5
USB20_N6: length 66.1
  IN3 w0.114: v2(113.8,137.82) 113.8,137.94 113.59,138.15 113.25,138.15 113.02,137.92 113.02,136.46 112.6,136.04 100.67,136.04 99.76,136.94 87.8,136.94 86.99,137.75 79.71,137.75 74.09,132.13 74.09,130.4 72.47,128.78 v1(72.47,128.43)
  BOTTOM w0.076: UC1.AH1 113.66,136.65 113.66,136.51 113.56,136.4 113.49,136.4 113.35,136.51 113.26,136.72 113.39,137.16 113.39,138 113.51,138.12 113.69,138.12 113.8,138.01 v2(113.8,137.82)
  BOTTOM w0.114: L5.4 59.85,125.31 60.68,126.14 69.86,126.14 72.14,128.43 v1(72.47,128.43)
USB20_N6_CMOS: length 11
  TOP w0.114: v1(58.43,120.27) 58.08,120.27 55.61,117.8 54.58,117.8 54.09,117.32 54.09,117.24 JLCD.17
  BOTTOM w0.114: v1(58.43,120.27) 58.43,120.62 59.28,121.47 v1(59.28,121.66) 59.28,122.09 59.26,122.1 59.26,122.34 58.41,123.19 58.41,123.87 58.76,124.21 L5.3
USB20_N8: length 196
  TOP w0.114: v1(195.43,142.53) 195.58,142.53 195.76,142.34 195.76,141.39 199.7,137.46 199.7,130.85 204.39,126.15 204.39,115.21 198.81,109.63 197.21,109.63 196.48,108.9 196.48,107.98 D4.3 196.32,107.12 196.48,106.97 196.48,106.55 191.9,101.98 191.9,90.55 179.34,77.99 179.34,77.57 178.96,77.19 JFPB.4
  IN1 w0.14: v2(113.52,139.73) 113.31,139.95 113.07,139.95 112.74,140.28 112.74,141.63 114.62,143.51 114.62,145.92 119.49,150.78 119.49,154.7 121.77,156.98 125.96,156.98 126.47,156.47 130.68,156.47 131.36,157.16 147.24,157.16 148.22,158.13 173.53,158.13 189.59,142.08 194.61,142.08 194.8,141.89 195.54,141.89 195.76,142.11 195.76,142.31 195.54,142.53 v1(195.43,142.53)
  IN3 w0.114: v2(113.52,139.73) 113.69,139.9 114.18,139.9 114.44,139.64 114.44,136.78 113.02,135.36 113.02,132.66 112.9,132.53 112.77,132.53 v2(112.57,132.74)
  BOTTOM w0.114: v2(112.57,132.74) 112.4,132.74 UC1.AF8
USB20_P0: length 321.6
  TOP w0.114: v1(283.33,43.23) 283.1,43 283.1,41.3 L11.1
  IN1 w0.076: 110.3,135.84 110.3,135.82 110.34,135.78 110.34,135.41 109.84,134.91 109.84,132.46 110.09,132.21 110.27,132.21 v2(110.43,132.05)
  IN1 w0.14: 110.3,135.84 110.3,143.88 111.36,144.94 111.36,147.86 115.17,151.67 115.17,153.75 120.83,159.4 130.1,159.4 130.76,160.07 133.98,160.07 134.49,159.56 146.04,159.56 146.94,160.46 164.11,160.46 164.69,161.04 173.96,161.04 189.41,145.59 234.39,145.59 237.68,142.3 237.68,141.59 v1(237.84,141.43)
  IN3 w0.114: v1(283.33,43.23) 283.12,43.43 283.12,43.62 278.83,47.91 278.83,70.94 275.4,74.38 273.3,74.38 270.26,77.42 265.16,77.42 262.35,80.23 256.67,80.23 252.28,84.63 251.56,84.63 251.13,85.06 244.53,85.06 244.33,85.26 244.33,85.27 244.15,85.45 244.15,88.84 244.98,89.67 244.98,91.29 240.74,95.52 229.06,95.52 226,98.59 224.98,98.59 224.16,99.4 222.1,99.4 219.52,101.98 218.97,101.98 211.95,108.99 211.95,114.93 237.62,140.6 237.62,141.21 v1(237.84,141.43)
  BOTTOM w0.076: UC1.AB10 v2(110.43,132.05)
USB20_P0_CON: length 12.6
  TOP w0.114: JUSB1.3 285.79,33.8 285.79,33.27 285.67,33.15 282.53,33.15 282.23,33.45 v1(282.23,33.46) 282.22,33.46 281.13,34.54 281.13,35.09 D8.1 281.13,35.56 281.13,36.34 281.82,37.02 281.82,38.34 283,39.52 283,39.74 L11.2
USB20_P1: length 346.3
  TOP w0.114: v1(277.61,12.75) 277.83,12.53 278.67,12.53 L14.1
  IN1 w0.076: v2(111.63,133.96) 111.46,134.13 111.25,134.13 110.97,134.41 110.97,134.91 110.92,134.95 110.92,134.97
  IN1 w0.14: v1(236.3,141.25) 236.16,141.39 236.16,142.08 233.43,144.81 189.05,144.81 174.36,159.5 174.36,159.54 173.7,160.19 164.99,160.19 164.48,159.68 147.58,159.68 146.6,158.71 130.72,158.71 130.03,158.02 127.11,158.02 126.5,158.63 121.15,158.63 116.06,153.54 116.06,151.46 113.05,148.45 113.05,144.32 111.11,142.38 111.11,136.28 110.92,136.1 110.92,134.97
  IN3 w0.114: v1(236.3,141.25) 236.09,141.03 236.09,140.06 211.24,115.21 211.24,108.61 221.96,97.89 224.38,97.89 225.68,96.59 226.9,96.59 230.68,92.81 240.66,92.81 242.11,91.36 242.11,89.91 243.45,88.57 243.45,85.12 244.24,84.32 250.88,84.32 251.27,83.93 251.99,83.93 256.38,79.54 262.06,79.54 264.87,76.72 269.97,76.72 273.01,73.68 275.11,73.68 278.14,70.65 278.14,45.13 279.43,43.83 279.43,40.06 278.28,38.9 278.28,28.47 280.62,26.13 280.62,21.72 278.5,19.6 278.5,17.19 277.16,15.85 277.16,12.69 277.27,12.58 277.45,12.58 v1(277.61,12.75)
  BOTTOM w0.076: UC1.AD7 111.13,133.66 v2(111.63,133.96)
USB20_P1_CON: length 9.1
  TOP w0.114: JUSB2.3 285.59,11.35 285.4,11.17 284.91,11.17 284.73,11.35 284.73,12.11 284.61,12.23 D9.1 283.75,11.39 283.53,11.17 281.63,11.17 281.35,11.45 281.35,12.01 280.87,12.48 280.14,12.48 L14.2
USB20_P2: length 130.8
  TOP w0.114: v1(138.55,76.63) 138.74,76.63 138.91,76.46 138.91,75.21 136.84,73.14 136.84,70.01 136.71,69.88 U14.3
  IN1 w0.14: v1(138.55,76.63) 138.74,76.63 138.88,76.49 138.88,76.1 138.65,75.87 137.76,75.87 136.21,77.42 113.62,77.42 107.34,83.69 106.65,83.69 104.52,85.82 104.52,88.38 99.02,93.87 95.57,93.87 94.67,94.77 94.67,96.3 95.57,97.2 95.57,102.42 91.78,106.21 91.78,113.42 92.74,114.39 92.74,117.07 96.88,121.21 96.88,121.57 98.15,122.84 100.54,122.84 100.92,123.22 102.15,123.22 102.66,123.73 105.05,123.73 105.49,123.29 108.02,123.29 108.98,124.25 108.98,124.41 109.71,125.14 110.1,125.14 110.85,125.89 110.85,128.66 111.27,129.07 111.27,129.74 111.04,129.97 111.04,130.32 111.85,131.14 112.62,131.14 114.57,133.09 114.57,133.79 115.17,134.39 115.17,136.33 114.57,136.93 114.57,138.44 114.71,138.58 114.91,138.58 115.05,138.44 v2(115.05,138.22)
  BOTTOM w0.076: v2(115.05,138.22) 115.05,138.53 114.93,138.65 114.6,138.65 114.42,138.48 114.42,137.65 113.98,137.21 113.98,135.96 113.88,135.6 113.91,135.45 113.99,135.39 114.13,135.4 114.31,135.58 114.31,135.69 UC1.AJ3
USB20_P2_C: length 2.5
  TOP w0.114: L6.4 136.92,64.3 136.92,65.68 136.71,65.89 U14.10
USB20_P2_CONN: length 12.4
  TOP w0.114: JU3AC.2 129.16,57.07 129.28,57.2 129.28,57.83 v1(129.02,58.09) ; v1(135.98,61.42) 136.3,61.73 136.3,61.87 136.87,62.45 136.87,62.61 L6.3
  IN3 w0.114: v1(135.98,61.42) 136.16,61.24 136.16,60.98 134.97,59.79 130.52,59.79 129.32,58.59 129.32,58.38 v1(129.02,58.09)
USB20_P3: length 213.5
  TOP w0.114: v1(193.71,147.24) 193.96,147 194.41,147 199.66,141.75 227.4,141.75 234.87,134.29 251.15,134.29 255.5,129.93 255.5,127.44 258.01,124.93 261.53,124.93 264.78,128.18 270.26,128.18 274.08,124.36 274.08,122.58 L20.1
  IN1 w0.14: v1(193.71,147.24) 193.5,147.02 189.07,147.02 174.28,161.81 164.19,161.81 163.61,161.23 135.02,161.23 134.84,161.05 130.65,161.05 129.78,160.18 120.5,160.18 110.47,150.15 110.47,147.33 108.82,145.68 108.82,143.33 108.83,143.33 108.83,142.97 108.82,142.97 108.82,136.41 108.74,136.33 108.74,134.19 109.14,133.8 109.14,131.86 109.8,131.2 110.51,131.2 111.11,131.79 111.11,132.03 111.27,132.19 111.5,132.19 v2(111.64,132.05)
  BOTTOM w0.114: v2(111.64,132.05) 111.33,131.74 UC1.AD10
USB20_P3_OD: length 14.9
  TOP w0.114: L20.2 273.94,120.98 273.94,119.75 274.5,119.18 274.96,119.18 275.92,120.14 D15.4 277.48,120.14 277.62,120 277.62,119.34 277.74,119.22 277.93,119.22 278.21,118.94 278.21,118.04 278.61,117.65 279.91,117.65 v1(280.54,118.28) 280.68,118.42 280.99,118.73 281.39,119.13 283.58,119.13 JLINK.8
USB20_P4_TPANEL: length 170.8
  TOP w0.114: v1(242.34,156.41) 242.09,156.16 v1(242.09,154.75) 242.09,154.11 242.18,154.02 L19.1
  IN1 w0.14: v1(242.34,156.41) 242.15,156.22 242.15,153.37 239.9,151.12 239.9,141.29 238.36,139.76 231.71,139.76 230.12,141.35 197.04,141.35 196.43,140.75 193.98,140.75 193.68,141.05 189.14,141.05 181.91,148.27 180.42,148.27 171.59,157.11 153.4,157.11 152.83,156.54 148.08,156.54 147.67,156.13 133.47,156.13 132.71,155.37 128.95,155.37 128.31,154.73 127.91,154.73 127.2,155.44 121.74,155.44 121.24,154.94 121.24,152.61 120.63,152 120.63,146.95 121.53,146.05 121.53,142.26 120.03,140.76 119.39,140.76 116.66,138.04 116.11,138.04 v2(116.06,137.99)
  BOTTOM w0.076: UC1.AJ2 114.23,136.47 114.69,136.94 114.83,137.24 115.76,138.16 115.89,138.16 v2(116.06,137.99)
USB20_P4_TPANEL_C: length 12.2
  TOP w0.114: L19.2 242.18,151.96 241.93,151.71 241.93,151.55 242.21,151.28 242.53,151.28 242.65,151.4 243,151.4 243.11,151.28 243.46,151.28 243.58,151.4 243.92,151.4 244.04,151.28 244.88,151.28 245.02,151.42 245.02,151.5 245.02,151.59 245.26,151.83 245.35,151.83 245.43,151.83 245.68,152.07 245.68,152.16 245.68,152.25 245.92,152.49 246.01,152.49 246.09,152.49 246.33,152.73 246.33,152.82 246.33,152.9 246.58,153.14 246.66,153.14 246.75,153.14 246.99,153.39 246.99,153.47 246.99,153.56 247.23,153.8 247.32,153.8 247.4,153.8 247.55,153.94 v1(248.14,153.94) 249.58,153.94 249.99,154.35 249.99,154.77 249.9,154.85 JTOUCH1.5
USB20_P5: length 204
  IN1 w0.076: v2(112.58,133.32) 112.76,133.49 112.93,133.49 113.18,133.74 113.18,134.89 113.22,134.93 113.22,134.95
  IN1 w0.14: 113.22,134.95 113.22,137.98 112.14,139.06 112.14,141.91 114.09,143.86 114.09,148.04 117.33,151.28 117.33,153.36 121.57,157.6 126.07,157.6 126.68,156.99 130.46,156.99 131.15,157.68 147.03,157.68 148.01,158.66 173.75,158.66 189.24,143.16 196.85,143.16 197.89,142.13 230.44,142.13 232.03,140.53 238.04,140.53 239.01,141.5 239.01,154.96 243.61,159.56 257.06,159.56 257.71,158.91 266.66,158.91 268.37,160.62 268.37,161.23 v1(268.51,161.37)
  BOTTOM w0.076: v2(112.58,133.32) 112.41,133.61 UC1.AF7
  BOTTOM w0.114: JWLBT.3 268.45,161.97 268.31,161.83 268.31,161.58 v1(268.51,161.37)
USB20_P6: length 66.1
  IN3 w0.114: v1(71.97,128.86) 72.26,128.86 73.88,130.48 73.88,132.21 79.63,137.95 87.07,137.95 87.88,137.15 99.85,137.15 100.75,136.24 112.51,136.24 112.82,136.55 112.82,138 113.17,138.35 113.7,138.35 v2(113.8,138.45)
  BOTTOM w0.076: UC1.AH2 113.57,136.16 113.49,136.24 113.44,136.24 113.21,136.4 113.09,136.72 113.23,137.18 113.23,138.07 113.44,138.28 113.63,138.28 v2(113.8,138.45)
  BOTTOM w0.114: v1(71.97,128.86) 71.97,128.57 69.76,126.37 v1(66.18,126.37) 60.59,126.37 59.74,125.52 L5.1
USB20_P6_CMOS: length 11
  TOP w0.114: v1(57.97,120.73) 57.97,120.48 55.51,118.03 54.48,118.03 54,117.55 53.83,117.55 JLCD.18
  BOTTOM w0.114: v1(57.97,120.73) 58.22,120.73 59.03,121.55 59.03,122.24 58.18,123.09 58.18,123.96 58.54,124.32 58.54,124.64
USB20_P8: length 195.9
  TOP w0.114: v1(196.19,142.53) 195.99,142.33 195.99,141.49 199.93,137.55 199.93,130.94 204.62,126.24 204.62,115.12 v1(203.57,114.06) 198.9,109.4 197.3,109.4 196.7,108.8 196.7,107.96 D4.2 196.86,107.12 196.7,106.97 196.7,106.46 192.13,101.89 192.13,90.46 179.57,77.9 179.57,77.57 179.96,77.19 JFPB.5
  IN1 w0.14: v2(113.52,140.33) 113.39,140.2 113.17,140.2 112.99,140.38 112.99,141.52 114.88,143.4 114.88,145.81 119.74,150.68 119.74,154.59 121.87,156.72 125.86,156.72 126.36,156.22 130.78,156.22 131.47,156.9 147.35,156.9 148.33,157.88 173.42,157.88 189.48,141.82 194.51,141.82 194.69,141.64 195.65,141.64 196.01,142 196.01,142.35 v1(196.19,142.53)
  IN3 w0.114: v2(112.57,132.15) 112.74,132.33 112.98,132.33 113.23,132.58 113.23,135.28 114.64,136.69 114.64,139.73 114.27,140.1 113.75,140.1 v2(113.52,140.33)
  BOTTOM w0.114: v2(112.57,132.15) 112.33,132.39 UC1.AF9
USB30_RX_N2_CON: length 8.9
  BOTTOM w0.114: L13.3 281.38,15.78 282.12,15.78 282.28,15.62 D10.5 D10.6 284.44,15.62 284.72,15.34 284.72,14.18 285.38,13.52 286.02,13.52 286.61,14.12 287.04,14.12 287.22,14.29 287.22,14.87 JUSB2.5
USB30_RX_P2_CON: length 8.8
  BOTTOM w0.114: L13.2 281.29,15.55 282.02,15.55 282.44,15.14 282.64,15.14 D10.4 D10.7 283.8,15.12 284.07,15.39 284.34,15.39 284.49,15.25 284.49,14.09 285.28,13.29 286.11,13.29 286.67,13.85 286.93,13.85 287.09,13.68 JUSB2.6
USB30_TX_N2_CON: length 11.5
  BOTTOM w0.114: JUSB2.8 287.09,8.33 286.95,8.18 286.64,8.18 285.67,9.15 285.25,9.15 284.59,9.81 284.59,13.49 284.01,14.07 283.8,14.07 283.75,14.12 D10.8 D10.2 282.32,14.12 282.18,13.98 282.02,13.98 281.83,14.17 281.34,14.17 L12.3
USB30_TX_P2_CON: length 11.5
  BOTTOM w0.114: JUSB2.9 287.09,7.79 286.93,7.95 286.55,7.95 285.58,8.92 285.15,8.92 284.36,9.72 284.36,13.4 284.14,13.62 D10.9 D10.1 282.45,13.62 282.32,13.75 281.92,13.75 281.74,13.94 281.33,13.94 L12.2
USB_OC0#: length 347.7
  IN1 w0.14: v1(184.65,94.92) 185.13,94.43 186.12,94.43 188.32,96.64 188.32,98.54 197.06,107.28 198.41,107.28 200.53,109.4 211.69,109.4 215.38,105.71 215.38,104.5 219.55,100.33 227.88,100.33 234.18,94.03 234.18,85.8 240.38,79.6 244.46,79.6 244.88,80.02 252.15,80.02 253.98,81.86 256.32,81.86 257.29,80.89 263.25,80.89 265.75,78.39 269.55,78.39 271.75,76.19 276.33,76.19 282.16,70.35 282.16,56.67 282.07,56.57 282.07,46.49 284.06,44.5 284.06,31.8 284.96,30.9 284.96,30 284.33,29.37 v1(284.33,25.94)
  BOTTOM w0.114: UC1.A9 98.33,132.87 95.61,132.87 95.28,133.2 92.72,133.2 92.07,132.56 91.65,132.56 90.3,131.21 RPC15.6 89.79,131.21 89.64,131.35 89.64,131.74 89.26,132.12 88.38,132.12 87.09,130.83 87.09,129.97 83.64,126.51 83.64,118.27 86.11,115.8 86.11,110.28 85.11,109.28 85.11,101.46 85.7,100.87 85.7,99.57 85.14,99.01 85.14,88.06 91.25,81.95 96.63,81.95 v4(97.27,82.6) 97.66,82.98 101.12,82.98 101.75,83.6 107.67,83.6 109.32,81.96 126.67,81.96 127.38,82.66 158.08,82.66 158.72,83.3 160.59,83.3 160.85,83.05 166.35,83.05 173.87,90.56 173.87,92.54 176.68,95.35 184.21,95.35 v1(184.65,94.92) ; U15.3 282.87,25.24 283.39,25.77 C120.1 v1(284.33,25.94)
USB_OC1#: length 132.2
  TOP w0.114: v1(142.16,66.53) 139.92,66.53 139.25,67.2 U14.13
  IN3 w0.114: v1(142.16,66.53) 141.19,67.49 141.19,68.47 141.45,68.73 141.45,69.61 140.84,70.22 119.41,70.22 118.71,70.91 107.04,70.91 101.42,76.53 98.09,76.53 96.3,78.32 96.3,81.42 v1(95.24,82.47)
  BOTTOM w0.076: 97.64,132.63 98.15,132.63 98.63,132.15 98.9,132.15 99.01,132.21 99.16,132.21 99.35,132.15 99.53,132.15 99.78,132.23 UC1.C9
  BOTTOM w0.114: 97.64,132.63 95.51,132.63 95.18,132.96 92.82,132.96 92.17,132.31 91.75,132.31 90.72,131.29 90.72,130.97 90.46,130.71 RPC15.7 89.89,130.71 89.64,130.46 89.64,129.02 89.16,128.54 88.74,128.54 83.88,123.68 83.88,118.37 86.35,115.9 86.35,110.18 85.36,109.18 85.36,101.58 85.94,100.99 85.94,99.46 85.38,98.9 85.38,88.16 91.35,82.19 92.55,82.19 v4(92.83,82.47) v1(95.24,82.47)
USB_OC2#: length 12.3
  BOTTOM w0.076: 97.42,132.39 98.16,132.39 98.56,131.98 98.92,131.98 99.02,132.02 99.21,132.02 99.3,131.98 99.55,131.98 100.03,132.12 100.15,132.12 100.41,132.2 UC1.D9
  BOTTOM w0.114: 97.42,132.39 95.41,132.39 95.22,132.57 v4(93.16,132.57) 92.77,132.57 92.27,132.07 91.85,132.07 90.96,131.19 90.96,130.56 90.61,130.21 RPC15.8
USB_OC3#: length 10.7
  BOTTOM w0.114: UC1.B9 98.74,133.11 96.28,133.11 v4(95.99,133.41) 95.63,133.77 92.95,133.77 91.97,132.8 91.43,132.8 90.34,131.71 RPC15.5
USB_ON#: length 226.6
  TOP w0.114: v4(177.04,112.97) 177.88,112.12 RE2.1 178.04,112.68 178.3,112.95 178.9,112.95 v1(179.78,113.84) 179.78,114.01 179.46,114.33 UE1.33
  IN1 w0.14: v1(179.78,113.84) 179.29,113.35 179.29,112.92 179.77,112.44 184.52,112.44 184.9,112.82 184.9,114.09 185.16,114.35 185.79,114.35 186.05,114.09 186.05,110.54 186.54,110.04 186.54,105.95 181.14,100.55 181.14,93.85 182.27,92.73 182.27,91.64 181.7,91.08 181.7,89.05 182.09,88.67 183.99,88.67 190.24,94.92 190.24,96.16 201.88,107.8 210.91,107.8 213.76,104.95 213.76,103.86 219.91,97.7 230.13,97.7 233.92,93.92 233.92,85.69 240.27,79.33 244.57,79.33 244.99,79.76 252.26,79.76 254.09,81.59 256.21,81.59 257.18,80.62 263.14,80.62 265.64,78.12 269.44,78.12 271.64,75.92 276.22,75.92 281.9,70.24 281.9,56.78 280.96,55.84 280.96,47.22 283.79,44.39 283.79,31.69 284.02,31.46 284.02,26.4 282.81,25.19 v1(282.81,23.53)
  BOTTOM w0.114: U15.4 282.87,22.19 283.25,22.57 283.25,23.09 v1(282.81,23.53)
USBCOMP: length 2.1
  TOP w0.254: v2(110.43,134.61) 110.26,134.61 109.7,135.17 109.31,135.17 RC359.1
  BOTTOM w0.254: UC1.AB6 v2(110.43,134.61)
VGA_AC_DC#: length 239.9
  TOP w0.114: UE1.126 180.26,129.76 180.19,129.7 v1(180.19,129.45)
  IN3 w0.114: v1(180.19,129.45) 179.43,129.45 178.26,128.27 178.26,110.88 177.23,109.85 177.23,95.32 179.46,93.08 183.07,93.08 v1(183.28,93.29)
  BOTTOM w0.114: DV2.1 75.83,159.13 76.38,158.58 78.57,158.58 81.15,156 81.15,155.42 82.36,154.2 82.36,151.25 76.52,145.41 76.52,131.67 77.58,130.6 77.58,123.61 v4(77.31,123.34) 77.1,123.13 77.1,120.93 78.01,120.02 78.01,119.41 81.25,116.18 81.25,114.85 82.68,113.42 82.68,88.74 90.69,80.74 100.88,80.74 102.54,82.4 106.58,82.4 108.65,80.32 126.45,80.32 127.83,81.7 160.29,81.7 160.66,82.07 166.78,82.07 174.92,90.21 174.92,92.19 176.94,94.2 181.83,94.2 182.74,93.29 v1(183.28,93.29)
VGA_LGATE1: length 16.9
  IN3 w1.016: 96.17,163.48 101.89,169.2 109.71,169.2 110.45,169.93
  vias: v1(93.35,163.66) v1(93.35,163.02) v1(99.75,164.45) v1(99.78,163.81) v1(112.48,170.19) v1(113.01,170.54)
VGA_LGATE2: length 17.8
  IN3 w1.016: 94.7,168.79 97.81,171.9 110.66,171.9 111.03,172.27
  vias: v1(91.83,168.99) v1(91.83,168.36) v1(98.38,168.97) v1(98.38,168.33) v1(112,172.27) v1(112.66,172.07)
VGA_ON: length 216
  TOP w0.114: DV6.1 54.92,174.46 RV152.1 RV153.1 55.91,174.19 58.78,171.32 60.11,171.32 60.39,171.04 60.39,170.73 59.61,169.95 59.61,165.4 v1(59.28,165.07) ; RV49.2 85.18,138.81 85.62,138.81 85.67,138.86 86.83,138.86 87.11,138.58 v1(87.81,138.58) ; v1(106.6,154.53) v4(100.81,154.53) 100.7,154.63 98.93,154.63 v1(98.85,154.71)
  IN1 w0.14: v1(106.6,154.53) 107.58,155.51 112.67,155.51 120.64,163.48 123.25,163.48 v1(126.04,166.27) ; v1(59.28,165.07) 60.09,165.07 61.05,164.11 65.22,164.11 72.5,156.83 72.5,152.28 v1(74.94,149.84)
  IN3 w0.114: v1(91.55,142.53) 91.43,142.64 91.43,145.7 98.79,153.06 98.79,154.64 v1(98.85,154.71) 98.85,155.29 98.52,155.62 89.53,155.62 87.61,153.7 79.63,153.7 75.77,149.84 v1(74.94,149.84) 74.44,149.34 74.44,143.96 73.69,143.21 70.51,143.21 67.81,140.51 55.75,140.51 55.22,139.99 55.22,132.89 53.56,131.22 51.69,131.22 49.64,129.17 v1(49.64,128.91)
  BOTTOM w0.076: 107.42,137.69 107.42,137.45 107.3,137.32 107.3,136.25 107.47,136.07 107.73,136.07 107.85,135.96 107.88,135.87 107.88,135.69 107.83,135.54 107.83,135.27 107.95,135.06 107.95,135.05 108.4,134.6 108.4,133.55 107.89,133.04 UC1.U8
  BOTTOM w0.114: 107.42,137.69 107.42,137.8 106.8,138.43 106.8,139.39 106.22,139.97 105.25,139.97 103.94,141.28 99.15,141.28 98.49,140.62 98.49,140.2 97.87,139.58 96.81,139.58 96.55,139.83 94.38,139.83 91.69,142.53 v1(91.55,142.53) 91.24,142.84 90.36,142.84 87.81,140.28 87.81,138.86 v1(87.81,138.58) 87.95,138.44 87.95,136.18 88.75,135.38 89.14,135.38 89.99,134.53 RPC26.1 ; RV136.1 76.99,151.21 76.54,150.76 76.54,150.22 75.78,149.46 75.32,149.46 v1(74.94,149.84) ; v1(49.64,128.91) 49.18,129.37 48.83,129.37 48.5,129.7 48.5,129.9 48.3,130.1 47.82,130.1 47.43,130.49 47.43,132.06 46.77,132.72 46.18,132.72 45.65,133.25 QV10.2
  BOTTOM w0.203: PR603.1 124.26,170.52
  BOTTOM w0.254: 124.26,170.52 124.85,170.52 126.74,168.63 126.74,166.97 v1(126.04,166.27)
VGA_PHASE1: length 61.9
  TOP w0.254: v1(123.55,163.07) 123.5,163.02 PR608.2 122.74,162.11 122.08,161.45 114.94,161.45 114.38,160.89 114.38,158.17 112.55,156.34 107.54,156.34 107,156.88 106.18,156.88 105.57,156.26 90.01,156.26 88.55,157.72 88.55,160.76 v1(88.4,160.92)
  IN3 w0.762: 110.83,168.41 107.68,165.26 102.39,165.26 99.6,162.47
  BOTTOM w0.254: v1(123.55,163.07) 123.55,163.38 123.83,163.66 PR616.2 ; v1(88.4,160.92) 88.96,161.47 PL603.1
  vias: v1(90.33,159.17) v1(90.28,157.87) v1(90.35,158.51) v1(90.96,159.16) v1(90.99,158.5) v1(90.96,157.87) v1(91.62,159.17) v1(91.65,158.51) v1(91.62,157.87) v1(92.26,159.16) v1(92.29,158.5) v1(92.31,157.87) v1(92.89,160.26) v1(92.9,159.62) v1(92.89,158.99) v1(92.9,158.33) v1(93.34,157.86) v1(93.58,160.26) v1(93.59,159.6) v1(93.58,158.96) v1(99.68,162.21) v1(99.67,161.58) v1(99.68,160.92) v1(99.67,160.28) v1(99.68,159.62) v1(99.67,158.99) v1(100.24,161.88) v1(100.24,161.23) v1(100.24,160.59) v1(100.24,159.94) v1(100.24,159.29) v1(100.24,158.64) v1(100.79,162.21) v1(100.84,160.99) v1(100.87,159.82) v1(100.9,158.58) v1(111.13,168.82) v1(111.84,168.89) v4(100.98,157.58)
VGA_PHASE2: length 82.8
  TOP w0.254: PR631.2 123.5,163.94 124.19,163.25 124.19,163.1 v1(124.31,162.97) 124.45,162.97 124.7,163.23 124.7,164.69 125.48,165.46 126.45,165.46 127.01,166.02 127.01,174.28 125.42,175.86 89.86,175.86 86.44,172.44 v1(86.44,169.76)
  IN3 w0.762: 111.44,173.79 92.51,173.79
  BOTTOM w0.254: v1(124.31,162.97) 124.31,163.1 124.72,163.51 PR632.2 ; PL604.1 86.45,169.75 v1(86.44,169.76)
  vias: v1(87.5,171.88) v1(88.16,172.54) v1(88.16,171.9) v1(88.81,172.55) v1(88.8,171.9) v1(89.49,173.21) v1(89.5,172.56) v1(89.49,171.91) v1(90.13,173.88) v1(90.13,173.23) v1(90.13,172.59) v1(90.13,171.94) v1(90.78,173.89) v1(90.78,173.26) v1(90.79,172.57) v1(90.79,171.94) v1(90.78,171.29) v1(90.79,170.64) v1(90.78,170) v1(91.35,174.23) v1(91.35,173.6) v1(91.35,170.99) v1(91.35,169.69) v1(91.36,172.91) v1(91.36,172.28) v1(91.35,171.64) v1(91.35,170.34) v1(91.9,173.26) v1(91.92,172.61) v1(91.92,171.94) v1(91.91,171.3) v1(91.92,170.65) v1(91.91,170.01) v1(111.92,173.31) v1(112.58,173.18) v4(91.01,175.3)
VGA_UGATE1: length 11.6
  IN3 w0.762: 103.03,163.68 107.88,163.68 112.66,168.46
  vias: v1(101.94,163.66) v1(102.57,163.66) v1(112.66,168.82) v1(113.32,168.92)
VGA_UGATE2: length 13.2
  IN3 w0.762: 99.78,174.76 99.97,174.95 111.93,174.95 112.61,174.28
  vias: v1(98.48,174.73) v1(99.14,174.73) v1(112.61,174.15) v1(113.24,174.15)
VGATE: length 186
  TOP w0.203: UE1.78 194.67,121.97 v1(194.8,121.84)
  TOP w0.254: v1(195.18,111.28) 194.83,111.28 193.38,109.83 191.01,109.83 184.46,103.28 178.26,103.28 175.17,100.19 175.17,99.66 171.05,95.54 171.05,90.61 170.42,89.97 166.88,89.97 165.97,89.06 165.97,88.21 163.13,85.38 160,85.38 157.46,82.84 148.44,82.84 146.54,80.93 124.09,80.93 v4(122.56,79.41) 122.56,79.11 108.51,65.06 101.86,65.06 v1(101.34,65.58)
  IN3 w0.254: v1(195.18,111.28) 194.8,111.67 v1(194.8,121.84) ; v1(61.32,61.88) 62.97,61.88 67.43,66.34 77.82,66.34 82.42,70.94 82.42,71.97 83.47,73.02 99.36,73.02 101.21,71.17 101.21,65.71 v1(101.34,65.58)
  BOTTOM w0.203: PU401.38 62.66,61.46 61.07,63.05 PR406.1
  BOTTOM w0.254: v1(61.32,61.88) 60.94,61.88 60.28,62.54 PR406.1
VMB:
  vias: v4(264.13,112.57)
VMB2:
  vias: v1(246.36,119.51) v1(246.69,118.96) v1(247.05,119.51) v1(247.07,118.4) v1(247.38,118.96) v1(247.73,119.51) v1(247.76,118.4) v1(248.06,118.96) v1(248.44,118.4) v1(257,114.03) v1(257.31,114.59) v1(257.39,113.47) v1(257.69,114.03) v1(257.99,114.59) v1(258.07,113.47) v1(258.38,114.03) v1(258.68,114.59) v1(258.76,113.47) v4(243.68,116.63) v4(243.99,118.38) v4(245.61,119.17)
VR_HOT#: length 257
  TOP w0.254: QE1.1 CE17.1 199.55,122.39 v1(199.13,121.97) ; v1(83.8,77.06) 86.98,80.24 v4(86.98,88.21) 88.46,89.69 88.46,95.27 89.1,95.91 89.1,98.12 88.94,98.27 RC294.2 90.19,98.8 RC5.1
  IN1 w0.254: v1(212.97,111.27) 211.2,113.04 201.09,113.04 v1(200.3,113.84)
  IN3 w0.254: v1(54.46,57.94) 54.46,57.91 56.16,56.22 58.96,56.22 60.31,57.56 60.31,59.09 61.32,60.1 61.32,60.87 60.62,61.57 60.62,62.77 62.15,64.29 64.37,64.29 67.05,66.98 77.54,66.98 81.78,71.22 81.78,72.23 83.05,73.5 83.05,76.75 83.36,77.06 v1(83.8,77.06) ; v1(199.13,121.97) 199.34,121.75 199.34,119.72 200.23,118.83 200.23,117.89 199.56,117.22 199.56,114.55 200.27,113.84 v1(200.3,113.84)
  BOTTOM w0.254: PR126.1 213.12,111.17 213.02,111.27 v1(212.97,111.27) 212.46,111.27 211.69,112.05 207.99,112.05 191.71,95.76 191.71,89.68 181.53,79.5 174.73,79.5 168.15,72.93 164.83,72.93 164.57,73.18 144,73.18 143.44,72.63 143.44,72.25 142.35,71.15 134.64,71.15 128.69,65.2 105.63,65.2 102.53,68.29 102.53,71.7 100.9,73.34 95.32,73.34 94,74.66 87.59,74.66 85.18,77.06 v1(83.8,77.06) ; PR409.2 54.64,57.77 v1(54.46,57.94)
VR_HOT#_R: length 10.2
  TOP w0.114: RC5.2 91.82,98.52 92.28,98.06 93.54,98.06 v1(94.09,98.62)
  BOTTOM w0.076: 97.49,99.72 97.9,100.13 98.44,100.13 98.63,99.93 98.9,99.93 99.01,99.99 99.16,99.99 99.35,99.93 99.53,99.93 99.78,100.02 UC1.C65
  BOTTOM w0.114: 97.49,99.72 97.49,99.27 96.96,98.74 94.21,98.74 v1(94.09,98.62)
VR_ON: length 241.4
  TOP w0.114: v1(179.82,139.31) 180.05,139.09 181.02,139.09 181.17,139.24 D59.2 182.2,140.42 RE47.1 ; v1(176.19,116.45) 176.19,116.38 175.84,116.02 D60.2
  TOP w0.254: v1(100.58,65.58) 101.48,64.68 108.72,64.68 124.16,80.12 v4(124.16,80.17) 124.55,80.55 146.7,80.55 148.6,82.46 157.62,82.46 160.16,85 163.29,85 165.71,87.42 168.4,87.42 171.43,90.45 171.43,95.16 v1(174.48,98.2) ; v1(82.99,71.31) 82.95,71.34 82.95,77.87 85.46,80.39 85.46,98.34 85.68,98.56 QC3.2
  IN3 w0.254: v1(54.6,54.69) 57.18,54.69 58.07,55.58 59.22,55.58 60.94,57.3 60.94,58.71 62.21,59.98 62.21,60.48 67.56,65.83 77.85,65.83 82.99,70.97 v1(82.99,71.31) 82.96,71.34 82.96,71.97 83.6,72.61 99.23,72.61 100.83,71.01 100.83,65.83 v1(100.58,65.58) ; v1(174.48,98.2) 174.48,101.25 175,101.77 175,109.51 174.48,110.03 174.48,113.77 175.94,115.23 175.94,116.2 v1(176.19,116.45) 176.19,117.01 177.19,118 177.19,129.49 179.27,131.57 179.27,138.2 179.82,138.76 v1(179.82,139.31)
  BOTTOM w0.254: PR407.1 55.92,62.81 53.58,60.46 53.58,55.71 v1(54.6,54.69)
VR_ON_EC: length 4.2
  TOP w0.114: D60.1 174.76,116.49 175.56,116.49 176.65,117.57 UE1.30
VR_SVID_ALRT#: length 66.2
  IN3 w0.203: v1(87.33,98.08) 87.18,98.08 86.24,99.02 83.8,99.02 77.7,92.92 67.37,92.92 66.2,91.75 66.2,90.54 59.97,84.31 59.59,83.48 59.59,81.65 58.93,80.01 58.93,71.72 59.4,71.25 59.4,67.3 57.68,65.58 57.68,62.52 57.77,62.43 57.77,59.75 57.56,59.54 v1(56.93,59.54)
  BOTTOM w0.114: RC19.2 v3(89.27,98.97) 88.37,98.97 88.04,98.64 RC20.2 v1(87.33,98.08)
  BOTTOM w0.254: PR408.1 57.84,59.6 56.98,59.6 v1(56.93,59.54)
VR_SVID_ALRT#_R: length 9.1
  BOTTOM w0.076: UC1.B63 99.11,101 97.52,101 97.3,100.79 96.98,100.79
  BOTTOM w0.114: RC19.1 91.42,98.97 91.89,99.43 91.89,99.61 93.07,100.79 v4(94.98,100.79) 96.98,100.79
VR_SVID_CLK: length 76
  IN3 w0.203: v1(57.21,60.36) 57.02,60.55 57.02,65.75 58.82,67.56 58.82,71.01 58.35,71.48 58.35,80.12 59,81.75 59,83.6 59.57,84.83 65.54,90.79 65.54,91.95 67.14,93.56 77.51,93.56 83.56,99.6 86.57,99.6 v1(87.27,98.9)
  BOTTOM w0.076: 97.27,101.28 97.38,101.17 98.65,101.17 UC1.A63
  BOTTOM w0.114: v1(87.27,98.9) 87.57,98.9 88.52,99.85 88.62,99.85 89.32,100.55 91.11,100.55 91.37,100.29 RC356.2 91.43,99.85 92.86,101.28 97.27,101.28
  BOTTOM w0.254: PR410.1 57.72,60.36 v1(57.21,60.36) 56.83,60.36 56.39,59.93 PR404.2
VR_SVID_DAT: length 77.8
  IN3 w0.203: v1(87.33,97.38) 86.91,97.38 85.86,98.43 84.04,98.43 77.87,92.26 67.55,92.26 66.78,91.5 66.78,90.28 60.45,83.95 60.17,83.35 60.17,81.54 59.52,79.9 59.52,71.96 59.99,71.5 59.99,67.02 58.26,65.3 58.26,63.29 58.35,63.2 58.35,59.42 57.82,58.88 v1(57.26,58.88)
  BOTTOM w0.076: 97.04,100.29 97.59,100.84 99.42,100.84 99.64,101.06 99.88,101.06 100.18,100.76 UC1.D64
  BOTTOM w0.114: v1(87.33,97.38) 90.6,97.38 91.29,98.08 RC355.2 91.55,98.08 92.38,98.91 92.38,99.4 93.27,100.29 97.04,100.29
  BOTTOM w0.254: PR411.1 v1(57.26,58.88) 56.42,58.88 PR403.2
VRALERT#: length 1.2
  TOP w0.114: v2(115.46,130.29) 115.46,130.3 T49.1
  BOTTOM w0.076: v2(115.46,130.29) 115.05,130.7 UC1.AM11
VSUM+: length 13
  TOP w0.508: v1(121.11,163.02) PR608.1 PR631.1 121.83,164.77 v4(122.59,165.54)
  BOTTOM w0.203: PR634.1 120.61,164.62 120.61,165.34 PC633.1 120.05,166.25 119.08,167.22 118.6,167.22 117.49,168.33 PU601.14
  BOTTOM w0.254: v1(121.11,163.02) 121.11,162.62 PR633.1 120.47,162.71 120.47,163.16 PC634.1 120.07,163.56 PR634.1
VSUM-: length 44.7
  TOP w0.254: v1(118.88,163) 119.11,163.23 PR639.2 120.17,163.23 v1(120.94,163.99)
  BOTTOM w0.203: PC633.2 119.18,164.98 PR635.2
  BOTTOM w0.254: PR635.2 PR634.2 119.51,163.74 PC634.2 119.31,163 v1(118.88,163) 118.93,162.95 118.93,162.47 PC637.2 119.08,162.03 112.86,155.81 104.27,155.81 v4(103.95,156.12) 103.25,156.83 93.48,156.83 92.97,157.33 PRT601.1
  BOTTOM w0.508: v1(120.94,163.99) 121.14,164.19 121.14,164.73 PC608.1 121.34,164.88 PC628.1 122.74,164.85 PR618.1 122.74,163.1 PR636.1
VSYSTEM: length 122
  TOP w0.508: PR5.1 273.97,107.53 274.69,108.25 v1(274.69,108.38)
  IN1 w0.508: v1(224.03,104.06) 228.02,104.06 231.97,100.11 248.44,100.11 249.47,101.14 250.44,101.14 251.33,102.03 254.25,102.03 254.75,101.52 257.93,101.52 258.44,101.01 273.68,101.01 v1(275.96,103.3)
  IN3 w0.508: v1(230.37,129.47) 230.38,129.48 249.93,129.48 257.78,121.64 257.78,119.22 262.93,114.07 268.39,114.07 274.08,108.38 v1(274.69,108.38)
  BOTTOM w0.508: PR113.1 216.97,104.63 218.62,102.98 222.95,102.98 v1(224.03,104.06) 224.13,104.06 224.14,104.05 PD102.2 ; PD1.2 v1(230.37,129.47)
VTTREF_0.675V: length 2.6
  TOP w0.229: 180.96,168.17 PU301.4
  TOP w0.254: PC315.1 181.04,166.62 v4(181.04,167.69) 180.96,167.77 180.96,168.17
WLAN_PWRON: length 113.7
  TOP w0.114: v1(271.15,129.04) 272.88,129.04 273.55,129.71 v4(273.55,132.38) 273.55,134.82 272.69,135.68 270.76,135.68 270.54,135.47 R9449.1 ; v1(181.73,134.29) 181.73,134.67 181.22,135.17 180.08,135.17 179.69,134.78 179.69,133.51 181.46,131.74 UE1.123
  IN1 w0.14: v1(271.15,129.04) 269.64,130.55 265.09,130.55 263.14,132.51 249.04,132.51 248.83,132.72 215.56,132.72 212.05,136.22 202.9,136.22 199.79,133.11 188.41,133.11 188.01,132.71 183.59,132.71 182.02,134.29 v1(181.73,134.29)
WLAN_PWRON#: length 4.1
  TOP w0.114: v4(271,128.33) 270.06,129.27 R9451.1 R9450.2 271,129.9 Q26.1
WLAN_PWRON_R: length 4
  TOP w0.114: Q26.2 271.65,133.82 R69.1 R9449.2 272.71,135.03 v4(273,134.74)
WRST#: length 7.3
  TOP w0.114: IT8.1 172.96,123.22 174.99,123.22 175.19,123.43 RE4.2 CE11.1 175.78,124.62 176.43,123.97 UE1.14
XDP_BPM#0: length 10.1
  BOTTOM w0.076: 96.84,105.33 96.86,105.35 97.57,105.35 97.85,105.63 99.67,105.63 UC1.C55
  BOTTOM w0.114: T15.1 91.44,108.71 93.86,106.29 95.27,106.29 96.23,105.33 96.84,105.33
XDP_BPM#1: length 17.4
  TOP w0.114: v2(96.4,105.75) 95.65,105 87.09,105 T16.1
  BOTTOM w0.076: UC1.D55 100.18,105.72 99.88,106.01 99.64,106.01 99.42,105.79 97.77,105.79 97.48,105.51 96.92,105.51 96.68,105.75
  BOTTOM w0.114: 96.68,105.75 v2(96.4,105.75)
XDP_BPM#2: length 11.2
  BOTTOM w0.076: 95.74,106.17 96.65,106.17 96.81,106.01 96.81,105.96 97.1,105.67 97.42,105.67 97.7,105.95 99.12,105.95 99.44,106.27 UC1.B54
  BOTTOM w0.114: 95.74,106.17 95.35,106.55 93.95,106.55 90.42,110.09 T19.1
XDP_BPM#3: length 10.3
  BOTTOM w0.076: UC1.C56 99.69,104.76 99,104.76 98.93,104.73 98.56,104.73 98.41,104.88 98,104.88 97.8,104.68 97.16,104.68 96.85,104.37
  BOTTOM w0.114: 96.85,104.37 94.76,104.37 92.29,106.84 92.11,106.84 T20.1
XDP_PRDY_N: length 17.1
  TOP w0.114: v2(95.17,105.75) 94.75,105.33 86.84,105.33 85.59,104.08 TP115.1
  BOTTOM w0.076: UC1.D56 100.45,105.44 97.89,105.44 97.6,105.16 96.88,105.16 96.81,105.09
  BOTTOM w0.114: v2(95.17,105.75) 95.82,105.09 96.81,105.09
XDP_PREQ_N: length 9.3
  BOTTOM w0.076: 96.97,103 97.02,103.04 99.55,103.04 99.64,102.95 99.88,102.95 99.9,102.97 100.27,102.97 100.29,102.95 100.47,102.95 UC1.D61
  BOTTOM w0.114: 96.97,103 96.46,103 96.29,103.16 93.93,103.16 93.56,103.54 91.88,103.54 TP116.1
XDP_TCLK: length 10.8
  BOTTOM w0.076: UC1.B61 99.23,102.47 99.01,102.47 98.93,102.43 98.64,102.43 98.35,102.72 97.23,102.72 97.03,102.51
  BOTTOM w0.114: 97.03,102.51 96.26,102.51 96.09,102.68 92.92,102.68 92.7,102.46 91.1,102.46 T5.1 90.28,102.52 89.98,102.52 89.92,102.46 RC4.1
XDP_TDI: length 12.2
  BOTTOM w0.076: 96.69,103.48 97.25,103.48 97.37,103.36 99.47,103.36 99.64,103.53 99.88,103.53 100.18,103.24 UC1.D60
  BOTTOM w0.114: RC31.1 89.92,105.96 90.18,105.7 T4.1 92.41,105.7 94.46,103.65 96.52,103.65 96.69,103.48
XDP_TDO: length 11.8
  BOTTOM w0.076: UC1.A61 98.58,102.88 97.14,102.88 97.01,102.75
  BOTTOM w0.114: RC3.1 89.47,104.18 89.47,103.33 RC404.1 89.94,103.32 90.29,103.68 90.29,103.93 T6.1 90.98,103.72 90.98,103.29 91.53,102.74 92.55,102.74 92.73,102.92 96.19,102.92 96.36,102.75 97.01,102.75
XDP_TMS: length 11.1
  BOTTOM w0.076: 97.15,103.24 97.18,103.2 99.72,103.2 UC1.C60
  BOTTOM w0.114: RC34.1 91.53,105.08 T3.1 92.95,104.81 94.36,103.4 96.41,103.4 96.57,103.24 97.15,103.24
XDP_TRST#: length 11.5
  BOTTOM w0.076: 96.63,103.89 96.84,103.68 97.28,103.68 97.44,103.52 99.15,103.52 UC1.B59
  BOTTOM w0.114: 96.63,103.89 94.56,103.89 92.37,106.08 T14.1 90.2,106.08 RC6.1
XTALIN: length 8.4
  BOTTOM w0.114: YV1.3 71.43,143.4 CV144.1 RV68.2 69.94,143.89 v3(68.65,143.89) 67.51,143.89 65.74,142.12 UV3.AM28
XTALOUT: length 11.7
  BOTTOM w0.114: YV1.1 72.38,144.85 70.88,144.85 70.45,145.28 CV143.1 RV68.1 69.08,144.85 v3(67.76,144.85) 67.61,144.7 67.61,144.37 66.22,142.98 65.11,142.98 64.94,142.82 UV3.AK28
YELLOW_LED: length 3.1
  TOP w0.114: v4(285.3,87.11) RL15.2 287.23,86.01 JRJ451.11
N09817: length 9.8
  TOP w0.254: PR625.2 115.92,162.56 v1(116.45,163.09) 116.72,163.35 PR626.1
  BOTTOM w0.203: PC621.2 117.38,165.91 116.3,166.99 116.3,167.87 116.29,167.89 PU601.17
  BOTTOM w0.254: v4(116.89,162.13) 116.45,162.57 v1(116.45,163.09) 116.45,163.44 117.28,164.27 PC622.1 117.51,164.45 117.51,165.72 PC621.2
N09897: length 11
  TOP w0.254: PR621.1 115.53,163.53 PR622.2 116.16,164.32 v1(117,165.16) 117.51,165.16 117.58,165.08 v1(118.09,165.08)
  BOTTOM w0.203: PC617.1 116.92,165.08 v1(117,165.16) ; PC621.1 118.29,165.87 117.53,166.64 v4(117.53,167.03) 116.69,167.87 PU601.16
  BOTTOM w0.254: PC619.2 118.09,164.4 v1(118.09,165.08) 118.29,165.28 PC621.1 ; PC617.1 116.24,165.92 PR623.1
N10003: length 2.3
  BOTTOM w0.254: PC610.1 PR613.2 113.54,164.01 113.15,163.62 v4(113.15,162.88)
N10023: length 7
  TOP w0.254: PR619.2 113.54,165.95 113.54,166.3 v1(113.9,166.66) 114.39,167.15 v4(114.72,167.15)
  BOTTOM w0.203: PU601.19 115.49,168.38 114.43,167.33 PC609.2 PC610.2 113.54,166.3 v1(113.9,166.66)
N10051: length 7
  TOP w0.254: PR624.1 v1(115.3,166.61)
  BOTTOM w0.203: PU601.18 115.89,167.64 v4(115.87,167.62) 115.87,167.18 v1(115.3,166.61)
  BOTTOM w0.254: v1(115.3,166.61) PR623.2 115.32,165.92 PR617.2 PC609.1 114.46,165.03 PR613.1
N10079: length 2.1
  BOTTOM w0.254: v4(115.32,162.93) PR617.1 116.21,164.14 PC617.2
N10153: length 2.6
  TOP w0.254: PR624.2 113.95,165.44 PC620.1 113.57,164.11 v4(113.07,163.61)
N13273: length 6.5
  TOP w0.254: v4(117.6,166.08) 117.82,165.87 PC635.1 119.16,166.15 v1(118.7,166.61)
  BOTTOM w0.203: PU601.15 117.09,168.22 v1(118.7,166.61)
  BOTTOM w0.254: PC635.1 119.16,166.15 v1(118.7,166.61)
N13333: length 3.1
  TOP w0.254: PC635.2 119.16,164.85 119.87,164.14 PR639.1 120.69,164.79 v4(120.69,165.66)
N13487: length 35.7
  BOTTOM w0.254: PR633.2 119.92,162.24 112.99,155.3 103.05,155.3 v4(102.13,156.23) 101.91,156.45 93.32,156.45 92.97,156.8 88.6,156.8 PRT601.2
N18669:
  vias: v4(108.7,167.2)
N22144:
  vias: v4(109.21,175.36)
N22186:
  vias: v4(114.52,175.18)
N32858: length 6.9
  BOTTOM w0.203: PR642.1 123.7,168.64 123.17,169.17 120.09,169.17 119.75,169.51 PU601.10
  BOTTOM w0.254: PR642.1 PC636.2 125.41,168.64 v4(125.72,168.32)
N34928: length 6.2
  TOP w0.254: v4(110.92,173.76) 110.92,173.23 111.3,172.86 PR602.1
  TOP w0.508: v1(111.94,171.38) 111.82,171.38 111.3,171.9 PR602.1
  BOTTOM w0.203: v1(111.94,171.38) 112.07,171.51 PU601.26
  BOTTOM w0.254: PC605.1 111.34,171.38 v1(111.94,171.38)
N41772: length 6.2
  BOTTOM w0.203: PU601.8 120.18,170.31 120.48,170.01 121.72,170.01 PC601.1 123.32,170.52 PR603.2 123.34,170.73 123.72,171.12 124.07,171.12 v4(124.55,171.6)
N193745: length 36.7
  TOP w0.254: v1(125.61,171.46) 124.66,170.51 v4(122.8,170.51) 120.78,168.5 v1(120.78,167.93)
  BOTTOM w0.203: PU601.11 118.98,168.61 PR641.1
  BOTTOM w0.254: v1(125.61,171.46) 125.71,171.56 125.71,175.57 125.13,176.16 108.8,176.16 108.04,175.39 103.72,175.39 PRT602.1 ; v1(120.78,167.93) 120.99,168.13 PR641.1
N13690206: length 4.7
  TOP w0.114: QV7.2 84.19,139.34 RV50.2 84.26,138.8 RV49.1 ; RV49.1 83.3,138.7 v4(83.3,139.24) ; RV49.1 83.74,137.41 CV140.1
N13748098: length 2.8
  TOP w0.114: v4(21.32,128.68) 21.13,128.87 CV104.1
  TOP w0.305: RV26.2 RV27.1 CV104.1
N13748269: length 3.6
  BOTTOM w0.114: v3(19.03,166.76) 19.19,166.92 19.61,166.92 20.04,166.48 CV131.1
  BOTTOM w0.254: CV131.1 20.04,165.15 RV39.1 RV38.2
N13756593: length 1.9
  TOP w0.114: v3(50.3,174.07) 50.3,173.36 RV12.1 50.04,173.26 49.28,173.26 CV76.2
N13756597: length 3.1
  TOP w0.114: CV77.2 RV13.1 41.65,173.83 v3(41.6,173.83)
N13756601: length 18.8
  TOP w0.114: CV76.1 49.26,172.26 48.91,171.91 48.91,170.24 48.75,170.09 TPV15.1 48.88,169.58 v1(49.66,169.58)
  IN3 w0.114: v2(50.21,157.28) 50.21,157.35 50.73,157.87 50.73,159.16 50.91,159.34 50.91,161.75 51.52,162.36 51.52,163.63 49.33,165.82 49.33,167.6 49.98,168.24 49.98,169.24 49.66,169.55 v1(49.66,169.58)
  BOTTOM w0.114: v2(50.21,157.28) 50.21,157.51 49.92,157.8 UV3.K8
N13756610: length 19.9
  TOP w0.114: TPV16.1 CV77.1 44.56,173.26 44.81,173.01 44.81,172.73 46.57,170.97 46.57,167.33 48.77,165.12 48.77,161.93 51.31,159.39 v2(51.31,158.86)
  BOTTOM w0.114: UV3.L7 50.9,158.6 51.16,158.86 v2(51.31,158.86)
N13756920: length 3.1
  TOP w0.114: RV10.1 CV74.1 65.14,169.01 64.95,169.2 RV9.2 63.94,169.2 v3(63.74,169.4)
N13756934: length 21.6
  TOP w0.114: v1(57.69,161.96) 58.45,161.96 62.35,165.86 v3(62.35,166.28) 62.48,166.4 CV75.1 RV11.1 RV10.2
  IN1 w0.14: v1(57.69,161.96) 56.33,160.6 54.07,160.6 53.08,159.6 53.08,156.05 52.64,155.61 51.82,155.61 51.32,156.11 v2(51.31,156.11)
  BOTTOM w0.114: v2(51.31,156.11) 51.22,156.2 UV3.L10
N13757067: length 12.8
  TOP w0.381: v1(48.67,135.42) 48.14,135.96 48.14,137.3 48.32,137.48 48.32,137.52 48.34,137.55 48.34,141.05 49.26,141.97 49.26,142.91 v2(49.35,143)
  BOTTOM w0.381: v1(48.67,135.42) 48.48,135.62 v4(47.97,135.62) 47.97,135.07 48.11,134.93 CV73.1 RV8.1 RV7.2 ; UV3.J26 48.96,143.4 v2(49.35,143)
N13757116: length 12.6
  TOP w0.381: v1(48.77,136.51) 49,136.51 49.52,137.03 49.52,140.97 49.79,141.24 49.79,142.66 v2(50.14,143)
  BOTTOM w0.381: v1(48.77,136.51) 48.98,136.51 49.85,135.63 v4(49.85,135.62) 49.85,135.4 49.13,134.68 RV6.1 CV72.1 RV5.2 ; UV3.K26 49.74,143.4 v2(50.14,143)
N13769821: length 4.8
  BOTTOM w0.114: v4(57.73,126.69) 58.53,127.49 RV87.1 RV88.1 RV86.2 60.48,128.1 60.94,128.56 DV1.2
N13769835: length 4.1
  BOTTOM w0.114: v4(57.64,130.13) 58.53,129.24 RV87.2 CV148.1 56.83,129.01 56.51,128.7 QV3.2
