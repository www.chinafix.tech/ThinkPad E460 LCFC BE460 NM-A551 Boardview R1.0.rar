# Allegro board ThinkPad E460 LCFC BE460 NM-A551 Boardview R1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CRX_C_GTX_P1: length 8.6
  BOTTOM w0.084: UV3.AG29 63.16,141.58 63.04,141.58 62.95,141.49 62.95,141.39 63.02,141.21 arc(63.05,141.14) 63.06,141.07 63.06,140.89 62.98,140.7 62.98,140.58 arc(63,140.48) 63.06,140.39 arc(63.06,140.38) 63.07,140.38 arc(63.07,140.37) 63.08,140.37 63.08,140.37 63.14,140.21 63.15,140.15 63.15,139.94 63.18,139.91 63.18,139.9
  BOTTOM w0.114: 63.18,139.9 63.18,139.18 63.12,139.12 63.12,136.65 62.01,135.55 61.33,135.55 61.17,135.38 61.17,135.14 CV134.2
PCIE_CRX_C_GTX_P2: length 14
  TOP w0.114: CV136.2 68.91,132.73 68.92,132.73 68.92,133.92 68.07,134.76 68.07,136.96 62.71,142.33 62.71,142.8 v5(62.91,143)
  BOTTOM w0.114: v5(62.91,143) 62.66,143 62.54,142.88 UV3.AF27
PCIE_CRX_C_GTX_P3: length 14.5
  TOP w0.114: CV138.2 66.84,132.76 66.84,135.63 63.49,138.98 62.32,138.98 61.58,139.73 61.58,140.17 61,140.75 61,142.66 v5(61.32,142.98)
  BOTTOM w0.114: v5(61.32,142.98) 61.28,142.98 60.94,142.64 UV3.AD27
PCIE_CRX_GTX_N0: length 48.1
  IN3 w0.114: v1(62.63,132.62) 62.93,132.92 62.93,133.25 63.4,133.71 64.42,133.71 65.56,132.57 69.48,132.57 71.29,130.76 71.29,128.65 73.08,126.86 80.56,126.86 81.65,125.78 85.78,125.78 86.17,126.17 88.66,126.17 91.78,123.05 99.5,123.05 99.89,123.44 101.18,123.44 101.38,123.63 101.38,123.8 v2(101.29,123.89)
  BOTTOM w0.076: v2(101.29,123.89) 101.51,124.11 UC1.E22
  BOTTOM w0.114: CV133.1 62.88,133.52 62.88,132.87 v1(62.63,132.62)
PCIE_CRX_GTX_N1: length 50.9
  IN3 w0.114: v2(101.89,122.08) 101.72,122.25 101.72,122.53 101.4,122.85 100.41,122.85 99.91,122.35 91.43,122.35 88.3,125.47 86.46,125.47 86.06,125.07 81.32,125.07 80.22,126.16 72.7,126.16 70.59,128.27 70.59,130.47 69.33,131.73 63.24,131.73 62.98,131.99 62.12,131.99 61.82,131.68 61.82,131.43 v1(61.64,131.25)
  BOTTOM w0.076: v2(101.89,122.08) 101.89,122.24 UC1.F25
  BOTTOM w0.114: CV135.1 60.81,133.69 60.81,133.31 61.86,132.27 61.86,131.47 v1(61.64,131.25)
PCIE_CRX_GTX_N2: length 39.5
  TOP w0.114: CV137.1 68.62,131.21 68.62,129.92 v1(68.47,129.77)
  IN3 w0.114: v5(100.93,120.65) 100.93,120.85 100.71,121.07 99.09,121.07 98.81,120.8 89.17,120.8 85.8,124.17 78.71,124.17 77.61,125.26 72.33,125.26 68.67,128.92 68.67,129.57 v1(68.47,129.77)
  BOTTOM w0.114: v5(100.93,120.65) 100.96,120.69 UC1.E28
PCIE_CRX_GTX_N3: length 42
  TOP w0.114: CV139.1 66.61,131.2 66.61,131.12 66.55,131.07 v1(66.37,130.89)
  IN3 w0.114: v1(66.37,130.89) 66.67,130.6 66.67,129.94 72.04,124.56 77.32,124.56 78.43,123.45 84.78,123.45 85.2,123.03 85.82,123.03 88.76,120.1 99.87,120.1 100.15,119.82 101.39,119.82 101.51,119.7 101.51,119.56 v2(101.28,119.34)
  BOTTOM w0.076: UC1.E30 101.28,119.54 v2(101.28,119.34)
PCIE_CRX_GTX_P0: length 48.1
  IN3 w0.114: v2(101.92,123.89) 101.27,123.24 99.97,123.24 99.58,122.84 91.7,122.84 88.58,125.96 86.25,125.96 85.86,125.57 81.56,125.57 80.48,126.66 73,126.66 71.09,128.57 71.09,130.67 69.39,132.37 65.48,132.37 64.34,133.51 63.48,133.51 63.14,133.16 63.14,132.77 v1(63.29,132.62)
  BOTTOM w0.076: v2(101.92,123.89) 101.51,123.48 UC1.E23
  BOTTOM w0.114: CV132.1 63.11,133.7 63.11,132.79 63.29,132.62 v1(63.29,132.62)
PCIE_CRX_GTX_P1: length 50.8
  IN3 w0.114: v1(62.35,131.25) 62.23,131.25 62.02,131.47 62.02,131.59 62.21,131.78 62.9,131.78 63.15,131.53 69.24,131.53 70.39,130.38 70.39,128.19 72.62,125.96 80.14,125.96 81.23,124.87 86.14,124.87 86.54,125.27 88.22,125.27 91.34,122.14 99.99,122.14 100.49,122.64 101.31,122.64 101.52,122.44 101.52,122.19 101.4,122.08 v2(101.25,122.08)
  BOTTOM w0.076: UC1.E25 101.51,122.16 101.43,122.08 v2(101.25,122.08)
  BOTTOM w0.114: v1(62.35,131.25) 62.34,131.25 62.08,131.51 62.08,132.37 61.04,133.41 61.04,133.84 61.14,133.94 CV134.1
PCIE_CRX_GTX_P2: length 39.5
  TOP w0.114: v1(69.15,129.77) 69.07,129.77 68.85,129.99 68.85,131.18 CV136.1
  IN3 w0.114: v2(101.29,121.15) 101.19,121.05 101.02,121.05 100.79,121.28 99,121.28 98.72,121 89.26,121 85.89,124.37 78.79,124.37 77.7,125.47 72.41,125.47 68.88,129 68.88,129.6 69.05,129.77 v1(69.15,129.77)
  BOTTOM w0.114: v2(101.29,121.15) 101.51,121.37 UC1.E27
PCIE_CRX_GTX_P3: length 42
  TOP w0.114: v1(67.05,130.89) 66.83,131.11 66.83,131.2 CV138.1
  IN3 w0.114: v2(101.89,119.31) 101.72,119.48 101.71,119.49 101.71,119.79 101.48,120.02 100.24,120.02 99.96,120.3 88.84,120.3 85.91,123.24 85.28,123.24 84.86,123.66 78.52,123.66 77.41,124.77 72.13,124.77 66.87,130.02 66.87,130.71 v1(67.05,130.89)
  BOTTOM w0.076: v2(101.89,119.31) 101.89,119.5 UC1.F30
PCIE_CTX_C_GRX_N0: length 46.6
  IN3 w0.114: v1(58.85,132.7) 59.2,132.35 59.2,131.56 67.65,123.11 73.96,123.11 74.52,122.55 77.16,122.55 77.7,122.02 83.12,122.02 84.3,120.83 85.08,120.83 85.79,121.53 85.87,121.53 v1(86.09,121.32)
  BOTTOM w0.114: CC86.1 88.77,121.56 86.33,121.56 v1(86.09,121.32) ; UV3.AE31 61.92,140.41 61.92,138.83 62.17,138.59 62.17,137.09 61.58,136.51 60.19,136.51 59.1,135.42 59.1,132.95 v1(58.85,132.7)
PCIE_CTX_C_GRX_N1: length 47.4
  IN3 w0.114: v1(84.51,122.08) 84.71,122.28 84.71,122.51 84.47,122.75 78.03,122.75 76.94,123.85 67.93,123.85 60.48,131.29 60.48,132.19 60.92,132.62 60.92,136.83 v1(60.64,137.11)
  BOTTOM w0.084: UV3.AD28 61.18,141.8 61.22,141.76 61.22,141.27 61.28,141.13 61.28,141.12 arc(61.28,141.12) 61.28,141.12 arc(61.29,141.09) 61.29,141.06 61.29,140.92 61.22,140.73 61.22,140.58 arc(61.24,140.42) 61.33,140.28 61.38,140.16 61.38,140.14 61.38,139.94 61.35,139.91 61.35,139.9
  BOTTOM w0.114: 61.35,139.9 61.35,138.47 60.9,138.02 60.9,137.35 60.66,137.11 v1(60.64,137.11) ; CC88.1 90.89,123.2 90.41,123.2 90.22,123.01 86.37,123.01 86.2,123.19 85.24,123.19 84.72,122.67 84.72,122.29 v1(84.51,122.08)
PCIE_CTX_C_GRX_N2: length 50.2
  IN3 w0.114: v1(84.87,119.41) 85.18,119.72 85.18,119.88 84.93,120.13 84.01,120.13 83.52,120.63 78.04,120.63 76.81,121.85 74.23,121.85 73.67,122.42 66.81,122.42 57.93,131.3 57.93,131.63 v1(57.64,131.92)
  BOTTOM w0.114: CC90.1 90.84,120.48 85.61,120.48 85.18,120.05 85.18,119.73 v1(84.87,119.41) ; UV3.AC31 60.31,140.43 60.31,138.58 58.49,136.76 58.49,136.75 57.88,136.15 57.88,132.16 v1(57.64,131.92)
PCIE_CTX_C_GRX_N3: length 53.8
  IN3 w0.114: v1(85.58,117.51) 85.77,117.7 85.77,117.92 85.53,118.16 84.99,118.16 83.23,119.93 77.75,119.93 77.25,120.43 74.63,120.43 74.06,121 64.91,121 58.02,127.89 58.02,128.58 56.66,129.94 56.66,135.84 57.73,136.91 57.73,137.08 v1(57.45,137.36)
  BOTTOM w0.084: UV3.AB28 59.58,141.56 59.58,141.36 59.67,141.14 59.67,141.14 arc(59.69,141.1) 59.69,141.06 59.69,140.92 59.61,140.73 59.61,140.58 arc(59.64,140.42) 59.73,140.28 59.78,140.16 59.78,140.14 59.78,139.93 59.75,139.9
  BOTTOM w0.114: CC24.1 88.81,119.08 86.45,119.08 85.72,118.35 85.72,117.65 v1(85.58,117.51) ; v1(57.45,137.36) 57.47,137.36 57.69,137.57 57.69,138.07 58.6,138.98 59.46,138.98 59.75,139.27 59.75,139.9
PCIE_CTX_C_GRX_P0: length 46.6
  IN3 w0.114: v1(59.56,132.7) 59.4,132.54 59.4,131.64 67.73,123.32 74.04,123.32 74.61,122.75 77.25,122.75 77.78,122.22 83.2,122.22 84.39,121.03 85,121.03 85.71,121.74 85.87,121.74 v1(86.09,121.95)
  BOTTOM w0.114: v1(59.56,132.7) 59.33,132.93 59.33,135.33 60.28,136.28 61.68,136.28 62.39,137 62.39,138.68 62.15,138.93 62.15,140.35 62.54,140.73 UV3.AF30 ; CC87.1 88.84,121.79 86.25,121.79 v1(86.09,121.95)
PCIE_CTX_C_GRX_P1: length 47.4
  IN3 w0.114: v1(61.4,137.11) 61.12,136.83 61.12,132.54 60.69,132.1 60.69,131.38 68.01,124.05 77.03,124.05 78.12,122.96 84.55,122.96 84.91,122.6 84.91,122.28 85.11,122.08 v1(85.25,122.08)
  BOTTOM w0.084: 61.58,139.9 61.55,139.93 61.55,140.15 61.54,140.21 61.48,140.37 61.48,140.37 arc(61.47,140.37) 61.47,140.38 arc(61.46,140.38) 61.46,140.39 arc(61.4,140.48) 61.38,140.58 61.38,140.7 61.46,140.89 61.46,141.07 arc(61.45,141.12) 61.44,141.17 arc(61.43,141.19) 61.43,141.2 61.43,141.21 61.39,141.3 61.39,141.57 61.46,141.65 61.6,141.65 61.74,141.5 UV3.AE29
  BOTTOM w0.114: v1(85.25,122.08) 85.11,122.08 84.95,122.24 84.95,122.57 85.33,122.96 86.1,122.96 86.28,122.79 90.31,122.79 90.5,122.97 90.78,122.97 CC89.1 ; v1(61.4,137.11) 61.37,137.11 61.13,137.35 61.13,137.92 61.58,138.37 61.58,139.9
PCIE_CTX_C_GRX_P2: length 50.2
  IN3 w0.114: v1(85.61,119.41) 85.38,119.64 85.38,119.97 85.01,120.33 84.1,120.33 83.6,120.83 78.13,120.83 76.9,122.06 74.32,122.06 73.75,122.62 66.9,122.62 58.13,131.38 58.13,131.71 v1(58.35,131.92)
  BOTTOM w0.114: UV3.AD30 60.94,140.75 60.54,140.34 60.54,138.48 58.72,136.67 58.72,136.66 58.11,136.05 58.11,132.16 v1(58.35,131.92) ; v1(85.61,119.41) 85.41,119.61 85.41,119.96 85.71,120.25 90.84,120.25 CC23.1
PCIE_CTX_C_GRX_P3: length 53.8
  IN3 w0.114: v1(86.32,117.51) 86.19,117.51 85.97,117.72 85.97,118 85.61,118.36 85.08,118.36 83.31,120.13 77.84,120.13 77.33,120.63 74.71,120.63 74.14,121.2 64.99,121.2 58.22,127.97 58.22,128.67 56.87,130.02 56.87,135.76 57.93,136.82 57.93,137.08 v1(58.21,137.36)
  BOTTOM w0.084: 59.98,139.9 59.98,139.92 59.95,139.95 59.95,140.15 59.94,140.21 59.88,140.37 59.88,140.37 arc(59.87,140.37) 59.87,140.38 arc(59.86,140.38) 59.86,140.39 arc(59.8,140.48) 59.78,140.58 59.78,140.7 59.86,140.89 59.86,141.07 arc(59.85,141.14) 59.82,141.21 59.75,141.39 59.75,141.48 59.8,141.54 60,141.54 UV3.AC29
  BOTTOM w0.114: 59.98,139.9 59.98,139.18 59.55,138.75 58.7,138.75 57.92,137.97 57.92,137.6 58.16,137.36 v1(58.21,137.36) ; CC91.1 88.81,118.85 86.54,118.85 85.95,118.26 85.95,117.75 86.19,117.51 v1(86.32,117.51)
PCIE_RCOMP: length 1.5
  TOP w0.254: RC360.2 102.55,134.57 v2(101.92,133.95)
  BOTTOM w0.254: UC1.F5 v2(101.92,133.95)
PCIE_WAKE#: length 31.5
  TOP w0.114: v4(133.72,150.8) 133.85,150.8 134.79,149.86 RPC6.1 134.21,149.63 133.85,149.27 v1(133.85,148.36)
  BOTTOM w0.076: UC1.BB15 121.44,128.5 122.3,128.5 122.64,128.84 122.82,128.84
  BOTTOM w0.114: 122.82,128.84 123.18,128.84 124.97,130.63 126.72,130.63 130.87,134.78 130.87,137.96 131.62,138.72 131.62,147.66 131.83,147.87 133.14,147.87 133.6,148.33 133.83,148.33 v1(133.85,148.36)
PECI: length 3.9
  TOP w0.114: UE1.117 183.86,132 183.5,132.36 v4(183.5,132.46) CE1.1 RE1.2
PG_VDD: length 4.4
  BOTTOM w0.203: PR604.1 112.99,166.88 113.29,166.88 v4(114.14,167.73) 115.09,168.68 PU601.20
  BOTTOM w0.254: PR605.2 112.66,165.67 PR604.1
PLANARID0: length 9.5
  TOP w0.114: v1(109.72,140.56) 109.87,140.56 110.41,141.09 110.41,142.23 110.46,142.28 RC74.1 110.48,142.72 110.94,143.18 110.94,144.37 110.32,144.99 RC70.2
  BOTTOM w0.076: UC1.AB1 110.25,137.15 110.29,137.18 110.29,138.77 110.13,138.92 110.13,139.54 109.97,139.7 109.97,140.31 v1(109.72,140.56)
PLANARID1: length 18.9
  TOP w0.114: RC410.1 101.9,146.35 v1(102.05,146.2) 102.56,146.71 RC409.2
  IN1 w0.14: v1(102.05,146.2) 103.32,144.93 103.32,141.75 104.03,141.04 v1(104.03,140.2)
  BOTTOM w0.114: v1(104.03,140.2) 104.62,140.2 105.1,139.72 105.81,139.72 106.16,139.37 106.16,138.04 106.57,137.64 106.57,134.95 106.83,134.69 107.97,134.69 108.2,134.46 108.2,134.01 107.88,133.69 UC1.U7
PLT_RST_VGA#: length 101.2
  TOP w0.114: v1(66.48,141.87) 66.34,142.01 66.34,148.37 68.12,150.15 69.51,150.15 71.1,151.73 72.21,151.73 72.33,151.85 78.77,151.85 v1(79.27,151.35)
  IN1 w0.14: v1(79.27,151.35) 80.02,152.11 82.29,152.11 82.98,151.42 83.43,151.42 84.31,150.54 85.21,150.54 85.71,151.04 85.71,155.1 86.99,156.38 99.94,156.38 100.07,156.26 104.77,156.26 106.09,157.58 108,157.58 110.99,160.57 110.99,162.48 113.14,164.63 123.68,164.63 v1(125.98,166.92)
  BOTTOM w0.114: DV1.1 63.54,130.9 RV44.1 64.63,131.99 UV4.4 65.74,132.35 67.03,133.64 RV43.2 66.53,134.51 v4(66.53,136.57) 66.53,139.96 67.01,140.44 67.01,141.33 v1(66.48,141.87) 66.05,141.43 65.51,141.43 65.34,141.61 UV3.AL27
  BOTTOM w0.203: PR606.1 124.9,169.53
  BOTTOM w0.254: 124.9,169.53 125.28,169.53 126.36,168.45 126.36,167.31 v1(125.98,166.92)
PLTRST#: length 84.1
  TOP w0.114: UC3.2 74.14,121.28 74.59,121.74 74.93,121.74 75.5,122.31 RC26.1 75.58,122.25 v1(75.58,121.15)
  IN3 w0.076: v2(116.02,131.2) 115.64,131.58 115.2,131.58 114.79,131.99 114.79,132.62 115.04,132.87 115.04,133.13
  IN3 w0.114: v1(73.39,130.84) 73.39,132.42 80.09,139.12 86.64,139.12 87.84,137.93 89.61,137.93 90.35,138.66 100.14,138.66 101.74,137.07 110.1,137.07 110.94,137.9 110.94,140.13 111.93,141.12 114.11,141.12 115.59,139.64 115.59,135.48 115.04,134.93 115.04,133.13
  BOTTOM w0.076: v2(116.02,131.2) 115.7,131.52 UC1.AN10
  BOTTOM w0.114: UV4.1 67.04,129.47 67.3,129.21 69.21,129.21 71,131 73.23,131 v1(73.39,130.84) 73.68,130.84 v4(74.93,129.59) 76.25,128.27 76.25,121.82 v1(75.58,121.15)
PLTRST_FAR#: length 506.8
  TOP w0.114: v1(251.23,96.57) 251.92,96.57 252.04,96.46 UL1.36 ; JCR.10 168.95,55.56 168.53,55.97 168.53,75.84 176.16,83.47 176.44,83.47 177.11,84.15 v1(177.16,84.15) 177.16,84.47 179.82,87.14 179.82,91.65 183.09,94.92 v1(184.01,94.92) ; RC48.2 CC9.1 73.55,116.95 72.56,115.96 72.56,113.32 74.82,111.06 79.74,111.06 81.15,109.65 81.15,103.42 80.03,102.31 80.03,95.78 81.15,94.66 81.15,83.86 v1(79.99,82.71) ; v1(189.35,120.17) 188.51,119.33 180.99,119.33 v1(179.82,120.5) 179.39,120.94 179.01,120.94 178.84,120.77 UE1.22 176.98,120.77 176.64,120.43 176.64,119.54 176.45,119.35 175.78,119.35 CE13.2 ; UTPM1.17 131.32,158.04 132.07,157.29 v1(132.07,156.09)
  IN1 w0.14: v1(227.32,99.61) 227.32,99.62 226.87,100.07 225.34,100.07 225.04,99.77 219.73,99.77 215.12,104.38 215.12,105.59 211.58,109.13 200.64,109.13 198.52,107.01 197.17,107.01 188.59,98.43 188.59,96.53 186.23,94.17 184.76,94.17 v1(184.01,94.92)
  IN3 w0.114: v1(184.01,94.92) 179.57,94.92 177.71,96.77 177.71,109.65 178.75,110.69 178.75,119.79 179.02,120.06 179.39,120.06 v1(179.82,120.5) ; v1(189.35,120.17) 189.35,121.75 194.02,126.42 194.02,133.37 192.68,134.71 192.68,135.62 191.92,136.38 191.92,138.2 187.33,142.79 187.33,149.45 v1(186.33,150.45) 182.38,154.4 174.42,154.4 170.92,157.91 147.04,157.91 145.89,156.75 136.18,156.75 135.52,156.09 v1(132.07,156.09) ; v1(251.23,96.57) 250.8,97 246.39,97 244.93,98.47 243.82,98.47 243.1,99.19 240.71,99.19 238.33,101.58 229.28,101.58 v1(227.32,99.61)
  BOTTOM w0.114: v1(177.16,84.15) 176.7,83.69 173.25,83.69 168.02,78.46 162.04,78.46 161.11,77.53 129.67,77.53 128.13,76 110.32,76 107.62,73.3 103.28,73.3 101.63,74.95 95.89,74.95 94.64,76.21 88.22,76.21 81.72,82.71 v1(79.99,82.71) ; JWLBT.52 256.2,156.24 256.07,156.37 252.84,156.37 252.7,156.23 JWLBT.66 252.7,154.45 251.95,153.7 251.95,151.9 251.55,151.51 250.03,151.51 247.83,153.7 238.19,153.7 230.08,145.59 207,145.59 202.95,149.64 187.14,149.64 v1(186.33,150.45)
PLTRST_NEAR#: length 202.3
  TOP w0.114: v1(79.99,81.95) 81.39,83.34 81.39,94.76 80.27,95.88 80.27,102.21 81.39,103.32 81.39,109.75 79.84,111.3 74.92,111.3 72.8,113.42 72.8,114.63 73.19,115.03 74.74,115.03 75.42,115.71 75.42,116.44 CC102.1 RC348.2
  BOTTOM w0.114: v1(79.99,81.95) 82.14,81.95 88.12,75.97 94.54,75.97 95.79,74.71 101.53,74.71 103.18,73.06 107.92,73.06 v4(110.42,75.55) 110.62,75.76 140.07,75.76 141.61,77.29 161.21,77.29 162.14,78.22 168.12,78.22 173.19,83.29 176.98,83.29 178.71,85.02 181.57,85.02 187.39,90.84 187.39,97.2 194.96,104.77 194.96,108.27 195.83,109.14 195.83,111.87 197.16,113.2 198.35,113.2 199.51,114.36 199.51,116.15 200.68,117.32 202.91,117.32 203.82,116.42 USROM1.3
PM_SLP_A#: length 135.6
  TOP w0.114: v1(186.81,121.54) 190.96,121.54 191.33,121.17 UE1.76 194.77,121.17 195.06,121.46 200.7,121.46 201.52,122.27 TP128.1
  IN3 w0.076: v2(116.09,127.55) 116.66,128.11 118.78,128.11 119.31,128.64 119.31,129.52
  IN3 w0.114: 119.31,129.52 120.41,130.62 120.41,131.78 123.16,134.53 123.16,135.32 124.06,136.22 124.06,138.81 125.5,140.25 127.22,140.25 129.72,142.74 129.72,143.8 131.45,145.54 131.45,148.88 132.14,149.56 135.53,149.56 140.5,154.53 147.04,154.53 147.6,155.09 152.41,155.09 153.22,154.28 155.96,154.28 157.12,155.43 166.06,155.43 167.71,153.78 170.66,153.78 172.34,152.1 174.73,152.1 181.88,144.96 181.88,143.76 185.21,140.43 185.68,140.43 189.03,137.08 189.03,135.11 191.4,132.74 191.4,126.06 190.89,125.55 187.91,125.55 187.45,125.09 187.45,122.18 v1(186.81,121.54)
  BOTTOM w0.076: UC1.AN16 v2(116.09,127.55)
PM_SLP_S0#: length 1.8
  TOP w0.114: T50.1 117.34,131.21 v2(117.37,131.19)
  BOTTOM w0.076: UC1.AT11 117.37,131.03 v2(117.37,131.19)
PM_SLP_S3#: length 139.2
  TOP w0.114: v4(176.33,122.85) 176.81,122.37 UE1.18 178.74,122.37 178.89,122.52 179.56,122.52 180.52,121.55 181.29,121.55 182.59,120.25 v1(186.84,120.25) ; v1(185.13,141.93) 183,141.93 182.44,141.37 D59.1 D62.1 ; v1(130.12,146.17) 129.58,145.64 TP125.1
  IN3 w0.076: v2(116.73,128.46) 117.27,129 118.75,129 119,129.25
  IN3 w0.114: v1(186.84,120.25) 187,120.25 187.69,120.94 187.69,124.99 188.01,125.31 190.99,125.31 191.64,125.96 191.64,133.07 190,134.7 190,136.45 185.13,141.32 v1(185.13,141.93) 185.02,142.04 184.41,142.04 182.12,144.33 182.12,145.06 174.79,152.38 172.4,152.38 170.76,154.03 167.81,154.03 166.16,155.67 157.02,155.67 155.86,154.52 153.32,154.52 152.51,155.33 147.5,155.33 146.94,154.77 140.4,154.77 135.43,149.8 132.04,149.8 130.6,148.36 130.6,146.65 v1(130.12,146.17) 129.48,145.53 129.48,142.84 127.12,140.49 125.4,140.49 123.82,138.91 123.82,136.27 122.96,135.42 122.96,134.61 120.22,131.87 120.22,130.71 119,129.49 119,129.25
  BOTTOM w0.076: UC1.AP15 v2(116.73,128.46)
PM_SLP_S4#: length 145.8
  TOP w0.114: v1(180.97,120.57) 180.37,120.57 179.67,121.27 178.88,121.27 178.78,121.17 UE1.21 ; D63.1 194.84,136.27 v1(194.89,136.22) ; TP126.1 180.47,136.32 v1(180.98,135.81)
  IN1 w0.14: v1(194.89,136.22) 194.46,136.22 194.23,136.44 190.64,136.44 189.55,137.54 187.1,137.54 186.75,137.88 182.13,137.88 180.98,136.73 v1(180.98,135.81)
  BOTTOM w0.076: UC1.BA16 120.47,127.92 122.64,127.92 122.84,128.12 122.92,128.12
  BOTTOM w0.114: 122.92,128.12 123.49,128.12 125.27,129.91 127.63,129.91 129.03,131.32 130.73,131.32 135.6,136.19 135.6,145.97 135.37,146.2 135.37,150.53 137.84,152.99 137.84,156.43 138.92,157.51 146.96,157.51 148.11,158.65 181.24,158.65 182.38,157.52 182.38,142.77 181.87,142.26 181.87,138.32 180.98,137.43 v1(180.98,135.81) 180.98,124.75 181.48,124.25 181.48,121.08 v1(180.97,120.57)
PM_SLP_S5#: length 136.8
  TOP w0.114: v1(180.84,122.54) 181.1,122.28 181.59,122.28 181.89,121.98 190.86,121.98 191.27,121.57 UE1.77 ; TP127.1 137.13,155.55 v1(138.3,155.55)
  BOTTOM w0.076: 125.11,129.41 125.03,129.41 123.37,127.76 120.88,127.76 120.71,127.59 120.29,127.59 119.98,127.9 UC1.AY16
  BOTTOM w0.114: 125.11,129.41 125.34,129.64 127.69,129.64 129.13,131.08 130.83,131.08 135.84,136.09 135.84,144.8 136.5,145.45 136.5,147.44 135.88,148.06 135.88,150.69 138.3,153.11 v1(138.3,155.55) 138.3,156.54 139.02,157.27 147.06,157.27 148.21,158.41 181.14,158.41 182.13,157.42 182.13,142.87 181.63,142.36 181.63,138.42 180.46,137.25 180.46,135.3 180.73,135.03 180.73,122.64 v1(180.84,122.54)
PM_SMB_CLK: length 272.2
  TOP w0.114: RC106.1 111.56,149.44 110.75,150.25 110.68,150.25 110.02,150.91 108.76,150.91 v1(108.69,150.98) 108.3,150.98 106.34,149.02 QC1.1 ; JCP.11 122.66,63.88 123.35,64.56 124.27,64.56 v1(125.67,65.96)
  IN3 w0.114: v1(195.82,129.99) 195.82,130.85 196.11,131.14 196.11,136.17 193.1,139.19 192.5,139.19 188.86,142.83 188.86,150.4 183.52,155.73 v1(174.61,155.73) 174.33,155.73 171.29,158.77 146.68,158.77 145.53,157.62 135.82,157.62 135.18,156.98 130.7,156.98 130.55,156.83 126.95,156.83 125.74,155.62 119.52,155.62 113.14,149.24 111.69,149.24 109.78,151.15 109.2,151.15 109.04,150.98 v1(108.69,150.98) ; v1(170.27,153.05) 170.27,152.91 169.67,152.31 161.9,152.31 v1(161.16,153.05)
  BOTTOM w0.114: JDIMM2.202 v1(161.16,153.05) ; v1(174.61,155.73) 174.23,155.35 174.23,153.4 173.88,153.05 JDIMM1.202 v1(170.27,153.05) ; v1(125.67,65.96) 128.44,65.96 134.33,71.84 141.68,71.84 143.76,73.93 164.81,73.93 165.11,73.62 167.87,73.62 174.44,80.19 181.24,80.19 191.01,89.97 191.01,96.05 207.32,112.35 207.32,115.6 203.82,119.11 USROM1.6 203.82,121.44 202.3,122.96 199.51,122.96 196.96,125.51 196.96,128.48 195.82,129.62 v1(195.82,129.99)
PM_SMB_DAT: length 271.9
  TOP w0.114: v1(108.74,150.35) RC107.1 107.4,149.64 106.92,149.16 106.92,147.99 107.18,147.72 QC1.4 ; JCP.7 120.66,63.56 120.76,63.66 120.76,64.4 123.4,67.04 v1(124.71,67.04)
  IN3 w0.114: v1(161.92,153.06) 162.19,153.34 166.74,153.34 167.53,152.55 169.15,152.55 v1(169.62,153.02) ; v1(195.78,128.98) 195.31,129.45 195.31,130.68 195.87,131.24 195.87,136.07 193,138.94 192.4,138.94 188.61,142.73 188.61,150.3 183.89,155.03 v1(174.66,155.03) 174.66,155.06 171.19,158.53 146.78,158.53 145.63,157.38 135.92,157.38 135.28,156.73 130.8,156.73 130.65,156.59 127.05,156.59 125.83,155.37 119.6,155.37 113.24,149 111.59,149 109.68,150.91 109.3,150.91 v1(108.74,150.35)
  BOTTOM w0.114: v1(169.62,153.02) 170.18,152.45 JDIMM1.200 173.62,152.45 174.66,153.49 v1(174.66,155.03) ; JDIMM2.200 161.31,152.45 v1(161.92,153.06) ; v1(124.71,67.04) 128.84,67.04 133.88,72.09 141.58,72.09 143.66,74.17 164.91,74.17 165.21,73.86 167.77,73.86 174.34,80.44 181.14,80.44 190.77,90.07 190.77,96.15 207.08,112.45 207.08,115.5 204.31,118.27 203.18,118.27 202.55,118.9 USROM1.5 202.55,121.57 201.41,122.7 199.42,122.7 196.7,125.42 196.7,128.05 v1(195.78,128.98)
PME#: length 19.3
  TOP w0.114: T62.1 128.03,143.86 v1(128.03,143.23)
  IN1 w0.14: v2(118.61,130.32) 118.61,130.35 119.02,130.75 119.02,131.74 121.13,133.86 121.13,135.44 123.51,137.82 123.51,139.63 124.43,140.55 126.09,140.55 128.03,142.49 v1(128.03,143.23)
  BOTTOM w0.114: UC1.AU11 118.3,130.63 v2(118.61,130.32)
PORTB_L: length 1.9
  TOP w0.203: UA1.32 185.63,53.85 184.97,53.19 RA19.1
PORTB_R: length 1.4
  TOP w0.203: RA24.1 186.04,54.59 UA1.33
PP: length 1.5
  TOP w0.114: TP940.1 124.78,160.05 126.27,160.05 UTPM1.4
PROC_POPIRCOMP: length 2.8
  TOP w0.254: v2(118,127.55) 117.54,128 117.1,128 v4(117.07,127.98) 117.03,128.02 116.29,128.02 116.1,128.21 116.1,128.26 116.1,128.27 RC151.2
  BOTTOM w0.254: UC1.AT16 v2(118,127.55)
PS8330_CAD: length 7.1
  TOP w0.114: UM1.8 256.91,143.81 256.24,143.14 256.24,142.22 255.85,141.83 255.85,141.22 255.64,141.02 TP70.1
PS8330_CFG1: length 5.8
  TOP w0.114: RM23.2 262.74,152.36 262.24,151.85 262.24,150.32 262.36,150.2 RM26.1 262.74,149.52 v3(262.47,149.25) 262.4,149.17 UM1.40
PS8330_REXT: length 4.4
  TOP w0.114: UM1.7 257.24,144.31 257.11,144.18 256.67,144.18 v3(256.47,143.97) 255.96,143.46 255.96,142.73 255.63,142.4 RM19.2 RM34.2
PS8330_RST: length 5.8
  TOP w0.114: UM1.35 265.75,146.81 266.31,147.37 RM31.1 CM12.1 267.25,145.97 268.75,145.97 RM20.2
PS8401_CFG: length 3
  TOP w0.114: URE1.23 v1(249.41,86.03)
  BOTTOM w0.114: v1(249.41,86.03) 249.43,86.01 RRE25.1 v4(250.22,84.62)
PS8401_DCIN_EN: length 4.9
  TOP w0.114: v4(242.46,83.64) 242.81,83.29 RRE26.1 242.88,82.66 243.32,83.1 244.82,83.1 245.11,83.39 URE1.13
PS8401_DDCBUF: length 3.3
  TOP w0.114: URE1.14 245.51,84.04 245.4,83.93 245.4,83.3 244.76,82.66 RRE21.2 RRE27.1
PS8401_EQ: length 5.6
  TOP w0.114: v4(248.82,80.56) 248.82,82.43 248.6,82.66 RRE29.1 RRE23.2 247.25,82.79 247.25,83.44 246.71,83.98 URE1.17
PS8401_ISET: length 4.8
  TOP w0.114: RRE24.2 RRE30.1 246.62,92.16 v4(247.01,91.77) 246.71,91.47 URE1.34
PS8401_PRE: length 3.2
  TOP w0.114: RRE22.2 RRE28.1 246.53,82.53 246.53,83.42 v4(246.49,83.46) 246.53,83.5 246.53,83.82 246.31,84.03 URE1.16
PS8713_RX1_C_N: length 116.6
  TOP w0.114: R74.1 210.7,94.17 210.9,94.37 212.45,94.37 212.58,94.24 v1(212.58,94.1)
  IN1 w0.14: v1(212.58,94.1) 212.58,94.25 212.81,94.48 218.87,94.48 219.92,93.43 219.92,92.41 223.78,88.55 225.89,88.55 238.21,76.23 245.85,76.23 246.28,76.66 257.43,76.66 259.54,74.55 262.55,74.55 263.02,75.02 268.11,75.02 270.89,72.23 274.4,72.23 276.46,70.18 276.46,45.55 279.31,42.7 279.31,35.35 279.18,35.23 278.87,35.23 278.74,35.36 v1(278.74,35.54)
  BOTTOM w0.114: L10.4 279.97,35.44 279.63,35.11 279.03,35.11 278.74,35.4 v1(278.74,35.54)
PS8713_RX1_C_P: length 116.5
  TOP w0.114: v1(212.58,94.86) 212.32,94.6 211.08,94.6 210.67,95 R72.1
  IN1 w0.14: v1(278.74,34.78) 278.93,34.97 279.28,34.97 279.56,35.25 279.56,42.81 276.71,45.65 276.71,70.28 274.51,72.49 271,72.49 268.21,75.28 262.92,75.28 262.45,74.8 259.64,74.8 257.53,76.91 246.17,76.91 245.75,76.49 238.31,76.49 225.99,88.81 223.88,88.81 220.17,92.52 220.17,93.53 218.97,94.73 212.72,94.73 v1(212.58,94.86)
  BOTTOM w0.114: v1(278.74,34.78) 278.84,34.88 279.99,34.88 L10.1
PS8713_RX1_N_R: length 35.6
  TOP w0.114: R31.2 200.33,92.99 197.33,92.99 197.08,93.24 197.08,94.75 196.72,95.11 195.97,95.11 195.76,94.9 195.76,93.15 v1(197.55,91.36) 200.62,88.3 210.35,88.3 214.1,92.05 214.1,93.84 213.69,94.25 213.53,94.25 212.8,93.52 211.93,93.52 R32.1
PS8713_RX1_P_R: length 35.6
  TOP w0.114: R29.1 211.97,95.51 212.76,95.51 214.33,93.94 214.33,91.95 210.45,88.07 200.52,88.07 v1(199.13,89.46) 195.54,93.05 195.54,95 195.88,95.34 199.03,95.34 199.51,94.86 200.73,94.86 R28.2
PS8713_RX2_C_N: length 125.9
  TOP w0.114: R76.1 228.58,93.89 228.58,94.27 228.78,94.47 230.28,94.47 230.5,94.25 v1(230.5,94.1)
  IN1 w0.14: v1(230.5,94.1) 230.5,94.23 230.72,94.44 230.97,94.44 231.25,94.16 231.25,86.16 239.63,77.78 245.21,77.78 245.64,78.21 257.63,78.21 258.39,78.97 262.46,78.97 264.86,76.57 268.75,76.57 271.1,74.22 275.01,74.22 278.71,70.51 278.71,46.8 281.03,44.48 281.03,42.54 281.41,42.16 281.41,37.31 281.21,37.1 281.21,30.73 281.03,30.56 281.03,17.29 279.48,15.73 278.98,15.73 278.69,16.02 v1(278.69,16.14)
  BOTTOM w0.114: v1(278.69,16.14) 278.69,16.02 278.84,15.87 279.76,15.87 L13.4
PS8713_RX2_C_P: length 125.9
  TOP w0.114: R46.2 228.63,95.03 228.96,94.7 230.34,94.7 v1(230.5,94.86)
  IN1 w0.14: v1(278.69,15.37) 278.79,15.48 279.58,15.48 281.29,17.18 281.29,30.45 281.46,30.63 281.46,37 281.67,37.2 281.67,42.27 281.29,42.65 281.29,44.58 278.97,46.9 278.97,70.62 275.12,74.47 271.21,74.47 268.86,76.83 264.97,76.83 262.57,79.22 258.29,79.22 257.52,78.46 245.53,78.46 245.1,78.04 239.73,78.04 231.5,86.27 231.5,94.27 231.07,94.7 230.67,94.7 v1(230.5,94.86)
  BOTTOM w0.114: L13.1 279.67,15.64 278.95,15.64 v1(278.69,15.37)
PS8713_RX2_N_R: length 25.6
  TOP w0.114: R48.1 229.9,93.48 230.94,93.48 231.37,93.91 231.37,94.47 231.55,94.65 232.06,94.65 232.37,94.34 232.37,90.84 229.65,88.12 221.08,88.12 v1(219.08,90.12) 218.43,90.77 218.43,91.48 218.73,91.78 219.3,91.78 R47.2
PS8713_RX2_P_R: length 25.5
  TOP w0.114: R34.2 217.99,91.52 218.2,91.31 218.2,90.68 220.99,87.89 229.74,87.89 232.59,90.74 v1(232.59,91.98) 232.59,94.44 232.16,94.88 231.53,94.88 230.89,95.51 229.88,95.51 R46.1
PS_0: length 10.8
  BOTTOM w0.114: UV3.AC19 60.14,149.17 60.54,148.77 62.72,148.77 62.97,149.03 62.97,149.26 63.1,149.38 66.15,149.38 66.58,149.82 CV153.1 RV99.2 RV98.2
PS_1: length 12.4
  BOTTOM w0.114: v4(71.28,152.38) 70.75,152.91 RV102.2 RV103.1 CV155.1 67.89,152.91 66.04,151.04 63.1,151.04 62.85,150.78 62.39,150.78 62.14,150.53 62.14,150.07 61.83,149.77 61.51,149.77 UV3.AD19
PS_2: length 12.1
  BOTTOM w0.114: v4(72.26,153.82) 72.19,153.75 RV100.2 RV101.1 CV154.1 67.41,153.75 65.43,151.77 63.17,151.77 62.95,151.55 62.95,151.34 62.73,151.12 62.35,151.12 61.74,150.51 UV3.AE17
PS_3: length 8.9
  BOTTOM w0.114: RV104.2 RV105.1 CV156.1 67.97,149 67.92,148.95 66.94,148.95 66.55,148.57 63.08,148.57 62.95,148.44 62.19,148.44 UV3.AE20
PSYS: length 191.5
  IN1 w0.254: v1(69.22,64.57) 69.34,64.69 70.15,64.69 71.11,63.72 79.49,63.72 83.8,68.03 v1(83.8,76.38)
  BOTTOM w0.203: PR413.2 69.45,64.93 69.45,64.8 v1(69.22,64.57) 69.22,64.5 68.47,63.75 68.32,63.75 67.93,63.36 67.93,63.02 67.04,62.14 66.5,62.14 65.86,61.49 PU401.46
  BOTTOM w0.254: PR124.1 212.79,110.28 PC127.2 212.73,110.34 211.87,110.34 210.8,111.41 208.26,111.41 192.34,95.5 192.34,89.42 181.79,78.87 174.99,78.87 168.42,72.3 163.53,72.3 163.25,72.02 148.16,72.02 146.09,69.95 134.33,69.95 v4(134.13,69.74) 128.95,64.56 105.37,64.56 101.9,68.03 101.9,71.44 100.63,72.7 95.06,72.7 93.73,74.03 87.32,74.03 84.97,76.38 v1(83.8,76.38)
PWM1_2PH: length 21.7
  TOP w0.254: PU403.2 83.29,49.86 82.76,49.33 v1(82.58,49.33)
  IN3 w0.254: v1(82.58,49.33) 82.07,49.33 81.87,49.13 70.75,49.13 v1(67.21,52.66)
  BOTTOM w0.203: v1(67.21,52.66) 65.46,54.42 PU401.16
PWM_1A: length 23.1
  TOP w0.254: v1(63.58,52.74) 63.48,52.74 61.51,54.71 v4(61.51,57.97) 61.51,59.6 65.69,63.78 v1(65.69,69.45)
  BOTTOM w0.203: PU401.22 63.06,53.26 v1(63.58,52.74)
  BOTTOM w0.254: PU402.2 65.45,69.7 v1(65.69,69.45)
PWM_1B: length 56.8
  IN2 w0.254: v1(77.2,100.13) 76.84,100.49 76.44,100.49 75.93,99.98 75.93,99.77 74.74,98.58 67.16,98.58 65.51,96.93 65.51,91.36 59.92,85.77 59.43,82.34 58.16,77.52 58.16,72.34 58.82,71.68 58.82,70.67 61.55,67.93 61.55,67.32 61.12,66.89 61.12,63.84 60.29,63.01 60.29,60.93 v1(60.69,60.54)
  BOTTOM w0.203: v1(77.2,100.13) 77.2,100.16 76.96,100.4 PU404.2
  BOTTOM w0.229: PU401.36 61.09,60.36
  BOTTOM w0.254: 61.09,60.36 60.87,60.36 v1(60.69,60.54)
PWROK: length 42.3
  TOP w0.114: RC41.2 143.66,128.56 v1(143.77,128.45) 143.74,128.43 143.74,124.41 143.01,123.68 138.86,123.68 138.3,123.13 138.3,122.54 139.26,121.59 139.26,119.43 137.61,117.78 CC528.2 RC403.2
  BOTTOM w0.076: UC1.BA20 121.03,125.83 121.57,125.83 121.92,126.18 122.52,126.18 123.04,126.69 124.15,126.69 124.52,127.07
  BOTTOM w0.114: v1(143.77,128.45) 143.03,127.71 143.01,127.71 142.37,127.07 124.52,127.07
Q27_G: length 3.6
  TOP w0.114: Q29.2 118.33,156.87 R9456.1 v4(117.37,156.31)
REMOTE1+: length 211.6
  TOP w0.254: U1.2 40.6,125.65 C2.1 39.05,126.78 38.67,127.16 37.87,127.16 37.32,126.61 37.32,126.12 v1(37.24,126.04) ; v1(110.38,68.83) 110.38,69.24 123.72,82.58 146.41,82.58 147.81,83.98 156.95,83.98 159.49,86.52 162.84,86.52 164.7,88.38 164.7,89.61 160.9,93.41 160.9,106.5 163.23,108.82 163.23,110.17 C4.1 163.23,110.57 163.23,111.06 Q1.2 163.48,112.1 Q1.1
  IN3 w0.254: v1(37.24,126.04) 37.07,125.86 37.07,124.92 37.87,124.11 41.64,124.11 55.86,109.89 58.15,109.89 59.42,111.16 60.95,111.16 63.87,114.08 66.52,114.08 66.88,113.72 69.56,113.72 70.7,112.58 74.63,112.58 74.68,112.63 77.96,112.63 78.91,113.58 79.97,113.58 86.39,107.16 86.39,105.7 87.09,105 87.93,105 88.35,104.58 88.35,83.35 96.12,75.58 101.03,75.58 107.58,69.03 110.18,69.03 v1(110.38,68.83)
REMOTE1-: length 209
  TOP w0.254: v1(37.93,126.04) 37.83,126.14 37.83,126.4 38.08,126.65 38.46,126.65 39.25,125.86 C2.2 39.67,125.86 40.38,125.15 U1.3 ; Q1.3 163.74,111.06 163.74,110.57 C4.2 163.74,110.17 163.74,108.61 161.41,106.29 161.41,93.62 165.21,89.82 165.21,88.17 163.05,86.01 159.7,86.01 157.16,83.47 148.02,83.47 146.62,82.07 123.93,82.07 111.52,69.66 v1(111.52,68.83)
  IN3 w0.254: v1(111.52,68.83) 110.81,69.54 107.79,69.54 101.24,76.09 96.33,76.09 88.86,83.56 88.86,104.79 88.14,105.51 87.3,105.51 86.9,105.91 86.9,107.37 80.18,114.09 78.7,114.09 77.75,113.14 74.47,113.14 74.42,113.09 70.91,113.09 69.77,114.23 67.09,114.23 66.73,114.59 63.66,114.59 60.74,111.67 59.21,111.67 57.94,110.4 56.07,110.4 41.85,124.62 38.08,124.62 37.57,125.13 37.57,125.64 37.93,125.99 v1(37.93,126.04)
REMOTE2+: length 49.7
  TOP w0.254: Q2.1 2.27,132.87 1.76,132.37 1.76,131.22 2.01,130.97 Q2.2 2.67,131.26 2.67,131.62 3.14,132.1 4.54,132.1 C5.1 5.06,132.11 5.82,132.11 7.22,133.51 v1(9.87,133.51) 11.92,133.51 13.19,132.24 13.19,128.81 13.82,128.18 33.16,128.18 35.83,125.51 37,125.51 38.01,124.49 39.61,124.49 C3.1 39.95,124.65 U1.4
REMOTE2-: length 46.2
  TOP w0.254: U1.5 40.18,124.15 C3.2 39.58,124.11 37.86,124.11 36.84,125.13 35.67,125.13 33,127.79 13.67,127.79 12.81,128.65 12.81,132.08 11.76,133.13 v1(8.16,133.13) 7.38,133.13 5.98,131.73 5.09,131.73 C5.2 4.54,131.72 3.3,131.72 3.05,131.46 3.05,131.2 3.28,130.97 Q2.3
RF_OFF#: length 181.6
  TOP w0.114: RC371.2 126.38,152.98 v1(127.13,152.23)
  IN1 w0.14: v1(127.13,152.23) 125.48,150.58 125.48,147.67 124.32,146.51 124.32,142.05 122.6,140.33 122.6,137.84 120.49,135.73 120.49,133.97 119.07,132.56 116.53,132.56 v2(116.09,132.12)
  BOTTOM w0.076: v2(116.09,132.12) 115.7,132.51 UC1.AN8
  BOTTOM w0.114: JWLBT.56 255.2,154.41 255,154.21 255,151.69 254.57,151.26 249.94,151.26 247.73,153.46 238.29,153.46 230.18,145.35 206.22,145.35 v4(204.72,146.86) 202.17,149.4 186.4,149.4 185.03,150.77 185.03,158.64 180.36,163.31 168.57,163.31 167.53,162.27 164,162.27 163.05,161.32 147,161.32 146.49,160.81 138.42,160.81 134.28,156.67 134.28,155.75 130.41,151.88 127.48,151.88 v1(127.13,152.23)
RJ45_ACTIVITY#: length 44.7
  TOP w0.114: UL1.27 255.64,96.38 255.86,96.6 v1(255.86,96.81)
  IN1 w0.14: JRJ451.12 287.28,84.59 285.87,86 285.87,93.49 280.33,99.03 260.01,99.03 258.43,97.44 256.52,97.44 255.89,96.81 v1(255.86,96.81)
RJ45_GND:
  vias: v4(279.09,82.82)
RJ45_LINKUP#: length 55.8
  TOP w0.114: v1(257.19,96.78) 256.49,96.78 256.04,96.32 UL1.26
  IN1 w0.14: v1(257.19,96.78) 257.59,97.17 258.54,97.17 260.12,98.76 280.22,98.76 285.6,93.37 285.6,84.87 286.01,84.46 286.01,74.4 JRJ451.10
RJ45_TXD0N: length 28.5
  IN3 w0.114: JRJ451.2 287.6,81.87 287.6,82.34 287.44,82.5 286.32,82.5 285.76,83.07 281.67,83.07 280.32,84.41 265.33,84.41 264.49,83.57 264.49,83.12 264.79,82.82 v1(265.17,82.82)
  BOTTOM w0.114: TL1.23 265.2,83.63 264.76,83.2 264.76,83 264.94,82.82 v1(265.17,82.82)
RJ45_TXD0P: length 28.5
  IN3 w0.114: JRJ451.1 287.82,82.57 287.57,82.82 286.45,82.82 285.89,83.38 281.8,83.38 280.45,84.73 265.2,84.73 264.18,83.7 264.18,83.13 v1(263.9,82.85)
  BOTTOM w0.114: TL1.24 263.93,83.64 264.34,83.22 264.34,83.02 264.17,82.85 v1(263.9,82.85)
RJ45_TXD1N: length 27.5
  IN3 w0.114: v1(270.32,82.86) 270.12,82.86 269.91,83.06 269.91,83.31 270.08,83.47 279.86,83.47 283.44,79.89 284.24,79.89 284.54,80.19 284.54,82.01 284.65,82.13 285.04,82.13 285.16,82.01 285.16,80.19 285.46,79.89 286.19,79.89 286.4,79.67 286.4,78.35 JRJ451.6
  BOTTOM w0.114: TL1.19 270.28,83.65 269.84,83.21 269.84,82.98 269.96,82.86 v1(270.32,82.86)
RJ45_TXD1P: length 27.5
  IN3 w0.114: JRJ451.3 287,80.53 286.68,80.21 285.59,80.21 285.48,80.32 285.48,82.14 285.18,82.44 284.52,82.44 284.22,82.14 284.22,80.32 284.1,80.21 283.58,80.21 279.99,83.79 269.94,83.79 269.6,83.44 269.6,83.06 269.39,82.85 v1(269.03,82.85)
  BOTTOM w0.114: v1(269.03,82.85) 269.24,82.85 269.42,83.03 269.42,83.21 269.01,83.63 TL1.20
RJ45_TXD2N: length 28.2
  IN3 w0.114: v1(272.52,82.84) 272.34,82.84 272.17,82.66 272.17,82.46 273.88,80.75 277.69,80.75 278.2,80.25 278.2,79.82 277.79,79.42 277.79,79.26 278.07,78.98 278.23,78.98 278.64,79.38 279.06,79.38 279.53,78.92 279.53,78.49 279.12,78.09 279.12,77.93 279.4,77.65 279.57,77.65 279.97,78.05 280.39,78.05 280.86,77.59 280.86,77.16 280.45,76.76 280.45,76.6 280.73,76.32 280.9,76.32 281.3,76.72 281.72,76.72 282.25,76.2 282.87,76.2 283.27,75.8 283.27,75.42 v1(283.59,75.1)
  BOTTOM w0.114: TL1.17 272.82,83.67 272.37,83.22 272.37,82.99 v1(272.52,82.84) ; v1(283.59,75.1) 283.57,75.1 283.41,75.26 283.41,75.57 286.08,78.25 287.3,78.25 287.54,78.49 JRJ451.5
RJ45_TXD2P: length 28.2
  IN3 w0.114: v1(271.76,82.84) 271.85,82.75 271.85,82.33 273.74,80.43 277.56,80.43 277.88,80.11 277.88,79.95 277.48,79.55 277.48,79.13 277.94,78.66 278.37,78.66 278.77,79.06 278.93,79.06 279.21,78.78 279.21,78.62 278.81,78.22 278.81,77.8 279.27,77.33 279.7,77.33 280.1,77.73 280.26,77.73 280.54,77.45 280.54,77.29 280.14,76.89 280.14,76.47 280.6,76 281.03,76 281.43,76.4 281.59,76.4 282.11,75.88 282.74,75.88 282.95,75.67 282.95,75.23 v1(282.8,75.08)
  BOTTOM w0.114: v1(271.76,82.84) 271.95,83.02 271.95,83.29 271.55,83.69 TL1.18 ; v1(282.8,75.08) 282.99,75.27 282.99,75.75 285.91,78.67 287.13,78.67 287.28,78.82 JRJ451.4
RJ45_TXD3N: length 27.5
  IN3 w0.114: v1(277.65,82.84) 277.53,82.84 277.36,82.67 277.36,82.42 277.69,82.09 279.97,82.09 280.42,81.63 280.42,81.21 279.57,80.36 279.57,80.2 279.85,79.92 280.01,79.92 280.86,80.77 281.29,80.77 281.75,80.3 281.75,79.88 280.9,79.03 280.9,78.87 281.18,78.59 281.34,78.59 282.19,79.44 282.62,79.44 283.08,78.97 283.08,78.55 282.23,77.7 282.23,77.54 282.51,77.26 282.67,77.26 283.52,78.11 283.95,78.11 285.16,76.9 285.16,75.1 285.28,74.98 v1(285.46,74.98)
  BOTTOM w0.114: TL1.13 277.9,83.72 277.48,83.3 277.48,83.01 v1(277.65,82.84) ; v1(285.46,74.98) 285.33,74.98 285.08,75.23 285.08,75.68 285.66,76.26 287.53,76.26 287.67,76.12 287.67,75.82 JRJ451.8
RJ45_TXD3P: length 27.4
  IN3 w0.114: v1(276.94,82.84) 277.04,82.74 277.04,82.29 277.56,81.77 279.84,81.77 280.11,81.5 280.11,81.34 279.26,80.49 279.26,80.07 279.72,79.6 280.15,79.6 281,80.45 281.16,80.45 281.44,80.17 281.44,80.01 280.59,79.16 280.59,78.74 281.05,78.27 281.48,78.27 282.33,79.12 282.49,79.12 282.77,78.84 282.77,78.68 281.92,77.83 281.92,77.4 282.38,76.94 282.81,76.94 283.66,77.79 283.82,77.79 284.84,76.77 284.84,75.19 v1(284.66,75.01)
  BOTTOM w0.114: v1(276.94,82.84) 277.06,82.95 277.06,83.27 276.63,83.7 TL1.14 ; JRJ451.7 287.94,76.45 287.71,76.68 285.49,76.68 284.66,75.85 v1(284.66,75.01)
S3_1.35V: length 4.8
  TOP w0.229: PU301.7 182.76,169.86
  TOP w0.254: PR311.1 PR310.1 184.33,167.72 PC318.1 184.16,168.59 183.63,169.11 183.25,169.11 v4(183.23,169.13) 183.18,169.18 183.18,169.45 182.76,169.86
S5_1.35V: length 4.1
  TOP w0.229: 182.68,170.26 PU301.8
  TOP w0.254: PC319.1 184.23,170.26 182.68,170.26 ; PC319.1 PR312.2 ; PC319.1 PR313.2
SA_CLK_DDR0: length 64.2
  IN1 w0.076: 119.23,105.93 119.21,105.93 119.19,105.95 118.43,105.95 118.25,106.13 118.25,106.26 v2(118,106.52)
  IN1 w0.114: 119.23,105.93 121.53,105.93 122.89,107.3 122.89,108.11 124.11,109.33 130.45,109.33 130.69,109.08 132.12,109.08 132.63,108.57 139.34,108.57 151.89,121.12 157.53,121.12 159.25,122.84 165.09,122.84 165.5,123.25 167.28,123.25 167.49,123.03 167.49,122.82 167.41,122.73 v1(167.13,122.73)
  BOTTOM w0.076: UC1.AT53 v2(118,106.52)
  BOTTOM w0.114: v1(167.13,122.73) 167.3,122.73 167.46,122.89 167.46,123.06 167.22,123.3 165.44,123.3 165.11,122.97 164.92,122.97 164.71,122.75 JDIMM1.101
SA_CLK_DDR1: length 64.1
  IN1 w0.076: 119.27,105.02 119.25,105.02 119.23,105.04 118.4,105.04 118.23,105.21 118.23,105.37 v2(118,105.6)
  IN1 w0.114: v1(169.47,122.35) 169.2,122.08 169.2,121.83 168.83,121.46 167.31,121.46 166.69,122.08 159.52,122.08 157.27,119.84 151.63,119.84 139.64,107.85 132.19,107.85 131.81,108.24 124.59,108.24 123.69,107.33 123.69,106.71 122,105.02 119.27,105.02
  BOTTOM w0.076: UC1.AT55 v2(118,105.6)
  BOTTOM w0.114: JDIMM1.102 170.6,123.05 170.5,123.15 169.57,123.15 169.25,122.82 169.25,122.57 v1(169.47,122.35)
SA_CLK_DDR#0: length 64.2
  IN1 w0.076: v2(118.63,106.52) 118.42,106.3 118.42,106.19 118.49,106.12 119.19,106.12 119.21,106.14 119.23,106.14
  IN1 w0.114: v1(167.92,122.73) 167.7,122.96 167.7,123.12 167.36,123.45 165.41,123.45 165.01,123.04 159.17,123.04 157.45,121.33 151.81,121.33 139.26,108.78 132.71,108.78 132.2,109.29 130.78,109.29 130.54,109.53 124.02,109.53 122.69,108.19 122.69,107.38 121.45,106.14 119.23,106.14
  BOTTOM w0.076: UC1.AU53 v2(118.63,106.52)
  BOTTOM w0.114: JDIMM1.103 164.71,123.35 164.86,123.2 165.01,123.2 165.34,123.53 167.32,123.53 167.69,123.15 167.69,122.96 v1(167.92,122.73)
SA_CLK_DDR#1: length 64.1
  IN1 w0.076: v2(118.63,105.6) 118.4,105.37 118.4,105.28 118.47,105.21 119.23,105.21 119.25,105.22 119.27,105.22
  IN1 w0.114: 119.27,105.22 121.91,105.22 123.49,106.8 123.49,107.42 124.51,108.44 131.89,108.44 132.28,108.05 139.56,108.05 151.54,120.04 157.19,120.04 159.43,122.29 166.78,122.29 167.4,121.67 168.75,121.67 168.99,121.91 168.99,122.06 v1(168.71,122.35)
  BOTTOM w0.076: UC1.AU55 v2(118.63,105.6)
  BOTTOM w0.114: JDIMM1.104 170.6,123.65 170.32,123.37 169.48,123.37 169.02,122.92 169.02,122.46 168.9,122.35 v1(168.71,122.35)
SA_DIMM_VREFDQ: length 65.8
  TOP w0.508: v2(120.89,98.25) 121.4,98.76 122.97,98.76 124.01,97.72 129.17,97.72 v4(131.18,95.7) 133.7,95.7 140.73,88.67 140.73,87.42 139.95,86.63 133.65,86.63 132.53,85.52 132.53,84.55 133.18,83.9 146.29,83.9 147.35,84.97 156.67,84.97 158.86,87.15 CD2.1 158.91,88.04 RD2.1
  BOTTOM w0.076: UC1.AY68 v2(120.89,98.25)
SATA_PRX_C_DTX_N0: length 5
  BOTTOM w0.114: JHDD.5 230.65,76.92 231.19,77.47 231.19,78.46 230.85,78.79 230.85,79.65 C26.2
SATA_PRX_C_DTX_P0: length 4.9
  BOTTOM w0.114: C27.2 231.08,79.85 231.08,78.89 231.42,78.55 231.42,77.36 231.92,76.86 JHDD.6
SATA_PRX_DTX_N0: length 208.4
  IN1 w0.076: 100.37,125.14 100.39,125.14 100.44,125.19 101.3,125.19 101.81,125.69 v2(101.95,125.69)
  IN1 w0.14: 100.37,125.14 99.95,125.14 99.68,124.87 94.22,124.87 92.44,123.09 92.44,120.92 87.57,116.06 87.57,114.55 90.23,111.89 90.23,105.56 93.17,102.62 93.17,100.46 92.31,99.6 92.31,87.92 94.33,85.9 101.69,85.9 103.23,84.36 103.65,84.36 105.87,82.15 106.7,82.15 113,75.85 135.49,75.85 137.31,74.03 139.53,74.03 141.17,75.67 161.93,75.67 164.48,73.12 174.44,73.12 176.78,75.46 176.78,77.87 176.59,78.06 v1(176.43,78.06)
  BOTTOM w0.076: UC1.F20 102.16,125.91 v2(101.95,125.69)
  BOTTOM w0.114: C26.1 230.64,81.06 230.85,81.28 230.85,81.86 230.3,82.42 v1(229.6,82.42) 223.14,82.42 218.46,77.75 213.91,77.75 212.34,79.32 207.66,79.32 203.71,75.37 193.07,75.37 191.68,76.77 177.22,76.77 176.8,77.18 176.8,77.85 176.59,78.06 v1(176.43,78.06)
SATA_PRX_DTX_P0: length 208.5
  IN1 w0.076: v2(101.31,125.69) 101.31,125.69 101.31,125.43 101.24,125.35 100.44,125.35 100.39,125.4 100.37,125.4
  IN1 w0.14: v1(177.19,78.06) 177.04,77.91 177.04,75.36 174.55,72.87 164.38,72.87 161.83,75.42 141.28,75.42 139.64,73.78 137.21,73.78 135.39,75.6 112.89,75.6 106.6,81.89 105.76,81.89 103.55,84.11 103.13,84.11 101.59,85.64 94.22,85.64 92.06,87.81 92.06,99.71 92.92,100.57 92.92,102.51 89.97,105.46 89.97,111.79 87.32,114.44 87.32,116.16 92.18,121.03 92.18,123.19 94.12,125.13 99.57,125.13 99.84,125.4 100.37,125.4
  BOTTOM w0.076: v2(101.31,125.69) 101.51,125.89 UC1.E20
  BOTTOM w0.114: C27.1 231.08,81.35 231.08,81.96 230.39,82.65 223.04,82.65 218.37,77.98 214.01,77.98 212.44,79.55 207.57,79.55 203.61,75.6 193.17,75.6 191.77,76.99 177.31,76.99 177.03,77.28 177.03,77.9 v1(177.19,78.06)
SATA_PTX_C_DRX_N0: length 4.8
  BOTTOM w0.114: C25.2 227.6,79.8 227.6,77.41 228.11,76.91 JHDD.3
SATA_PTX_C_DRX_P0: length 4.9
  BOTTOM w0.114: JHDD.2 226.84,76.9 227.37,77.44 227.37,79.7 C24.2
SATA_PTX_DRX_N0: length 194.2
  IN1 w0.14: v1(95.14,124.31) 95.25,124.2 95.25,124 93.07,121.83 93.07,120.3 90.97,118.2 90.97,114.23 90.75,114.01 90.75,105.78 94.54,101.99 94.54,97.74 93.58,96.78 93.58,94.4 95.14,92.84 98.59,92.84 101.33,90.11 101.33,87.2 103.49,85.04 103.73,85.04 106.09,82.67 106.92,82.67 113.2,76.39 135.72,76.39 137.52,74.58 139.35,74.58 140.98,76.21 162.38,76.21 164.92,73.67 174.25,73.67 175.79,75.2 175.79,76.38 175.44,76.72 175.11,76.72 v1(174.94,76.89)
  BOTTOM w0.076: UC1.B21 99.31,125.11 99.31,125.21 99.09,125.44 98.37,125.44 98.16,125.23 97.02,125.23 96.74,124.95 95.66,124.95 95.41,124.7 95.41,124.57 v1(95.14,124.31)
  BOTTOM w0.114: C25.1 227.7,81.3 227.7,81.5 227.41,81.8 223.41,81.8 218.74,77.13 213.46,77.13 211.89,78.7 207.92,78.7 203.93,74.71 192.84,74.71 191.6,75.94 176.47,75.94 175.7,76.71 175.12,76.71 v1(174.94,76.89)
SATA_PTX_DRX_P0: length 194.2
  IN1 w0.14: v1(174.94,76.07) 174.94,76.31 175.1,76.47 175.34,76.47 175.53,76.27 175.53,75.31 174.14,73.92 165.03,73.92 162.49,76.47 140.87,76.47 139.24,74.84 137.63,74.84 135.82,76.64 113.3,76.64 107.02,82.92 106.2,82.92 103.83,85.29 103.6,85.29 101.58,87.3 101.58,90.21 98.7,93.1 95.25,93.1 93.83,94.51 93.83,96.68 94.79,97.64 94.79,102.1 91,105.89 91,113.9 91.22,114.12 91.22,118.09 93.33,120.2 93.33,121.72 95.57,123.97 95.57,124.17 95.71,124.31 v1(96.03,124.31)
  BOTTOM w0.076: v1(96.03,124.31) 95.85,124.13 95.67,124.13 95.57,124.23 95.57,124.63 95.73,124.78 96.81,124.78 97.09,125.07 98.23,125.07 98.44,125.27 99.02,125.27 99.14,125.15 99.14,124.92 99.05,124.82 98.94,124.82 UC1.A21
  BOTTOM w0.114: v1(174.94,76.07) 174.94,76.32 175.11,76.48 175.61,76.48 176.38,75.71 191.51,75.71 192.74,74.48 204.02,74.48 208.01,78.47 211.8,78.47 213.37,76.9 218.83,76.9 223.51,81.57 227.31,81.57 227.48,81.41 227.48,81.25 227.28,81.06 C24.1
SB_CLK_DDR0: length 53
  IN3 w0.076: 120.14,110.6 120.12,110.6 120.1,110.62 119.88,110.62 119.02,111.48 116.72,111.48 116.64,111.4 116.64,111.17 v2(116.73,111.09)
  IN3 w0.114: 120.14,110.6 120.69,110.6 120.93,110.83 120.93,112.62 121.04,112.73 121.44,112.73 121.55,112.62 121.55,111.41 121.78,111.18 122.06,111.18 123.12,110.12 130.81,110.12 131.69,109.24 136.32,109.24 150.36,123.28 153.03,123.28 153.44,123.68 153.44,123.83 v1(153.69,124.08)
  BOTTOM w0.076: UC1.AP45 v2(116.73,111.09)
  BOTTOM w0.114: JDIMM2.101 151.51,122.75 151.63,122.87 153.17,122.87 153.47,123.17 153.47,123.87 v1(153.69,124.08)
SB_CLK_DDR1: length 52.2
  IN3 w0.076: v2(116.73,110.17) 116.63,110.27 116.63,110.38 116.82,110.56 118.65,110.56 118.67,110.54 118.72,110.54 118.74,110.52 118.75,110.52
  IN3 w0.114: 118.75,110.52 118.99,110.52 119.68,109.84 121.21,109.84 121.51,109.53 130.56,109.53 131.57,108.52 136.62,108.52 150.66,122.56 153.85,122.56 155.02,123.73 155.02,124.26 155.35,124.59 155.8,124.59 155.99,124.41 155.99,124.14 155.86,124.01 v1(155.67,124.01)
  BOTTOM w0.076: UC1.AP46 v2(116.73,110.17)
  BOTTOM w0.114: v1(155.67,124.01) 155.83,124.01 156.04,123.81 156.04,123.56 156.3,123.3 157.15,123.3 157.4,123.05 JDIMM2.102
SB_CLK_DDR#0: length 53
  IN3 w0.076: v2(116.09,111.09) 116.65,111.65 119.08,111.65 119.95,110.79 120.11,110.79 120.12,110.8 120.14,110.8
  IN3 w0.114: 120.14,110.8 120.61,110.8 120.72,110.91 120.72,112.7 120.96,112.94 121.52,112.94 121.75,112.7 121.75,111.5 121.87,111.38 122.14,111.38 123.2,110.32 130.89,110.32 131.77,109.44 136.24,109.44 150.28,123.48 152.95,123.48 153.23,123.77 153.23,123.93 153.08,124.08 v1(152.95,124.08)
  BOTTOM w0.076: UC1.AN45 v2(116.09,111.09)
  BOTTOM w0.114: JDIMM2.103 151.51,123.35 151.76,123.1 153.07,123.1 153.25,123.27 153.25,123.97 153.13,124.08 v1(152.95,124.08)
SB_CLK_DDR#1: length 52.2
  IN3 w0.076: 118.75,110.73 116.75,110.73 116.2,110.17 v5(116.09,110.17)
  IN3 w0.114: 118.75,110.73 119.08,110.73 119.77,110.04 121.29,110.04 121.6,109.73 130.64,109.73 131.66,108.72 136.54,108.72 150.58,122.76 153.76,122.76 154.82,123.81 154.82,124.35 155.27,124.8 155.89,124.8 156.19,124.49 156.19,124.23 v1(156.41,124.01)
  BOTTOM w0.076: UC1.AN46 v5(116.09,110.17)
  BOTTOM w0.114: v1(156.41,124.01) 156.27,123.87 156.27,123.65 156.39,123.53 157.28,123.53 157.4,123.65 JDIMM2.104
SB_DIMM_VREFDQ: length 37.6
  TOP w0.508: v1(133.85,85.01) 145.51,85.01 146.79,86.29 RD17.1 CD31.1
  BOTTOM w0.076: UC1.BA67 120.91,98.85 121.06,98.71 121.31,98.58 121.53,98.49 121.53,98.49 121.54,98.49 121.71,98.32 121.71,97.92 122.24,97.39 122.24,95.89 126.31,91.83
  BOTTOM w0.508: 126.31,91.83 127.03,91.83 128.77,90.08 v4(128.77,87.8) 128.77,87.42 131.19,85.01 v1(133.85,85.01)
SCL_CTL: length 4.3
  TOP w0.114: RM21.2 RM24.1 255.34,146.68 RM29.2 256.25,145.96 v4(256.39,145.81) UM1.4
SDA_CTL: length 4.2
  TOP w0.114: RM25.1 RM22.2 RM30.2 255.57,145.31 UM1.5
SERIRQ: length 143.8
  TOP w0.114: v1(127.5,149.78) 126.97,149.25 RPC22.1 127.63,148.94 128.59,149.91 128.59,152 128.95,152.36 128.95,153.74 v4(129.3,154.09) 129.43,154.09 129.49,154.15 129.66,154.15 130.22,153.59 R271.1 ; UE1.5 179.43,127.57 181.05,125.95 183.4,125.95 183.88,126.43 v1(186.16,126.43)
  BOTTOM w0.076: 122.97,131.36 122.97,131.21 122.27,130.51 120.68,130.51 120.57,130.62 UC1.AY11
  BOTTOM w0.114: 122.97,131.36 122.97,132.27 123.91,133.21 125.07,133.21 125.31,132.96 125.94,132.96 128.94,135.96 128.94,146.38 128.07,147.25 128.07,148.12 127.5,148.69 v1(127.5,149.78) 127.5,149.91 129.15,151.56 130.43,151.56 134.52,155.65 134.52,156.57 137.89,159.93 145.96,159.93 147.1,161.08 163.28,161.08 164.23,162.03 167.63,162.03 168.67,163.07 180.26,163.07 184.79,158.54 184.79,150.67 187.95,147.51 187.95,133.46 186.14,131.64 186.14,126.46 v1(186.16,126.43)
SERIRQ_R: length 7.5
  TOP w0.114: UTPM1.18 131.42,158.54 132.58,157.37 132.58,156.64 132.86,156.36 132.86,155.76 v4(132.61,155.51) 132.47,155.37 R261.1 R271.2
SM_DIMM_VREFCA: length 102.7
  TOP w0.508: CD12.1 RD10.2 159.32,131.81 160.03,132.52 v1(160.13,132.52)
  IN3 w0.508: v1(160.13,132.52) 160.13,131.5 159.04,130.41 159.04,126.74 159.43,126.35 159.43,124.28 159.04,123.89 159.04,86.19 v1(160.87,84.36)
  BOTTOM w0.076: UC1.AY67 120.36,99.1 120.58,99.1 120.66,99.13 120.87,99.13 120.98,99.08 121.2,99.08 121.31,99.13 121.55,99.13 121.73,98.96 121.73,98.83 122.07,98.49 122.37,98.49 122.5,98.36 122.5,95.87 125.45,92.91 125.86,92.91 125.97,92.8
  BOTTOM w0.508: 125.97,92.8 127.49,92.8 129.93,90.36 129.93,88.17 v4(130.8,87.3) 131.17,86.93 133.36,86.93 136.81,83.48 157.74,83.48 158.68,84.42 160.81,84.42 v1(160.87,84.36)
SM_PG_CTRL: length 62.1
  TOP w0.254: PR310.2 v1(185.96,167.67) ; v1(194.68,144.06) v4(192.02,141.4) 189.76,139.14 181.96,139.14 181.6,138.78 178.63,138.78 177.06,140.36 175.2,140.36 174.54,139.7 174.54,133.9 QD1.1
  IN3 w0.254: v1(185.96,167.67) 184.78,166.49 184.78,165.78 186.6,163.96 186.6,162.12 188.45,160.27 191.37,160.27 195.78,155.87 195.78,145.16 v1(194.68,144.06)
SM_RCOMP0: length 1.5
  TOP w0.254: v2(117.36,126.63) 117.36,126.15 RC8.1
  BOTTOM w0.254: v2(117.36,126.63) 117.02,127.07 UC1.AR18
SM_RCOMP1: length 1.9
  TOP w0.254: RC9.1 118.59,125.88 118,126.47 v2(118,126.63)
  BOTTOM w0.254: UC1.AT18 117.67,127.07 v2(118,126.63)
SM_RCOMP2: length 1.6
  TOP w0.305: v2(118.63,126.63) 118.63,126.81 119.16,127.34 RC10.1
  BOTTOM w0.254: v2(118.63,126.63) 118.32,127.07 UC1.AU18
SMBCLK: length 51.5
  TOP w0.114: v2(55,158.21) 55,159.36 56.24,160.6 56.24,161.56 57.47,162.78 58.01,162.78 60.43,165.21 v3(60.43,166.48) 60.43,169.04 v1(60.48,169.09) 60.48,169.93 61.22,170.67 RV72.2
  IN1 w0.14: v1(60.48,169.09) 61.14,168.43 64.19,168.43 69.53,163.1 70.72,163.1 74.28,159.55 74.28,159.07 76.72,156.62 77.23,156.62 80.27,153.58 83.52,153.58 v1(83.88,153.22)
  BOTTOM w0.114: QV2.1 85.84,151.56 85.09,150.8 84.19,150.8 83.81,151.18 83.81,153.15 v1(83.88,153.22) ; v2(55,158.21) 55.38,158.6 UV3.U7
SMBDAT: length 46.4
  TOP w0.114: v1(54.96,157.38) 54.99,157.38 55.42,157.8 55.42,158.5 v3(55.31,158.61) 55.31,159.32 56.5,160.51 56.5,161.42 57.58,162.5 58.12,162.5 61.31,165.69 RV73.2 61.5,167.44 61.98,167.93 61.98,168.66 62.09,168.77 62.09,169.23 62.56,169.7 v1(62.7,169.7)
  IN1 w0.14: v1(83.55,154.46) 82.96,153.87 80.35,153.87 77.34,156.89 76.83,156.89 74.54,159.18 74.54,159.66 68.46,165.74 68.46,165.9 65.96,168.4 64.97,168.4 63.66,169.7 v1(62.7,169.7)
  BOTTOM w0.114: UV3.U8 55.38,157.8 v1(54.96,157.38) ; v1(83.55,154.46) 83.55,154.11 83.99,153.67 QV2.4
SPI_CLK: length 45.9
  TOP w0.114: RPC23.7 138.42,134.13 138.88,134.59 138.88,135.48 v1(138.85,135.51) 138.81,135.54 138.81,136.82 135.77,139.86 v4(135.14,139.86) 133.41,139.86 132.92,139.37 131.05,139.37 RC365.1 ; v1(138.67,150.88) 138.6,150.88 133.6,155.88 133.6,158.21 R266.1 ; v1(142.34,135.12) 142.34,134.24 142.1,134 RPC24.7
  BOTTOM w0.114: v1(142.34,135.12) 141.57,135.12 141,134.55 141,134.06 140.46,133.52 139.85,133.52 138.9,134.47 138.9,135.45 v1(138.85,135.51) 138.85,135.51 138.73,135.63 138.73,142.57 139.36,143.2 139.36,146.33 138.73,146.96 138.73,150.82 v1(138.67,150.88)
